# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TX5_C_N: length 13.8
  TOP w0.147: v1(86.45,15.57) 86.52,15.64 C21.1
  10_GND w0.163: v1(86.45,15.57) 86.13,15.25 arc(86.09,15.2) 86.08,15.14 86.08,14.93 arc(86.1,14.84) 86.15,14.77 arc(86.25,14.62) 86.28,14.44 86.28,6.3 arc(86.33,6.09) 86.45,5.91 86.51,5.85 arc(86.61,5.69) 86.65,5.5 U2.A40
PCIE_TX5_C_P: length 13.8
  TOP w0.147: C22.1 85.38,15.64 v1(85.45,15.57)
  10_GND w0.163: v1(85.45,15.57) 85.77,15.25 arc(85.8,15.2) 85.82,15.14 85.82,14.93 arc(85.85,14.74) 85.96,14.58 arc(86,14.52) 86.02,14.44 86.02,6.29 arc(85.98,6.1) 85.88,5.94 85.73,5.79 arc(85.67,5.71) 85.65,5.61 U2.A39
PCIE_TX5_N: length 57
  TOP w0.147: C21.2 86.52,18.97 v1(86.45,19.04) ; v2(125.24,47.84) U1.AK6
  07_SIG3 w0.183: 119.62,42.43 119.49,42.3 arc(119.41,42.18) 119.38,42.03 119.38,41.68 arc(119.37,41.56) 119.34,41.44 119.34,41.44 arc(119.33,41.41) 119.31,41.38 arc(119.17,41.1) 118.97,40.86 113.65,35.54 arc(113.37,35.36) 113.05,35.29 111.64,35.29 arc(111.36,35.24) 111.13,35.08 109.17,33.12 arc(109.11,33.05) 109.06,32.99 arc(108.9,32.68) 108.85,32.34 arc(108.71,31.68) 108.34,31.13 105.72,28.51 arc(105.3,28.23) 104.81,28.13 102.31,28.13 arc(101.76,28.02) 101.3,27.71 98.02,24.43 arc(96.95,23.71) 95.69,23.46 91.68,23.46 arc(91.48,23.42) 91.31,23.31 89.98,21.98 arc(89.9,21.79) 89.98,21.59 90.04,21.53 arc(90.04,21.15) 89.65,21.15 89.59,21.21 arc(89.21,21.21) 89.21,20.82 89.22,20.8 arc(89.22,20.41) 88.84,20.41 88.82,20.43 arc(88.62,20.51) 88.43,20.43 88.18,20.18 arc(87.94,20.02) 87.66,19.96 86.35,19.96 arc(86.16,19.89) 86.08,19.7 86.08,19.53 arc(86.1,19.41) 86.17,19.31 v1(86.45,19.04)
  07_SIG3 w0.237: v2(125.24,47.84) arc(125.09,47.49) 124.74,47.34 124.28,47.34 arc(123.9,47.18) 123.74,46.8 arc(123.6,46.48) 123.28,46.34 arc(123.1,46.31) 122.95,46.2 122.84,46.1 arc(122.76,45.98) 122.74,45.85 122.74,44.73 arc(122.62,44.46) 122.35,44.34 121.2,44.34 arc(120.95,44.26) 120.79,44.06 arc(120.75,43.91) 120.74,43.76 arc(120.72,43.66) 120.66,43.58 120.6,43.51 arc(120.41,43.39) 120.18,43.34 arc(120,43.31) 119.85,43.21 arc(119.83,43.18) 119.81,43.16 arc(119.81,43.16) 119.81,43.16 arc(119.8,43.15) 119.79,43.13 arc(119.79,43.13) 119.79,43.13 arc(119.78,43.11) 119.78,43.1 arc(119.75,43.02) 119.74,42.93 119.74,42.72 arc(119.71,42.56) 119.62,42.43
PCIE_TX5_P: length 57
  TOP w0.147: v1(85.45,19.04) 85.38,18.97 C22.2 ; v2(125.24,48.84) U1.AK7
  07_SIG3 w0.183: v1(85.45,19.04) 85.66,19.25 arc(85.74,19.38) 85.78,19.53 85.78,19.7 arc(85.94,20.1) 86.35,20.27 87.66,20.27 arc(87.82,20.3) 87.96,20.39 91.1,23.53 arc(91.36,23.71) 91.68,23.77 95.69,23.77 arc(96.83,24) 97.8,24.64 101.08,27.92 arc(101.65,28.3) 102.31,28.43 104.81,28.43 arc(105.19,28.51) 105.51,28.72 108.13,31.34 arc(108.43,31.8) 108.54,32.34 arc(108.61,32.77) 108.81,33.17 108.81,33.19 110.92,35.3 arc(111.25,35.52) 111.64,35.6 113.05,35.6 arc(113.26,35.64) 113.43,35.76 118.75,41.08 arc(118.91,41.27) 119.03,41.5 119.03,42 arc(118.98,42.26) 118.84,42.47
  07_SIG3 w0.237: v2(125.24,48.84) 124.91,48.52 arc(124.72,48.39) 124.49,48.34 124.23,48.34 arc(123.88,48.2) 123.74,47.85 123.74,47.79 arc(123.73,47.71) 123.71,47.62 arc(123.53,47.4) 123.26,47.32 123.2,47.32 arc(122.87,47.18) 122.74,46.85 arc(122.59,46.49) 122.22,46.34 arc(121.88,46.2) 121.74,45.85 121.74,45.85 arc(121.7,45.68) 121.61,45.54 121.52,45.45 arc(121.47,45.41) 121.42,45.38 arc(121.34,45.35) 121.26,45.34 121.14,45.34 arc(120.86,45.22) 120.74,44.94 120.74,44.81 arc(120.6,44.48) 120.27,44.34 119.21,44.34 arc(119.03,44.31) 118.88,44.2 arc(118.75,44.01) 118.71,43.79 118.71,42.79 arc(118.74,42.62) 118.84,42.47
PCIE_TX6_C_N: length 12.2
  TOP w0.147: C19.1 90.88,14.04 v1(90.8,13.97)
  10_GND w0.163: v1(90.8,13.97) 90.49,13.66 arc(90.33,13.43) 90.28,13.16 90.28,6.16 arc(90.32,5.98) 90.42,5.82 90.53,5.71 arc(90.62,5.58) 90.65,5.41 U2.A44
PCIE_TX6_C_P: length 12.1
  TOP w0.147: v1(89.8,13.97) 89.73,14.04 C20.1
  10_GND w0.163: U2.A43 89.65,5.5 arc(89.67,5.62) 89.74,5.71 89.87,5.85 arc(89.98,6.01) 90.02,6.2 90.02,13.46 arc(89.96,13.74) v1(89.8,13.97)
PCIE_TX6_N: length 58.7
  TOP w0.147: v1(90.8,17.77) 90.88,17.7 C19.2 ; v2(127.24,47.84) U1.AM6
  05_SIG2 w0.183: v1(90.8,17.77) 90.51,18.06 arc(90.47,18.12) 90.46,18.19 90.46,18.55 arc(90.58,18.85) 90.89,18.98 arc(91.7,19.14) 92.39,19.6 93.3,20.51 arc(93.53,20.61) 93.75,20.51 arc(93.98,20.42) 94.2,20.51 94.27,20.58 arc(94.36,20.81) 94.27,21.03 arc(94.18,21.26) 94.27,21.48 94.6,21.81 arc(94.98,22.06) 95.42,22.15 95.82,22.15 arc(96.41,22.27) 96.91,22.6 97.1,22.79 arc(97.29,22.87) 97.48,22.79 arc(97.61,22.74) 97.74,22.79 98,23.05 arc(98.05,23.18) 98,23.31 arc(97.92,23.5) 98,23.69 98.13,23.82 arc(98.32,23.9) 98.52,23.82 arc(98.71,23.74) 98.9,23.82 99.03,23.95 arc(99.11,24.15) 99.03,24.34 arc(98.95,24.53) 99.03,24.73 100.55,26.25 arc(101.37,26.79) 102.34,26.99 104.93,26.99 arc(105.93,27.18) 106.77,27.75 arc(107.44,28.2) 108.24,28.36 112.73,28.36 arc(114.03,28.61) 115.13,29.35 116.85,31.07 arc(117.01,31.31) 117.07,31.59 arc(117.11,31.78) 117.22,31.95 117.44,32.17 arc(117.78,32.39) 118.17,32.47 118.3,32.47 118.3,32.48 arc(119.45,32.74) 120.43,33.41 121.26,34.24 arc(121.51,34.61) 121.6,35.06 121.6,37.35 arc(121.78,38.24) 122.28,39 122.98,39.7 arc(123.27,40.13) 123.37,40.64 123.37,40.9 arc(123.37,40.91) 123.37,40.93 arc(123.39,41.08) 123.48,41.2
  05_SIG2 w0.237: 123.48,41.2 123.6,41.32 arc(123.7,41.48) 123.74,41.66 123.74,45.85 arc(123.88,46.2) 124.23,46.34 125.46,46.34 arc(125.66,46.42) 125.74,46.62 125.74,46.85 arc(125.88,47.2) 126.23,47.34 arc(126.42,47.38) 126.58,47.49 126.89,47.8 arc(126.94,47.83) 127,47.84 v2(127.24,47.84)
PCIE_TX6_P: length 58.9
  TOP w0.147: v2(127.24,48.84) U1.AM7 ; v1(89.8,17.77) 89.73,17.7 C20.2
  05_SIG2 w0.183: v1(89.8,17.77) 90.1,18.06 arc(90.14,18.12) 90.15,18.19 90.15,18.55 arc(90.37,19.07) 90.89,19.28 arc(91.58,19.42) 92.17,19.82 94.38,22.03 arc(94.86,22.34) 95.42,22.46 95.82,22.46 arc(96.29,22.55) 96.69,22.82 100.34,26.46 arc(101.26,27.07) 102.34,27.29 104.93,27.29 arc(105.81,27.47) 106.55,27.96 arc(107.33,28.48) 108.24,28.66 112.73,28.66 arc(113.91,28.89) 114.91,29.56 116.64,31.29 arc(116.73,31.43) 116.76,31.59 arc(116.82,31.9) 117,32.16 117.22,32.38 arc(117.66,32.68) 118.17,32.78 arc(118.23,32.78) 118.29,32.78 arc(119.33,33.02) 120.21,33.62 121.04,34.45 arc(121.23,34.73) 121.29,35.06 121.29,37.35 arc(121.49,38.36) 122.07,39.22 122.77,39.92 arc(122.99,40.25) 123.07,40.64 123.07,40.9 arc(123.03,41.05) 122.95,41.18
  05_SIG2 w0.237: v2(127.24,48.84) 126.91,48.52 arc(126.72,48.39) 126.49,48.34 126.06,48.34 arc(125.83,48.25) 125.74,48.01 125.74,47.79 arc(125.71,47.62) 125.62,47.48 arc(125.47,47.38) 125.29,47.34 123.19,47.34 arc(122.87,47.21) 122.74,46.89 122.74,41.53 arc(122.76,41.4) 122.84,41.29 122.95,41.18
PCIE_TX7_C_N: length 14.2
  TOP w0.147: C17.1 95.23,15.9 v1(95.16,15.83)
  10_GND w0.163: U2.A48 94.65,5.44 arc(94.61,5.64) 94.5,5.8 94.41,5.89 arc(94.32,6.03) 94.28,6.2 94.28,11.21 arc(94.36,11.58) 94.56,11.89 arc(94.73,12.14) 94.79,12.44 94.79,15.39 arc(94.8,15.45) 94.84,15.51 v1(95.16,15.83)
PCIE_TX7_C_P: length 14.2
  TOP w0.147: v1(94.16,15.83) 94.09,15.9 C18.1
  10_GND w0.163: U2.A47 93.65,5.39 arc(93.69,5.57) 93.79,5.73 93.98,5.92 arc(94.01,5.96) 94.02,6.02 94.02,11.21 arc(94.11,11.68) 94.38,12.07 arc(94.49,12.24) 94.53,12.44 94.53,15.39 arc(94.51,15.45) 94.48,15.51 v1(94.16,15.83)
PCIE_TX7_N: length 56.9
  TOP w0.147: U1.AN4 v2(128.24,45.84) ; v1(95.16,19.62) 95.23,19.55 C17.2
  03_SIG1 w0.183: v1(95.16,19.62) 94.82,19.96 arc(94.79,20) 94.79,20.04 94.79,20.1 arc(94.79,20.13) 94.79,20.15 arc(94.97,20.53) 95.36,20.68 102.86,20.68 arc(103.84,20.88) 104.68,21.43 arc(105.06,21.69) 105.51,21.78 110.12,21.78 arc(110.73,21.9) 111.24,22.24 111.79,22.8 arc(112.3,23.13) 112.89,23.25 116.78,23.25 arc(117.73,23.44) 118.54,23.98 120.93,26.37 arc(122.14,27.18) 123.57,27.47 125.02,27.47 arc(125.7,27.6) 126.28,27.99 127.97,29.69 arc(128.2,30.01) 128.32,30.39 128.36,30.76 arc(128.36,30.77) 128.36,30.79 128.36,41.13 arc(128.38,41.22) 128.43,41.3 128.45,41.32
  03_SIG1 w0.237: 128.45,41.32 128.63,41.5 arc(128.71,41.61) 128.74,41.75 128.74,46 arc(128.49,46.25) 128.24,46 v2(128.24,45.84)
PCIE_TX7_P: length 56.9
  TOP w0.147: U1.AN5 v2(128.24,46.84) ; C18.2 94.09,19.55 v1(94.16,19.62)
  03_SIG1 w0.183: v1(94.16,19.62) 94.27,19.73 arc(94.42,19.94) 94.48,20.18 94.48,20.18 arc(94.76,20.75) 95.36,20.98 102.86,20.98 arc(103.73,21.16) 104.47,21.65 arc(104.95,21.97) 105.51,22.08 110.12,22.08 arc(110.61,22.18) 111.02,22.46 111.58,23.01 arc(112.18,23.41) 112.89,23.56 116.78,23.56 arc(117.61,23.72) 118.32,24.2 120.71,26.59 arc(122.03,27.47) 123.57,27.77 125.02,27.77 arc(125.58,27.89) 126.06,28.21 127.76,29.9 arc(127.93,30.15) 128.01,30.43 128.06,30.8 128.06,40.87 arc(128.04,41.06) 127.97,41.24
  03_SIG1 w0.237: v2(128.24,46.84) 127.8,46.41 arc(127.75,46.34) 127.74,46.25 127.74,41.64 arc(127.75,41.56) 127.8,41.48 arc(127.85,41.43) 127.9,41.37 arc(127.94,41.31) 127.97,41.24
PCIE_TX8_C_N: length 14
  TOP w0.147: v1(99.65,15.83) 99.72,15.9 C31.1
  10_GND w0.163: U2.A53 99.65,5.34 arc(99.61,5.54) 99.49,5.71 99.42,5.79 arc(99.32,5.94) 99.28,6.12 99.28,6.25 99.28,15.26 arc(99.32,15.44) 99.43,15.6 v1(99.65,15.83)
PCIE_TX8_C_P: length 14
  TOP w0.147: C32.1 98.58,15.9 v1(98.65,15.83)
  10_GND w0.163: v1(98.65,15.83) 98.88,15.6 arc(98.98,15.44) 99.02,15.26 99.02,6.36 99.02,6.36 99.02,6.09 arc(98.99,5.96) 98.92,5.85 98.81,5.74 arc(98.69,5.57) 98.65,5.36 U2.A52
PCIE_TX8_N: length 51.1
  TOP w0.147: C31.2 99.72,19.55 v1(99.65,19.62) ; v2(129.24,47.84) U1.AP6
  05_SIG2 w0.183: v1(99.65,19.62) 99.36,19.92 arc(99.32,19.97) 99.3,20.04 99.3,20.23 arc(99.36,20.35) 99.49,20.41 99.55,20.41 arc(99.73,20.48) 99.8,20.66 99.8,20.89 arc(99.73,21.07) 99.55,21.14 arc(99.38,21.21) 99.3,21.39 99.3,21.63 arc(99.38,22.01) 99.6,22.33 100.2,22.94 arc(100.54,23.17) 100.95,23.25 102.16,23.25 arc(102.67,23.35) 103.1,23.64 103.32,23.86 arc(103.55,23.95) 103.77,23.86 103.91,23.72 arc(104.43,23.72) 104.43,24.24 104.32,24.34 arc(104.22,24.6) 104.32,24.86 104.73,25.27 arc(104.93,25.4) 105.17,25.45 107.18,25.45 arc(107.98,25.61) 108.66,26.06 109.12,26.53 arc(109.9,27.05) 110.82,27.23 112.85,27.23 arc(114.86,27.63) 116.56,28.76 118.82,31.03 arc(119.27,31.33) 119.81,31.44 arc(120.3,31.53) 120.72,31.81 122.07,33.16 arc(122.63,34) 122.83,34.99 122.83,36.43 arc(123.02,37.39) 123.56,38.2 125.11,39.76 arc(125.3,40.04) 125.37,40.38 125.37,40.99 arc(125.39,41.11) 125.46,41.2
  05_SIG2 w0.237: 125.46,41.2 125.66,41.41 arc(125.72,41.49) 125.74,41.59 125.74,43.72 arc(125.92,44.16) 126.36,44.34 arc(126.63,44.45) 126.74,44.72 126.74,44.97 arc(126.74,45.04) 126.76,45.09 arc(126.79,45.14) 126.82,45.17 126.87,45.22 arc(126.92,45.27) 126.98,45.3 arc(126.99,45.31) 126.99,45.31 arc(126.99,45.31) 127,45.31 arc(127.07,45.33) 127.16,45.34 127.18,45.34 arc(127.57,45.51) 127.74,45.9 127.74,46.96 arc(127.76,47.05) 127.81,47.13 127.91,47.24 arc(128.06,47.34) 128.24,47.37 arc(128.72,47.47) 129.14,47.74 v2(129.24,47.84)
PCIE_TX8_P: length 51.1
  TOP w0.147: v2(129.24,48.84) U1.AP7 ; C32.2 98.58,19.55 v1(98.65,19.62)
  05_SIG2 w0.183: v1(98.65,19.62) 98.95,19.92 arc(98.98,19.97) 99,20.04 99,21.63 arc(99.1,22.12) 99.38,22.55 99.99,23.15 arc(100.43,23.45) 100.95,23.55 102.16,23.55 arc(102.55,23.63) 102.89,23.85 104.52,25.48 arc(104.82,25.68) 105.17,25.75 107.18,25.75 arc(107.86,25.89) 108.44,26.28 108.91,26.74 arc(109.78,27.33) 110.82,27.53 112.85,27.53 arc(114.74,27.91) 116.34,28.98 118.6,31.24 arc(119.16,31.61) 119.81,31.74 arc(120.19,31.82) 120.51,32.03 121.42,32.94 arc(121.42,32.94) 121.42,32.94 121.85,33.38 arc(122.35,34.12) 122.52,34.99 122.52,36.43 arc(122.73,37.51) 123.34,38.42 124.9,39.97 arc(125.02,40.16) 125.07,40.38 125.07,40.9 arc(125.03,41.05) 124.95,41.18
  05_SIG2 w0.237: v2(129.24,48.84) 128.77,48.38 arc(128.7,48.33) 128.61,48.31 128.13,48.31 arc(127.86,48.2) 127.75,47.93 127.75,47.74 arc(127.74,47.68) 127.72,47.63 arc(127.53,47.42) 127.25,47.34 127.2,47.34 arc(126.87,47.2) 126.74,46.88 126.74,45.92 arc(126.73,45.87) 126.73,45.82 arc(126.53,45.48) 126.16,45.34 arc(125.86,45.22) 125.74,44.92 125.74,44.74 arc(125.7,44.58) 125.61,44.44 125.6,44.43 arc(125.51,44.36) 125.4,44.34 125.06,44.34 arc(124.83,44.25) 124.74,44.02 124.74,41.53 arc(124.76,41.4) 124.84,41.29 124.95,41.18
PCIE_TX9_C_N: length 12.4
  TOP w0.147: v1(103.65,14.23) 103.72,14.3 C34.1
  10_GND w0.163: v1(103.65,14.23) 103.43,14 arc(103.32,13.84) 103.28,13.66 103.28,6.04 arc(103.3,5.97) 103.34,5.91 103.51,5.74 arc(103.61,5.58) 103.65,5.39 U2.A57
PCIE_TX9_C_P: length 12.4
  TOP w0.147: C33.1 102.58,14.3 v1(102.65,14.23)
  10_GND w0.163: v1(102.65,14.23) 102.65,14.23 arc(102.92,13.82) 103.02,13.34 103.02,5.97 arc(103,5.89) 102.96,5.83 102.86,5.73 arc(102.71,5.49) 102.65,5.22 U2.A56
PCIE_TX9_N: length 51.1
  TOP w0.147: C34.2 103.72,17.95 v1(103.65,18.02) ; v2(130.24,45.84) 129.74,46.34 U1.AR4
  03_SIG1 w0.183: v1(103.65,18.02) 103.31,18.36 arc(103.29,18.4) 103.28,18.44 103.28,18.56 arc(103.33,18.69) 103.47,18.75 108.59,18.75 arc(109.38,18.91) 110.06,19.36 111.92,21.22 arc(112.64,21.7) 113.49,21.87 119.43,21.87 arc(119.99,21.98) 120.47,22.3 124,25.83 arc(124.48,26.15) 125.04,26.26 125.62,26.26 arc(125.62,26.26) 125.63,26.26 125.9,26.26 arc(126.42,26.37) 126.87,26.66 129.14,28.94 arc(130.05,30.29) 130.36,31.89 130.36,41.13 arc(130.38,41.22) 130.43,41.3 130.5,41.36
  03_SIG1 w0.237: v2(130.24,45.84) 130.24,45.99 arc(130.49,46.24) 130.74,45.99 130.74,41.75 arc(130.71,41.61) 130.63,41.5 130.5,41.36
PCIE_TX9_P: length 51.1
  TOP w0.147: v1(102.65,18.02) 102.58,17.95 C33.2 ; U1.AR5 v2(130.24,46.84)
  03_SIG1 w0.183: v1(102.65,18.02) 102.82,18.19 arc(102.93,18.36) 102.97,18.56 arc(103.12,18.91) 103.47,19.05 108.59,19.05 arc(109.26,19.19) 109.84,19.57 111.3,21.03 111.7,21.43 arc(112.52,21.98) 113.49,22.17 119.43,22.17 arc(119.88,22.26) 120.25,22.52 123.79,26.05 arc(124.36,26.43) 125.04,26.57 125.62,26.57 arc(125.62,26.57) 125.63,26.57 125.9,26.57 arc(126.31,26.65) 126.65,26.88 128.92,29.15 arc(129.76,30.41) 130.06,31.89 130.06,40.87 arc(130.02,41.12) 129.91,41.36
  03_SIG1 w0.237: v2(130.24,46.84) 129.8,46.41 arc(129.75,46.34) 129.74,46.25 129.74,41.64 arc(129.75,41.56) 129.8,41.48 arc(129.83,41.46) 129.85,41.43 arc(129.88,41.4) 129.91,41.36
PCIE_TX10_C_N: length 14
  TOP w0.147: C36.1 107.72,16.03 v1(107.65,15.95)
  10_GND w0.163: U2.A61 107.65,5.34 arc(107.61,5.54) 107.49,5.71 107.42,5.79 arc(107.32,5.94) 107.28,6.12 107.28,6.25 107.28,15.38 arc(107.32,15.57) 107.43,15.73 v1(107.65,15.95)
PCIE_TX10_C_P: length 14
  TOP w0.147: C35.1 106.58,16.03 v1(106.65,15.95)
  10_GND w0.163: U2.A60 106.65,5.29 arc(106.7,5.56) 106.86,5.79 106.92,5.85 arc(106.99,5.96) 107.02,6.09 107.02,6.36 107.02,6.36 107.02,15.38 arc(106.98,15.57) 106.88,15.73 v1(106.65,15.95)
PCIE_TX10_N: length 45.7
  TOP w0.147: U1.AT6 v2(131.24,47.84) ; C36.2 107.72,19.68 v1(107.65,19.75)
  07_SIG3 w0.183: v1(107.65,19.75) 107.41,19.75 arc(107.34,19.85) 107.3,19.98 arc(107.45,20.28) 107.76,20.41 109.08,20.41 arc(109.49,20.49) 109.84,20.73 114.89,25.78 arc(116,26.52) 117.32,26.78 117.63,26.78 arc(118.58,26.97) 119.37,27.5 120.42,28.55 arc(120.62,28.68) 120.84,28.73 121,28.73 arc(121.2,28.77) 121.37,28.88 125.2,32.71 arc(125.39,32.84) 125.61,32.88 127.05,32.88 arc(127.49,32.97) 127.86,33.22 130.84,36.19 arc(131.24,36.79) 131.38,37.5 131.38,38.68 arc(131.45,38.83) 131.6,38.9 arc(131.76,38.96) 131.82,39.12 131.82,39.23 arc(131.76,39.38) 131.6,39.45 arc(131.45,39.51) 131.38,39.67 131.38,39.77 arc(131.45,39.93) 131.6,40 arc(131.76,40.06) 131.82,40.22 131.82,40.32 arc(131.76,40.48) 131.6,40.54 arc(131.45,40.61) 131.38,40.77 131.38,41.14 arc(131.39,41.23) 131.42,41.31 arc(131.43,41.33) 131.45,41.35 arc(131.46,41.37) 131.48,41.39 131.64,41.54
  07_SIG3 w0.237: v2(131.24,47.84) 131.52,47.56 arc(131.68,47.32) 131.74,47.04 131.74,41.79 arc(131.71,41.65) 131.64,41.54
PCIE_TX10_P: length 45.7
  TOP w0.147: v1(106.65,19.75) 106.58,19.68 C35.2 ; U1.AT7 v2(131.24,48.84)
  07_SIG3 w0.183: 130.88,41.48 130.96,41.4 arc(131.05,41.27) 131.08,41.12 131.08,37.5 arc(130.96,36.91) 130.63,36.41 127.65,33.43 arc(127.37,33.25) 127.05,33.19 125.61,33.19 arc(125.27,33.12) 124.98,32.92 121.15,29.1 arc(121.08,29.05) 121,29.03 120.84,29.03 arc(120.5,28.96) 120.21,28.77 119.16,27.72 arc(118.46,27.25) 117.63,27.09 117.32,27.09 arc(115.89,26.8) 114.67,25.99 109.62,20.94 arc(109.37,20.77) 109.08,20.72 107.76,20.72 arc(107.23,20.5) 107,19.98 arc(107,19.96) 107,19.95 arc(106.98,19.88) 106.95,19.82 106.87,19.75 v1(106.65,19.75)
  07_SIG3 w0.237: v2(131.24,48.84) 130.86,48.46 arc(130.77,48.33) 130.74,48.17 130.74,41.83 arc(130.78,41.64) 130.88,41.48
PCIE_TX11_C_N: length 12.4
  TOP w0.147: C38.1 111.72,14.3 v1(111.65,14.23)
  10_GND w0.163: v1(111.65,14.23) 111.33,13.91 arc(111.3,13.85) 111.28,13.79 111.28,5.97 arc(111.3,5.9) 111.34,5.83 111.51,5.67 arc(111.61,5.51) 111.65,5.32 U2.A65
PCIE_TX11_C_P: length 12.4
  TOP w0.147: C37.1 110.58,14.3 v1(110.65,14.23)
  10_GND w0.163: v1(110.65,14.23) 110.97,13.91 arc(111.01,13.85) 111.02,13.79 111.02,5.97 arc(111,5.89) 110.96,5.83 110.79,5.66 arc(110.69,5.5) 110.65,5.32 U2.A64
PCIE_TX11_N: length 44.9
  TOP w0.147: v1(111.65,18.02) 111.72,17.95 C38.2 ; U1.AU4 131.74,46.34 v2(132.24,45.84)
  03_SIG1 w0.183: v1(111.65,18.02) 111.31,18.36 arc(111.29,18.4) 111.28,18.44 111.28,18.78 arc(111.29,18.85) 111.33,18.91 112.86,20.44 arc(113.13,20.61) 113.44,20.68 118.95,20.68 arc(122.31,21.34) 125.16,23.25 130.51,28.6 arc(131.88,30.65) 132.36,33.07 132.36,42.13 arc(132.38,42.22) 132.43,42.3
  03_SIG1 w0.237: v2(132.24,45.84) 132.24,46.01 arc(132.49,46.26) 132.74,46.01 132.74,42.75 arc(132.71,42.61) 132.63,42.5 132.43,42.3
PCIE_TX11_P: length 45
  TOP w0.147: C37.2 110.58,17.95 v1(110.65,18.02) ; U1.AU5 v2(132.24,46.84)
  03_SIG1 w0.183: v1(110.65,18.02) 110.9,18.27 arc(110.96,18.35) 110.97,18.44 110.97,18.78 arc(111.01,18.96) 111.12,19.12 112.45,20.46 112.54,20.55 112.65,20.65 arc(113.01,20.9) 113.44,20.98 118.95,20.98 arc(122.19,21.63) 124.94,23.46 130.3,28.82 arc(131.6,30.77) 132.06,33.07 132.06,41.87 arc(132.04,42.06) 131.97,42.25
  03_SIG1 w0.237: v2(132.24,46.84) 131.8,46.41 arc(131.75,46.34) 131.74,46.25 131.74,42.64 arc(131.75,42.56) 131.8,42.48 arc(131.85,42.43) 131.89,42.38 arc(131.93,42.32) 131.97,42.25
PCIE_TX12_C_N: length 14.1
  TOP w0.147: C43.1 115.72,16.03 v1(115.65,15.95)
  10_GND w0.163: U2.A69 115.65,5.34 arc(115.61,5.54) 115.49,5.71 115.42,5.79 arc(115.32,5.94) 115.28,6.12 115.28,6.25 115.28,15.52 arc(115.3,15.58) 115.33,15.63 v1(115.65,15.95)
PCIE_TX12_C_P: length 14.1
  TOP w0.147: v1(114.65,15.95) 114.58,16.03 C42.1
  10_GND w0.163: U2.A68 114.65,5.36 arc(114.69,5.57) 114.81,5.74 114.92,5.85 arc(114.99,5.96) 115.02,6.09 115.02,6.36 115.02,6.36 115.02,15.52 arc(115.01,15.58) 114.97,15.63 v1(114.65,15.95)
PCIE_TX12_N: length 39.4
  TOP w0.147: v2(134.24,45.84) 133.74,46.34 U1.AW4 ; v1(115.65,19.75) 115.72,19.68 C43.2
  07_SIG3 w0.183: v1(115.65,19.75) 115.31,20.09 arc(115.29,20.12) 115.28,20.17 115.28,21.52 arc(115.32,21.73) 115.44,21.91 117.35,23.82 arc(117.57,23.97) 117.83,24.02 118.22,24.02 arc(118.56,24.08) 118.84,24.27 122.22,27.66 arc(122.41,27.78) 122.63,27.82 122.97,27.82 arc(123.28,27.89) 123.54,28.06 124.34,28.86 arc(124.46,29.03) 124.5,29.24 124.5,29.58 arc(124.6,30.07) 124.88,30.49 125.3,30.92 arc(125.92,31.33) 126.65,31.47 127.38,31.47 arc(127.7,31.54) 127.98,31.72 134.13,37.87 arc(134.32,38.15) 134.38,38.48 134.38,39.24 arc(134.45,39.4) 134.6,39.46 arc(134.76,39.53) 134.82,39.68 134.82,39.79 arc(134.76,39.95) 134.6,40.01 arc(134.45,40.08) 134.38,40.23 134.38,40.34 arc(134.45,40.5) 134.6,40.56 arc(134.76,40.63) 134.82,40.78 134.82,40.89 arc(134.76,41.05) 134.6,41.11 arc(134.45,41.17) 134.38,41.33 134.38,41.77 arc(134.41,41.93) 134.5,42.05 134.63,42.18
  07_SIG3 w0.237: v2(134.24,45.84) 134.52,45.56 arc(134.68,45.32) 134.74,45.04 134.74,42.45 arc(134.71,42.31) 134.63,42.18
PCIE_TX12_P: length 39.4
  TOP w0.147: v1(114.65,19.75) 114.58,19.68 C42.2 ; U1.AW5 v2(134.24,46.84)
  07_SIG3 w0.183: v1(114.65,19.75) 114.97,20.06 arc(114.97,20.07) 114.97,20.08 114.97,21.52 arc(115.04,21.85) 115.22,22.12 117.13,24.03 arc(117.45,24.25) 117.83,24.32 118.22,24.32 arc(118.44,24.37) 118.62,24.49 122.01,27.87 arc(122.29,28.06) 122.63,28.13 122.97,28.13 arc(123.16,28.17) 123.32,28.28 124.13,29.08 arc(124.18,29.15) 124.19,29.24 124.19,29.58 arc(124.31,30.19) 124.66,30.71 125.09,31.13 arc(125.8,31.61) 126.65,31.78 127.38,31.78 arc(127.59,31.82) 127.77,31.94 133.92,38.09 arc(134.03,38.27) 134.08,38.48 134.08,41.68 arc(134.02,41.97) 133.86,42.2
  07_SIG3 w0.237: v2(134.24,46.84) 133.86,46.46 arc(133.77,46.33) 133.74,46.17 133.74,42.5 arc(133.77,42.34) 133.86,42.2
PCIE_TX13_C_N: length 12.4
  TOP w0.147: C45.1 119.72,14.3 v1(119.65,14.23)
  10_GND w0.163: v1(119.65,14.23) 119.33,13.91 arc(119.3,13.85) 119.28,13.79 119.28,5.97 arc(119.3,5.9) 119.34,5.83 119.51,5.67 arc(119.61,5.51) 119.65,5.32 U2.A73
PCIE_TX13_C_P: length 12.4
  TOP w0.147: v1(118.65,14.23) 118.58,14.3 C44.1
  10_GND w0.163: U2.A72 118.65,5.32 arc(118.69,5.5) 118.79,5.66 118.96,5.83 arc(119,5.89) 119.02,5.97 119.02,13.79 arc(119.01,13.85) 118.97,13.91 v1(118.65,14.23)
PCIE_TX13_N: length 38.3
  TOP w0.147: v2(136.24,45.84) 135.74,46.34 U1.BA4 ; v1(119.65,18.02) 119.72,17.95 C45.2
  07_SIG3 w0.183: 136.63,42.18 136.51,42.07 arc(136.42,41.92) 136.38,41.75 136.38,41.5 arc(136.45,41.34) 136.61,41.27 arc(136.77,41.21) 136.84,41.05 136.84,40.95 arc(136.77,40.79) 136.61,40.72 arc(136.45,40.66) 136.38,40.5 136.38,40.4 arc(136.45,40.24) 136.61,40.18 arc(136.77,40.11) 136.84,39.95 136.84,39.85 arc(136.77,39.69) 136.61,39.63 arc(136.45,39.56) 136.38,39.4 136.38,37.86 arc(136.01,36.02) 134.97,34.46 119.36,18.85 arc(119.3,18.76) 119.28,18.64 119.28,18.44 arc(119.29,18.4) 119.31,18.36 v1(119.65,18.02)
  07_SIG3 w0.237: v2(136.24,45.84) 136.52,45.56 arc(136.68,45.32) 136.74,45.04 136.74,42.45 arc(136.71,42.31) 136.63,42.18
PCIE_TX13_P: length 38.2
  TOP w0.147: C44.2 118.58,17.95 v1(118.65,18.02) ; U1.BA5 v2(136.24,46.84)
  07_SIG3 w0.183: v1(118.65,18.02) 118.92,18.29 arc(118.96,18.35) 118.97,18.42 118.97,18.64 arc(119.02,18.87) 119.15,19.07 134.76,34.68 arc(135.73,36.14) 136.08,37.86 136.08,41.68 arc(136.08,41.71) 136.07,41.73 arc(136.01,41.99) 135.86,42.2
  07_SIG3 w0.237: v2(136.24,46.84) 135.86,46.46 arc(135.77,46.33) 135.74,46.17 135.74,42.5 arc(135.77,42.34) 135.86,42.2
PCIE_TX14_C_N: length 14.4
  TOP w0.147: v1(124.54,15.95) 124.61,16.03 C47.1
  10_GND w0.163: U2.A77 123.65,5.25 arc(123.59,5.54) 123.43,5.78 arc(123.31,5.96) 123.27,6.17 123.27,11.67 arc(123.34,12.03) 123.55,12.34 arc(124.01,13.04) 124.17,13.86 124.17,15.52 arc(124.18,15.58) 124.22,15.63 v1(124.54,15.95)
PCIE_TX14_C_P: length 14.4
  TOP w0.147: C46.1 123.47,16.03 v1(123.54,15.95)
  10_GND w0.163: U2.A76 122.65,5.45 arc(122.68,5.6) 122.76,5.71 122.85,5.8 arc(122.96,5.97) 123,6.17 arc(123,6.18) 123,6.18 123,11.67 arc(123.09,12.14) 123.36,12.53 arc(123.77,13.14) 123.91,13.86 123.91,15.52 arc(123.9,15.58) 123.86,15.63 v1(123.54,15.95)
PCIE_TX14_N: length 35.1
  TOP w0.147: v1(124.54,19.75) 124.61,19.68 C47.2 ; U1.BC4 v2(138.24,45.84)
  05_SIG2 w0.183: v1(124.54,19.75) arc(124.31,20.09) 124.23,20.49 arc(124.27,20.68) 124.38,20.84 124.4,20.86 arc(124.58,20.98) 124.8,21.02 arc(125.09,21.08) 125.34,21.24 arc(125.58,21.61) 125.67,22.04 125.67,22.08 arc(125.97,23.61) 126.84,24.91 127.39,25.46 132.38,30.46 arc(132.87,31.05) 133.23,31.73 133.26,31.79 arc(133.37,32.11) 133.45,32.43 arc(133.5,32.76) 133.52,33.1 133.52,34.24 arc(133.79,35.63) 134.58,36.81 137.45,39.67 arc(138.14,40.71) 138.38,41.93 138.38,42.01 arc(138.43,42.25) 138.57,42.46
  05_SIG2 w0.237: v2(138.24,45.84) 138.24,46.02 arc(138.26,46.16) 138.34,46.28 arc(138.5,46.34) 138.65,46.28 arc(138.71,46.18) 138.74,46.06 138.74,42.87 arc(138.69,42.65) 138.57,42.46
PCIE_TX14_P: length 35.1
  TOP w0.147: v1(123.54,19.75) 123.47,19.68 C46.2 ; U1.BC5 v2(138.24,46.84)
  05_SIG2 w0.183: v1(123.54,19.75) 123.68,19.89 arc(123.87,20.16) 123.93,20.48 arc(123.93,20.49) 123.93,20.49 arc(123.99,20.8) 124.17,21.06 124.18,21.07 arc(124.46,21.26) 124.8,21.33 arc(124.97,21.36) 125.12,21.46 arc(125.3,21.73) 125.36,22.04 125.36,22.08 arc(125.69,23.73) 126.62,25.13 126.62,25.13 132.17,30.68 arc(132.62,31.22) 132.95,31.84 132.97,31.91 arc(133.08,32.19) 133.15,32.49 arc(133.2,32.79) 133.21,33.1 133.21,34.24 arc(133.51,35.74) 134.37,37.02 137.23,39.89 arc(137.86,40.83) 138.08,41.93 138.08,42.13 arc(138.08,42.15) 138.08,42.16 arc(138.04,42.35) 137.93,42.51
  05_SIG2 w0.237: v2(138.24,46.84) 137.85,46.46 arc(137.77,46.33) 137.74,46.18 137.74,42.83 arc(137.76,42.71) 137.82,42.62 137.93,42.51
PCIE_TX15_C_N: length 12.4
  TOP w0.147: v1(127.65,14.23) 127.72,14.3 C49.1
  10_GND w0.163: v1(127.65,14.23) 127.33,13.91 arc(127.3,13.85) 127.28,13.79 127.28,5.97 arc(127.3,5.9) 127.34,5.83 127.51,5.67 arc(127.61,5.51) 127.65,5.32 U2.A81
PCIE_TX15_C_P: length 12.4
  TOP w0.147: v1(126.65,14.23) 126.58,14.3 C48.1
  10_GND w0.163: U2.A80 126.65,5.32 arc(126.69,5.5) 126.79,5.66 126.96,5.83 arc(127,5.89) 127.02,5.97 127.02,13.79 arc(127.01,13.85) 126.97,13.91 v1(126.65,14.23)
PCIE_TX15_N: length 36.4
  TOP w0.147: C49.2 127.72,17.95 v1(127.65,18.02) ; v2(140.24,45.84) U1.BE4
  05_SIG2 w0.183: v1(127.65,18.02) 127.57,18.1 arc(127.39,18.37) 127.33,18.68 127.33,18.91 arc(127.4,19.07) 127.56,19.14 127.77,19.14 arc(128.14,19.51) 127.77,19.87 127.69,19.87 arc(127.44,19.98) 127.33,20.24 127.33,20.8 arc(127.36,20.94) 127.44,21.06 127.67,21.29 arc(127.85,21.56) 127.91,21.87 127.91,22.11 arc(128.03,22.7) 128.36,23.21 129.74,24.58 arc(130.22,25.31) 130.39,26.16 130.39,26.63 arc(130.44,26.86) 130.56,27.05 131.09,27.57 arc(131.23,27.66) 131.39,27.7 arc(131.81,27.78) 132.17,28.02 133.87,29.73 arc(134.46,30.6) 134.66,31.63 134.66,33.55 arc(134.98,35.12) 135.87,36.46 138.81,39.4 arc(139.1,39.83) 139.2,40.34 139.2,40.74 arc(139.29,41.2) 139.55,41.59 140.19,42.23 arc(140.35,42.47) 140.41,42.75 arc(140.41,42.82) 140.41,42.9 arc(140.43,43.02) 140.5,43.12
  05_SIG2 w0.237: v2(140.24,45.84) 140.63,45.45 arc(140.71,45.33) 140.74,45.19 140.74,44.84 140.74,43.69 arc(140.68,43.38) 140.5,43.12
PCIE_TX15_P: length 36.4
  TOP w0.147: U1.BE5 v2(140.24,46.84) ; C48.2 126.58,17.95 v1(126.65,18.02)
  05_SIG2 w0.183: v1(126.65,18.02) 126.82,18.19 arc(126.97,18.42) 127.02,18.68 127.02,20.8 arc(127.08,21.06) 127.22,21.28 127.45,21.51 arc(127.56,21.67) 127.6,21.87 127.6,22.11 arc(127.74,22.82) 128.15,23.42 129.53,24.8 arc(129.94,25.42) 130.09,26.16 130.09,26.63 arc(130.15,26.97) 130.35,27.26 130.87,27.79 arc(131.11,27.94) 131.39,28 arc(131.69,28.06) 131.95,28.23 133.66,29.94 arc(134.18,30.72) 134.36,31.63 134.36,33.55 arc(134.7,35.24) 135.65,36.67 138.6,39.62 arc(138.82,39.95) 138.89,40.34 138.89,40.74 arc(139.01,41.32) 139.34,41.81 139.98,42.45 arc(140.07,42.59) 140.1,42.75 140.1,42.76 arc(140.1,42.83) 140.1,42.9 140.1,42.93 arc(140.07,43.1) 139.97,43.25
  05_SIG2 w0.237: v2(140.24,46.84) 139.85,46.46 arc(139.77,46.33) 139.74,46.18 139.74,43.95 arc(139.8,43.58) 139.97,43.25
PCIE_WAKE_B: length 88.1
  TOP w0.152: v1(54.14,18.38) 55.07,17.45 55.98,17.45 57.4,16.03 57.4,10.21 55.25,8.05 55.25,6.45 55.65,6.05 U2.B11
  20_SIG7 w0.089: v1(66.75,58.34) 66.14,57.73 66.14,54.76 58.84,47.46 58.84,45.71 54.77,41.63 53.7,41.63 45.41,33.34 43.94,33.34 43.25,32.65 43.25,19.72 45.8,17.17 47.85,17.17 48.59,17.91 53.73,17.91 54.14,18.32 v1(54.14,18.38)
  BOTTOM w0.152: U3.12 61.7,54.4 65.64,58.34 v1(66.75,58.34)
PCIE_WAKE_B_LS: length 198.4
  TOP w0.152: v2(138.24,66.84) U1.BC24
  05_SIG2 w0.173: v1(66.32,63.12) 63.26,63.12 58.29,68.08 53.07,68.08 52.58,67.59 v1(52.58,67.18)
  14_SIG4 w0.089: v1(81.46,21.78) 79.68,23.56 77.37,23.56 76.05,22.24 69.81,22.24 68.86,23.19 68.86,24.77 68.4,25.22 67.03,25.22 66.75,24.94 66.22,24.94 65.57,25.59 65.57,30.33 63.94,31.97 63.38,31.97 61.87,33.47 61.02,33.47 59.97,34.51 59.97,36.11 58.44,37.64 54.35,37.64 52.65,39.34 52.65,40.79 54.07,42.21 55.27,42.21 57.98,44.92 57.98,52.63 58.65,53.29 58.65,56.44 58.87,56.66 58.87,57.74 53.11,63.5 53.11,66.65 v1(52.58,67.18)
  16_SIG5 w0.089: v2(138.24,66.84) 137.74,67.34 134.03,67.34 133.74,67.64 133.74,68.17 133.56,68.34 131.03,68.34 130.74,68.05 130.74,67.64 130.44,67.34 118.87,67.34 117.79,66.27 116.92,66.27 115.74,65.08 115.74,58.64 115.44,58.34 115.43,58.34 115.03,58.34 114.74,58.05 114.74,42.62 114.68,42.55 114.68,40.45 110.98,36.75 110.98,30.23 109.94,29.2 109.94,26.22 108.31,24.59 105.1,24.59 103.45,22.93 103.45,21.88 102.45,20.88 101.41,20.88 101.19,21.1 92.37,21.1 92.09,20.82 89.54,20.82 89.04,21.32 82.02,21.32 81.56,21.78 v1(81.46,21.78)
  BOTTOM w0.152: v1(66.32,63.12) 64.57,63.12 61.7,60.25 U3.9
PHY1_CLKOUT: length 182.3
  TOP w0.152: v1(28.78,137.57) 29.29,138.07 R32.2 ; U1.AU23 v2(132.24,64.84)
  16_SIG5 w0.089: v1(28.78,137.57) 30.38,137.57 30.76,137.19 38.18,137.19 41.35,140.36 42.8,140.36 44.76,138.4 49.05,138.4 49.41,138.04 49.41,134.9 51.61,132.69 51.61,128.32 52.25,127.68 52.25,109.7 54.15,107.8 58.06,107.8 58.47,107.39 58.47,107.14 58.98,106.63 58.98,101.88 58.08,100.99 58.08,81.82 57.59,81.32 57.59,80.42 58.09,79.91 v1(58.39,79.91)
  BOTTOM w0.152: v2(132.24,64.84) 131.93,64.84 131.14,65.63 130.2,65.63 129.67,66.17 129.24,66.17 128.74,66.67 128.74,67.04 128.44,67.34 118.93,67.34 118.54,67.74 118.54,68.17 117.37,69.34 114.07,69.34 113.72,68.99 113.72,68.62 113.42,68.33 113.03,68.33 112.78,68.07 112.78,67.72 112.45,67.39 110.01,67.39 109.74,67.66 109.74,68.19 109.58,68.34 108.92,68.34 108.74,68.53 108.74,69.04 108.41,69.37 107.8,69.37 107.65,69.52 107.65,70.13 107.4,70.38 106.93,70.38 106.74,70.58 106.74,71.06 106.46,71.34 105.95,71.34 105.74,71.55 105.74,72.19 105.58,72.34 104.87,72.34 104.7,72.52 104.7,73.08 104.44,73.34 103.92,73.34 103.74,73.53 103.74,74.16 103.56,74.34 102.92,74.34 102.74,74.53 102.74,75.06 102.46,75.33 102.03,75.33 101.74,75.63 101.74,76.06 101.45,76.34 101,76.34 100.74,76.61 100.74,77.06 100.45,77.34 89.43,77.34 86.33,80.44 82.55,80.44 81.91,79.81 81.91,76.94 81.61,76.63 66.47,76.63 65.33,77.77 65.33,78.89 63.43,80.79 59.27,80.79 v1(58.39,79.91)
PHY1_GPIO_0: length 244.6
  TOP w0.14: v1(41.14,137.86) U7.39
  TOP w0.152: U1.AR22 v2(130.24,63.84) ; v1(39.64,39.62) 40.65,38.61 65.7,38.61 67.29,37.03 67.29,30.98 68.83,29.44 73.47,29.44 76.39,32.36 82.01,32.36 89.66,40.01 126.4,40.01 v2(128.24,41.84)
  07_SIG3 w0.173: v1(41.14,137.86) 41.72,137.86 42.39,137.19 42.39,134.54 39.7,131.85 39.7,130.51 36.6,127.41 36.6,118.8 39.42,115.98 39.42,109.55 40.59,108.38 40.59,106.53 41.83,105.29 42.51,105.29 42.95,104.85 42.95,100.88 41.2,99.13 41.2,96.32 39.52,94.64 39.01,94.64 34.24,89.87 34.24,82.27 32.31,80.35 32.31,78.1 28.58,74.36 28.58,68.36 30.25,66.69 30.25,44.7 36,38.96 38.98,38.96 v1(39.64,39.62)
  14_SIG4 w0.089: v2(130.24,63.84) 129.84,63.44 129.84,60.6 129.49,60.24 129.07,60.24 128.8,59.97 128.8,47.38 128.84,47.34 128.84,45.21 128.71,45.08 128.71,42.31 v2(128.24,41.84)
PHY1_MDC: length 207.9
  TOP w0.152: U1.AV23 v2(133.24,64.84) ; R27.2 31.11,140.61 v1(31.37,140.36) 31.58,140.58 31.97,140.58 32.35,140.58 32.62,140.86 U7.16
  03_SIG1 w0.173: v1(31.37,140.36) 30.15,140.36 29.79,140 28.45,140 26.64,138.2 26.64,134.37 27.41,133.6 27.41,132.03 28.07,131.37 28.07,127.41 27.41,126.75 20.52,126.75 J13.1
  16_SIG5 w0.089: v1(58.06,80.75) 58.55,81.24 58.55,94.44 59.61,95.5 59.61,101.14 59.87,101.4 59.87,106.68 57.91,108.64 57.91,109.85 56.74,111.02 56.26,111.02 55.65,111.63 53.87,111.63 52.86,112.65 52.86,127.74 52.08,128.51 52.08,132.89 49.95,135.02 49.95,140.72 48.13,142.54 45.64,142.54 45.49,142.7 41.51,142.7 41.07,142.27 33.27,142.27 v1(31.37,140.36)
  BOTTOM w0.152: v2(133.24,64.84) 133.24,65.26 132.66,65.84 132.05,65.84 131.57,66.32 130.93,66.32 130.74,66.52 130.74,67.04 130.44,67.34 130.04,67.34 129.74,67.64 129.74,68.04 129.44,68.34 129.02,68.34 128.74,68.63 128.74,69.04 128.44,69.34 119,69.34 118.57,69.77 118.57,70.13 117.35,71.34 114.07,71.34 113.69,70.97 113.69,70.56 113.51,70.38 113,70.38 112.78,70.15 112.78,69.67 112.52,69.42 109.93,69.42 109.75,69.6 109.75,70.03 109.45,70.33 108.99,70.33 108.74,70.59 108.74,71.04 108.44,71.34 108.08,71.34 107.74,71.69 107.74,72.12 107.51,72.34 107.04,72.34 106.76,72.62 106.76,73.1 106.51,73.34 106.08,73.34 105.74,73.69 105.74,74.04 105.44,74.34 105.04,74.34 104.74,74.64 104.74,75.03 104.42,75.34 104.04,75.34 103.74,75.64 103.74,76.04 103.42,76.36 103.02,76.36 102.74,76.64 102.74,77.06 102.45,77.34 102.04,77.34 101.74,77.64 101.74,78.06 101.45,78.34 101.02,78.34 100.74,78.62 100.74,79.05 100.45,79.34 92.28,79.34 88.67,82.96 82.42,82.96 82.17,82.7 82.17,81.76 81.38,80.98 67.23,80.98 66.7,81.51 58.83,81.51 v1(58.06,80.75)
PHY1_MDIO: length 273.7
  TOP w0.152: v1(42.37,39.8) 42.96,39.21 65.75,39.21 67.68,37.27 67.68,31.09 68.98,29.8 73.15,29.8 76.16,32.8 81.8,32.8 89.65,40.65 126.05,40.65 v2(127.24,41.84) ; R26.2 v1(31.35,139.34) 31.58,139.57 31.58,139.81 31.99,140.22 32.15,140.22 32.49,140.22 32.63,140.36 U7.17 ; U1.AR23 v2(130.24,64.84)
  03_SIG1 w0.173: J16.1 20.98,124.54 28.55,124.54 30.4,126.39 30.4,133.32 30.13,133.6 30.13,138.12 v1(31.35,139.34)
  07_SIG3 w0.173: v1(42.37,39.8) 41.78,40.39 36.57,40.39 31.15,45.81 31.15,66.4 31.15,66.4 31.15,66.58 29.55,68.17 29.55,68.8 29.55,74.19 35.57,80.21 35.57,84.47 37.44,86.34 37.44,91.38 39.39,93.32 39.39,93.33 39.69,93.63 39.7,93.63 43.76,97.7 43.76,105 42.93,105.84 42.06,105.84 41.15,106.76 41.15,108.71 40.16,109.7 40.16,116.94 39.04,118.06 39.04,119.06 39.07,119.09 39.07,120.52 37.21,122.38 v1(37.21,123.75)
  14_SIG4 w0.089: v2(130.24,64.84) 129.64,64.24 129.64,60.68 129.4,60.44 128.95,60.44 128.62,60.11 128.62,47.31 128.66,47.27 128.66,45.56 128.42,45.32 127.98,45.32 127.82,45.15 127.82,42.42 v2(127.24,41.84)
  16_SIG5 w0.089: J16.1 21.36,122.35 22.76,123.75 v1(37.21,123.75)
PHY1_PDWN_B_I_INT_B_O: length 243.2
  TOP w0.14: R34.2 v1(42.29,141.15) 41.5,140.36 U7.44
  TOP w0.152: v1(23.32,94.23) 26.64,94.23 31.08,89.8 31.08,68.04 v1(33.46,65.65) ; U1.AR24 v2(130.24,66.84)
  07_SIG3 w0.173: v1(42.29,141.15) 41.05,141.15 40.31,140.41 40.31,135.13 38.43,133.25 38.43,130.51 35.92,127.99 35.92,119.1 31.85,115.04 30.68,115.04 25.83,110.19 23.52,110.19 22.35,109.02 22.35,102.69 21.95,102.29 21.95,99.42 23.32,98.04 v1(23.32,94.23)
  14_SIG4 w0.089: v2(123.24,41.84) 122.75,42.33 122.75,44.05 123.05,44.35 123.44,44.35 123.73,44.64 123.73,44.66 123.74,44.67 123.74,46.14 123.93,46.34 124.46,46.34 124.73,46.61 124.73,50.13 124.95,50.35 125.03,50.35 125.03,50.35 125.44,50.35 125.44,50.35 125.52,50.35 125.74,50.57 125.74,51.18 125.84,51.28 125.84,61.02 126.06,61.24 126.35,61.24 126.64,61.53 126.64,62.53 126.84,62.73 126.84,63.05 127.02,63.24 127.74,63.24 127.84,63.35 128.52,63.35 128.74,63.56 128.74,65.35 v2(130.24,66.84)
  BOTTOM w0.152: v2(123.24,41.84) 122.62,41.22 85.81,41.22 83.18,38.59 37.66,38.59 36.12,40.12 36.12,61.49 33.46,64.14 v1(33.46,65.65)
PHY1_RESET_B: length 202.7
  TOP w0.14: U7.43 40.81,139.86 40.88,139.93 41.65,139.93 41.73,140 42.12,140 v1(42.36,139.76) 42.61,140 R39.2
  TOP w0.152: U1.BA21 v2(136.24,62.84)
  05_SIG2 w0.173: v1(49.92,76.58) 51.21,76.58 51.77,76.02 55.98,76.02 59.54,79.58 65.74,79.58 67.3,78.01 67.3,74.77 v1(66.34,73.81)
  16_SIG5 w0.089: J11.1 48.94,133.66 48.94,135.62 48.21,136.35 45.92,136.35 45.29,136.98 44.65,136.98 44.3,137.34 44.3,138.2 42.74,139.76 v1(42.36,139.76) 41.81,139.2 41.81,138.48 42.42,137.87 42.42,134.7 39.57,131.85 39.57,128.19 40.61,127.15 42.24,127.15 43,126.39 43,119.91 41.66,118.57 40.64,118.57 39.34,117.27 39.34,108.88 38.72,108.26 38.72,100.39 39.33,99.78 40.43,99.78 41.26,98.95 41.26,96.43 44.06,93.63 44.06,92.11 49.86,86.31 49.86,80.68 50.23,80.32 50.23,76.89 v1(49.92,76.58)
  BOTTOM w0.113: v2(136.24,62.84) 136.24,62.71 135.64,62.11 135.64,61.63 135.45,61.44 134.84,61.44 134.64,61.24 134.64,60.65 134.43,60.44 132.88,60.44 132.74,60.58
  BOTTOM w0.152: 132.74,60.58 132.74,61.12 132.51,61.34 132.04,61.34 131.74,61.64 131.74,62.04 131.43,62.35 131,62.35 130.74,62.61 130.74,63.04 130.42,63.36 130.02,63.36 129.73,63.65 129.73,64.05 129.44,64.34 129.02,64.34 128.74,64.63 128.74,65.04 128.12,65.66 118.44,65.66 117.75,66.35 114.3,66.35 113.31,65.35 94.07,65.35 90.07,61.35 84.77,61.35 84.1,62.02 84.1,66.72 83.21,67.61 82.63,67.61 82.22,68.02 82.22,70.54 81.38,71.38 68.77,71.38 v1(66.34,73.81)
PHY1_SGMII_CLK_C_N: length 6.1
  TOP w0.104: U7.34 38.55,135.5 38.54,135.49 38.54,134.52 R205.1 38.99,132.83 C90.2 39.65,132.82 39.71,132.88 R66.1 40.79,132.88 40.85,132.95 41.53,132.95
PHY1_SGMII_CLK_C_P: length 6.1
  TOP w0.104: U7.33 38.05,135.71 38.31,135.45 38.31,134.15 38.21,134.04 R206.1 37.86,132.84 C93.2 36.73,132.82 R61.2 R67.1
PHY1_SGMII_CLK_N: length 247.4
  TOP w0.104: C90.1 v1(38.99,131.14) ; U1.AU22 v2(132.24,63.84)
  16_SIG5 w0.076: v2(132.24,63.84) 131.92,63.84 131.83,63.94 131.83,64.14 131.53,64.44 129.96,64.44 129.64,64.12 129.64,63.66 129.42,63.44 118.98,63.44 118.64,63.1 118.64,56.19 118.15,55.7 118.15,41.68 118.11,41.64 118.11,41.62
  16_SIG5 w0.089: 118.11,41.62 118.11,39.64 120.3,37.45 120.3,33.92 118.89,32.51 118.89,30.59 116.71,28.41 116.71,24.05 112.77,20.11 112.77,18.95 113.21,18.5 113.21,17.81 112.45,17.04 105.59,17.04 105.04,16.5 101.08,16.5 100.69,16.89 88.81,16.89 88.29,17.42 83.51,17.42 82.99,16.89 79.58,16.89 79.04,17.42 76.67,17.42 74.99,19.1 62.96,19.1 62.18,19.88 62.18,22.39 62.61,22.82 62.61,26.43 62.19,26.86 62.19,31.58 60.36,33.41 60.36,45.35 59.51,46.2 59.51,50.34 60.96,51.78 60.96,58.4 58.06,61.3 56.25,61.3 54.19,63.36 54.19,68.93 48.76,74.36 47.63,74.36 46.85,75.15 46.85,79.74 42.72,83.87 42.72,93.45 41.91,94.26 41.91,94.92 38.15,98.68 38.15,109.25 36.79,110.6 36.79,120.41 40.54,124.16 40.54,125.37 38.55,127.36 38.55,129.8 38.64,129.89 38.7,129.89 38.79,129.98 38.79,130.16 38.7,130.24 38.64,130.24 38.55,130.33 38.55,130.92 38.55,131.05 38.64,131.14 v1(38.99,131.14)
PHY1_SGMII_CLK_P: length 247.4
  TOP w0.104: C93.1 v1(37.84,131.14) ; U1.AT22 v2(131.24,63.84)
  16_SIG5 w0.076: 118.39,41.62 118.39,41.64 118.35,41.68 118.35,55.62 118.84,56.11 118.84,63.02 119.06,63.24 129.5,63.24 129.84,63.58 129.84,64.04 130.04,64.24 131.45,64.24 131.63,64.06 131.63,63.92 131.55,63.84 v2(131.24,63.84)
  16_SIG5 w0.089: v1(37.84,131.14) 38.19,131.14 38.27,131.05 38.27,130.92 38.27,127.24 40.26,125.26 40.26,124.27 36.52,120.53 36.52,110.49 37.87,109.13 37.87,98.56 41.63,94.8 41.63,94.14 42.44,93.34 42.44,83.76 46.57,79.63 46.57,75.03 47.52,74.08 48.65,74.08 53.91,68.82 53.91,63.25 56.14,61.02 57.94,61.02 60.68,58.28 60.68,51.9 59.23,50.45 59.23,46.09 60.08,45.24 60.08,33.29 61.91,31.46 61.91,26.74 62.33,26.32 62.33,22.94 61.9,22.5 61.9,19.76 62.84,18.82 74.88,18.82 76.56,17.14 78.93,17.14 79.46,16.61 83.1,16.61 83.63,17.14 88.17,17.14 88.7,16.61 100.57,16.61 100.96,16.22 105.16,16.22 105.7,16.76 112.56,16.76 113.49,17.7 113.49,18.62 113.05,19.06 113.05,19.99 116.99,23.93 116.99,28.29 119.17,30.48 119.17,32.39 120.58,33.8 120.58,37.56 118.39,39.76 118.39,41.62
PHY1_SGMII_IN_C_N: length 4
  TOP w0.104: U7.28 35.55,135.5 35.43,135.39 35.43,135.08 34.92,134.57 33.78,134.57 33.66,134.44 33.66,134.21 33.78,134.09 C85.2
PHY1_SGMII_IN_C_P: length 4
  TOP w0.104: U7.27 35.05,135.54 35.19,135.4 35.19,135.16 34.82,134.8 33.68,134.8 33.43,134.54 33.43,134.16 33.36,134.09 C77.2
PHY1_SGMII_IN_N: length 256.2
  TOP w0.104: v1(34.28,131.65) 33.96,131.97 33.96,132.33 33.68,132.61 33.68,132.97 33.8,133.09 34.2,133.09 ; v2(133.24,62.84) U1.AV21
  16_SIG5 w0.076: 119.03,41.51 119.03,41.53 119.07,41.57 119.07,41.92 118.62,42.37 118.62,55.15 118.91,55.44 119.47,55.44 119.64,55.61 119.64,62.12 119.96,62.44 130.42,62.44 130.64,62.66 130.64,63.11 130.97,63.44 132.57,63.44 132.83,63.19 132.83,62.94 132.92,62.84 v2(133.24,62.84)
  16_SIG5 w0.089: v1(34.28,131.65) 33.95,131.32 33.95,130.84 34.04,130.75 34.15,130.75 34.24,130.66 34.24,130.48 34.15,130.39 34.04,130.39 33.95,130.3 33.95,128.66 38.02,124.59 38.02,122.94 35.58,120.49 35.58,106.27 36.49,105.35 36.49,97.72 40.94,93.27 40.94,92.89 41.6,92.23 41.6,82.18 44.63,79.15 44.63,75.74 47.42,72.96 48.88,72.96 53.38,68.46 53.38,62.73 56.16,59.95 57.98,59.95 59.54,58.39 59.54,52.07 58.44,50.97 58.44,44.58 57.48,43.62 57.48,38.83 58.05,38.25 58.05,34.6 59.15,33.5 59.15,31.27 58.81,30.94 58.81,28.44 59.96,27.29 59.96,18.98 62.15,16.79 67.6,16.79 68.38,16 74.09,16 74.93,15.16 77.28,15.16 77.73,15.62 83.19,15.62 84.2,16.63 87.75,16.63 88.37,16.01 92.3,16.01 93.42,14.88 100.47,14.88 101.31,15.72 105.07,15.72 105.78,15.01 108.42,15.01 109.41,16 112.53,16 114.54,18.01 115.7,18.01 117.54,19.85 117.54,26.33 119.96,28.74 119.96,30.3 121.13,31.48 121.13,38.26 119.03,40.37 119.03,41.51
PHY1_SGMII_IN_P: length 256.2
  TOP w0.104: 32.91,133.09 33.3,133.09 33.45,132.94 33.45,132.52 33.73,132.24 33.73,132.03 v1(33.35,131.65) ; v2(132.24,62.84) U1.AU21
  16_SIG5 w0.076: 119.31,41.51 119.31,41.53 119.27,41.57 119.27,42.01 118.82,42.46 118.82,55.07 118.99,55.24 119.56,55.24 119.84,55.52 119.84,62.04 120.04,62.24 130.5,62.24 130.84,62.58 130.84,63.03 131.05,63.24 132.49,63.24 132.63,63.1 132.63,62.92 132.55,62.84 v2(132.24,62.84)
  16_SIG5 w0.089: v1(33.35,131.65) 33.67,131.32 33.67,128.54 37.74,124.47 37.74,123.05 35.3,120.6 35.3,106.15 36.21,105.24 36.21,97.61 40.67,93.15 40.67,92.77 41.32,92.12 41.32,82.07 44.35,79.03 44.35,75.63 47.3,72.68 48.77,72.68 53.1,68.34 53.1,62.62 56.05,59.67 57.87,59.67 59.26,58.28 59.26,52.19 58.16,51.08 58.16,44.69 57.2,43.73 57.2,38.71 57.77,38.14 57.77,34.48 58.87,33.38 58.87,31.39 58.53,31.05 58.53,28.33 59.68,27.18 59.68,18.87 62.04,16.51 67.48,16.51 68.27,15.72 73.98,15.72 74.81,14.88 77.39,14.88 77.85,15.34 83.31,15.34 84.32,16.35 87.63,16.35 88.25,15.73 92.18,15.73 93.3,14.61 100.58,14.61 101.42,15.44 104.95,15.44 105.66,14.73 108.53,14.73 109.52,15.72 112.65,15.72 114.66,17.73 115.81,17.73 117.82,19.74 117.82,26.21 120.24,28.63 120.24,30.19 121.41,31.36 121.41,38.38 119.31,40.49 119.31,41.51
PHY1_SGMII_OUT_C_N: length 8.6
  TOP w0.104: U7.36 39.55,135.5 39.42,135.37 39.42,135.2 39.52,135.1 39.95,135.1 40.21,135.36 41,135.36 v1(41.27,135.64) 41.27,135.6 41.54,135.33 42.21,135.33 42.57,134.98 42.73,134.98 C86.2 R68.2
  BOTTOM w0.104: C86.2 41.48,135.43 v1(41.27,135.64)
PHY1_SGMII_OUT_C_P: length 9
  TOP w0.104: U7.35 39.05,135.5 39.19,135.36 39.19,135.1 39.42,134.87 40.05,134.87 40.3,135.13 41.02,135.13 v1(41.27,134.87) 41.5,135.1 42.11,135.1 42.92,134.29 R70.2 C87.2
  BOTTOM w0.104: R71.1 41.65,134.39 42.06,134.8 42.06,135 41.96,135.1 41.5,135.1 v1(41.27,134.87)
PHY1_SGMII_OUT_N: length 239.2
  TOP w0.104: C86.1 44.61,135.01 44.61,134.84 v1(45.06,134.39) ; v2(133.24,66.84) U1.AV24
  16_SIG5 w0.076: v2(133.24,66.84) 132.8,66.84 132.63,67.02 132.63,67.22 132.41,67.44 130.95,67.44 130.64,67.13 130.64,66.68 130.28,66.32 118.49,66.32 118.04,65.87 117.2,65.87 116.64,65.31 116.64,57.54 116.54,57.44 115.84,57.44 115.64,57.24 115.64,49.51 115.62,49.49 115.62,47.29 115.66,47.25 115.66,44.39 115.62,44.35 115.62,42.2 115.58,42.16 115.58,42.15
  16_SIG5 w0.089: v1(45.06,134.39) 45.09,134.39 45.35,134.12 46.79,134.12 47.22,133.69 47.22,131.84 46.05,130.67 46.05,127.61 43.99,125.55 43.99,119.84 41.97,117.82 41.16,117.82 40.26,116.92 40.26,109.4 41.18,108.48 41.18,100.55 53.42,88.31 53.42,81.26 55.16,79.52 55.62,79.52 56.54,78.6 56.54,74.12 54.97,72.54 54.97,66.56 61.89,59.63 61.89,50.85 61.39,50.35 61.39,39.86 65.73,35.52 65.73,30.92 68.19,28.46 77.01,28.46 80.71,24.76 80.71,21.84 81.7,20.85 88.75,20.85 89.29,20.32 92.41,20.32 92.66,20.56 100.97,20.56 101.23,20.3 103.14,20.3 104.87,22.04 109.35,22.04 109.95,22.64 109.95,24.37 110.45,24.87 111.24,24.87 111.75,25.38 111.75,31.74 112.29,32.27 112.29,36.21 115.58,39.5 115.58,42.15
PHY1_SGMII_OUT_P: length 239.3
  TOP w0.104: v1(45.09,133.58) 44.6,133.09 44.19,133.09 ; v2(132.24,66.84) U1.AU24
  16_SIG5 w0.076: v2(132.24,66.84) 132.43,67.03 132.43,67.14 132.32,67.24 131.04,67.24 130.84,67.04 130.84,66.59 130.36,66.12 118.58,66.12 118.12,65.67 117.28,65.67 116.84,65.23 116.84,57.46 116.62,57.24 115.92,57.24 115.84,57.16 115.84,49.42 115.82,49.41 115.82,47.37 115.85,47.34 115.85,44.3 115.82,44.27 115.82,42.21 115.86,42.17 115.86,42.15
  16_SIG5 w0.089: 115.86,42.15 115.86,39.38 112.57,36.09 112.57,32.15 112.03,31.62 112.03,25.26 111.36,24.59 110.56,24.59 110.23,24.25 110.23,22.52 109.47,21.76 104.99,21.76 103.25,20.03 101.11,20.03 100.85,20.28 92.77,20.28 92.53,20.04 89.17,20.04 88.64,20.57 81.59,20.57 80.43,21.73 80.43,24.64 76.89,28.18 68.08,28.18 65.45,30.81 65.45,35.41 61.12,39.75 61.12,50.47 61.62,50.97 61.62,59.52 54.69,66.45 54.69,72.66 56.26,74.24 56.26,78.48 55.5,79.24 55.04,79.24 53.14,81.15 53.14,88.2 40.9,100.44 40.9,108.36 39.98,109.28 39.98,117.03 41.04,118.1 41.85,118.1 43.71,119.96 43.71,125.67 45.77,127.73 45.77,130.78 46.94,131.95 46.94,133.58 46.67,133.85 46.25,133.85 46.16,133.76 46.16,133.29 46.07,133.2 45.89,133.2 45.8,133.29 45.8,133.76 45.71,133.85 45.35,133.85 v1(45.09,133.58)
PMBUS_ALERT: length 485.7
  TOP w0.152: v1(166.56,142.28) 166.56,141.9 166.19,141.53 U166.13 ; U165.13 182.39,46.17 182.76,45.81 v1(183.14,45.81)
  03_SIG1 w0.173: v1(185.75,30.2) 186.64,31.08 189.14,31.08 191.64,28.58 191.64,27.56 192.13,27.08 193.09,27.08 195.83,29.82 199.14,29.82 199.65,29.31 209.06,29.31 213.31,33.56 223.53,33.56 224.3,34.33 226.45,34.33 v1(227.09,34.98) 230.83,34.98 231.9,36.04 234.28,36.04 J39.7 ; v1(214.44,61.21) 213.82,61.84 212.9,61.84 212.08,61.01 212.08,59.21 213.44,57.85 213.44,53.49 214.17,52.77 214.17,51.91 213.8,51.54 v1(213.8,51.28) ; v1(239.28,109.88) 238.69,109.88 236.8,111.77 233.34,111.77 230.51,114.6 227.74,114.6 225.96,116.38 225.59,116.38 224.7,117.28 224.7,118.87 221.23,122.33 193.75,122.33 184.96,131.11 180.9,131.11 179.76,132.26 179.76,134.19 178.21,135.74 178.21,138.91 178.99,139.69 178.99,140.32 v1(178.49,140.82) ; v1(155.57,112.52) 156.06,113.01 156.32,113.01 157.34,114.03 157.34,114.65 158.5,115.82 159.34,115.82 159.61,115.54 160.37,115.54 161.73,116.91 162.67,116.91 163.39,117.63 163.39,118.38 167.94,122.93 167.94,128.73 169.29,130.08 169.29,142.24 168.48,143.06 167.33,143.06 v1(166.56,142.28)
  05_SIG2 w0.173: v1(48.49,124.97) 49.1,125.58 51,125.58 51.54,125.04 55.22,125.04 56.57,126.39 58.62,126.39 61.82,129.59 61.82,131 66.35,135.53 66.35,141.37 64.88,142.84 v1(64.09,142.84) ; v1(239.28,109.88) 238.53,109.13 238.53,106.3 237.87,105.64 237.87,104.06 236.3,102.49 236.3,100.05 230.75,94.5 230.75,92.1 228.64,89.99 228.64,81.37 225.39,78.11 222.65,78.11 220.53,76 220.53,65.8 218.5,63.76 216.99,63.76 v1(214.44,61.21)
  07_SIG3 w0.173: v1(185.75,30.2) 184.43,31.52 184.43,44.52 v1(183.14,45.81) 184.45,47.12 184.45,49.5 185.83,50.88 191.26,50.88 192.44,49.7 198.08,49.7 199.13,50.74 204.88,50.74 205.94,49.68 212.2,49.68 v1(213.8,51.28) ; v1(178.49,140.82) 178.49,141.57 178.01,142.06 169.26,142.06 167.58,140.37 166.94,140.37 166.56,140.76 v1(166.56,142.28)
  BOTTOM w0.152: v1(48.49,124.97) 48.49,124.58 47.96,124.05 U150.9 ; U9.9 156.11,113.44 155.57,112.9 v1(155.57,112.52) ; v1(166.56,142.28) 166.56,143.5 165.34,144.72 144.87,144.72 142.52,142.37 127.74,142.37 127.3,142.82 127.3,143.12 127.94,143.76 127.94,145.08 124.36,148.66 70.24,148.66 65.37,143.79 65.05,143.79 v1(64.09,142.84) ; v1(178.49,140.82) 178.87,140.82 179.41,140.28 U30.9 ; v1(214.44,61.21) 214.06,61.21 213.53,61.75 U6.9 ; v1(185.75,30.2) 186.1,29.84 186.54,29.84 186.93,29.46 U156.9 ; v1(227.09,34.98) R500.2 226.38,35.49 226.26,35.61 225.76,35.61 225.59,35.78 Q23.3 Q21.3 ; U4.9 214.72,50.75 214.18,51.28 v1(213.8,51.28)
  BOTTOM w0.178: v1(239.28,109.88) 239.1,109.71 U164.13
PMBUS_ALERT_FPGA: length 138.5
  TOP w0.152: U1.BB23 v2(137.24,64.84)
  20_SIG7 w0.089: v2(137.24,64.84) 138.5,66.1 144.68,66.1 149.03,70.46 149.03,79.35 149.9,80.21 153.37,80.21 153.72,80.57 153.72,80.9 154.56,81.74 172.19,81.74 175.06,78.87 178.92,78.87 181.61,76.17 181.61,75.76 183.63,73.74 183.63,68.67 186.97,65.33 186.97,59.95 188.14,58.79 193.18,58.79 195.6,56.38 197.92,56.38 198.06,56.23 199.19,56.23 204.09,51.33 204.58,51.33 205.99,49.92 205.99,46.24 207.1,45.13 207.1,43.79 212.64,38.26 v1(230.86,38.26)
  BOTTOM w0.152: Q21.2 227.09,38.36 227.19,38.26 R324.2 v1(230.86,38.26)
PMBUS_ALERT_SYSCTLR: length 348.2
  TOP w0.152: v1(63.7,129.67) 64.9,129.67 65.74,128.83 67.44,128.83 68.99,127.28 68.99,125.47 65.35,121.83 65.35,116.31 64.49,115.44 64.49,108.57 65.64,107.42 68.86,107.42 69.55,108.1 87.62,108.1 88.18,107.55 88.18,106.91 90.95,104.14 104.77,104.14 108.76,108.13 116.31,108.13 116.97,107.47 123.52,107.47 124.82,106.17 124.82,98.55 126.82,96.54 140.32,96.54 142.18,98.4 143.79,98.4 144.8,97.4 145.95,97.4 146.97,98.42 v1(146.97,99.55) ; U111.P11 v5(10.7,131.77)
  14_SIG4 w0.089: v1(146.97,99.55) 147.35,99.93 147.35,102.29 148.62,103.56 151.87,103.56 152.46,104.15 152.46,105.24 154.79,107.57 165.15,107.57 166.98,105.74 166.98,104.74 167.68,104.04 168.1,104.04 169.85,102.29 170.87,102.29 171.7,101.45 171.7,98.32 171.2,97.82 v1(171.2,87.2) ; v5(10.7,131.77) U111.P11 11.1,133.62 11.39,133.91 15.72,133.91 16.26,134.45 16.26,141.91 16.79,142.44 30.99,142.44 33.99,139.45 33.99,133.05 34.82,132.21 34.82,129.44 37.26,127 50.27,127 53.29,123.98 59.06,123.98 63.7,128.62 v1(63.7,129.67)
  20_SIG7 w0.089: v1(171.2,87.2) 171.2,84.49 175.5,80.19 181.09,80.19 184.78,76.49 184.78,69.95 193.44,61.29 196.16,61.29 196.7,60.75 196.7,59.63 201.77,54.56 210.23,54.56 212.12,52.66 217.1,52.66 219.69,50.07 220.34,50.07 220.99,49.43 220.99,46.59 222.29,45.29 224.78,45.29 231.37,38.7 231.37,36.61 230.49,35.74 v1(229.69,35.74)
  BOTTOM w0.152: Q23.2 227.03,36.2 227.13,36.1 R820.2 229.33,36.1 v1(229.69,35.74)
PMBUS_SCL: length 535.1
  TOP w0.14: v1(144.46,119.57) 143.81,118.92 U80.5
  TOP w0.152: v1(167.19,141.77) 166.56,141.14 166.56,140.89 166.69,140.75 U166.12 ; v1(182.63,45.17) 182,45.81 181.74,45.81 181.61,45.67 U165.12
  03_SIG1 w0.173: v1(186.9,30.32) 187.02,30.2 187.02,29.55 187.62,28.95 189.62,28.95 190.47,28.1 190.47,25.77 191.72,24.52 194.57,24.52 195.94,25.88 198.3,25.88 200.61,28.19 211.18,28.19 215,32.02 225.16,32.02 225.65,31.52 226.74,31.52 v1(227.09,31.17) 227.49,31.57 228.01,31.57 230.21,29.36 231.35,29.36 232.27,28.45 234.26,28.45 J39.1 ; v1(167.19,141.77) 167.33,141.64 168,141.64 168.43,141.21 168.43,132.08 167.06,130.71 167.06,123.17 162.37,118.48 161.7,118.48 160.49,117.27 157.93,117.27 156.79,116.13 156.79,114.34 156.01,113.56 155.47,113.56 v1(155.32,113.41) ; v1(213.56,60.96) 213.47,60.87 213.47,60.24 214.86,58.84 214.86,55.17 216.71,53.32 216.71,50.17 216.21,49.66 215.3,49.66 214.76,50.2 214.76,51.46 v1(214.69,51.54) ; v1(239.53,110.67) 238.69,110.67 236.64,112.71 235.16,112.71 231.94,115.93 228.04,115.93 227.58,115.93 226.47,117.04 226.47,118.91 221.48,123.9 196.96,123.9 188.42,132.43 186.58,132.43 184.04,134.97 180.14,134.97 178.97,136.14 178.97,138.88 179.54,139.46 179.54,140.91 v1(179.38,141.07)
  05_SIG2 w0.173: v1(63.73,140.45) 63.72,140.44 63.72,139.49 62.95,138.72 62.95,135.39 58.43,130.87 55.89,130.87 55.22,130.21 54.9,129.88 54.9,129.04 53.06,127.2 48.82,127.2 47.02,125.4 47.02,124.56 47.59,123.98 48.65,123.98 v1(48.75,124.08) ; v1(213.56,60.96) 213.42,61.1 213.42,61.39 213.54,61.52 213.62,61.52 213.77,61.67 213.77,61.95 213.63,62.09 213.56,62.09 213.42,62.23 213.42,62.54 213.95,63.07 213.95,63.47 217.84,67.36 218.41,67.36 219.25,68.2 219.25,76.17 223.39,80.31 223.39,80.8 223.39,80.8 223.39,94.87 224.52,96 225.2,96 225.67,95.53 226.14,95.53 226.71,96.1 230.17,96.1 232.04,97.97 232.04,102.03 233.25,103.24 235.33,103.24 236.62,104.53 236.62,105.75 237.54,106.67 237.58,106.72 237.58,109.53 238.81,110.76 239.43,110.76 v1(239.53,110.67)
  07_SIG3 w0.173: v1(186.9,30.32) 186.96,30.26 186.96,29.18 186.49,28.7 185.56,28.7 183.71,30.55 183.71,42.97 182.55,44.14 182.55,45.09 v1(182.63,45.17) 182.63,45.39 182.02,46.01 181.82,46.01 181.12,46.71 181.12,48.72 180.56,49.28 180.56,49.72 182.54,51.7 185.09,51.7 186.23,52.84 186.23,54.48 186.92,55.17 190.4,55.17 192.13,53.44 192.13,51.46 193.16,50.43 198.01,50.43 202.15,54.56 209.42,54.56 211.45,52.53 211.63,52.53 211.78,52.39 211.78,51.76 212,51.54 212.47,51.54 212.64,51.71 212.64,52.31 212.86,52.53 214.48,52.53 214.9,52.12 214.9,51.75 v1(214.69,51.54) ; v1(167.19,141.77) 167.19,142.48 167.87,143.16 178.67,143.16 179.16,142.67 181.24,142.67 181.58,142.33 181.58,142.33 181.91,142.01 181.91,140.15 181.24,139.48 180.12,139.48 179.38,140.22 v1(179.38,141.07)
  14_SIG4 w0.089: v1(155.32,113.41) 155.32,112.96 155.12,112.77 154.85,112.77 154.71,112.9 154.71,113.37 154.54,113.54 154.04,113.54 153.64,113.13 152.12,113.13 150.99,114.26 150.99,116.08 148.1,118.98 146.32,118.98 145.54,119.76 145.12,119.76 145.01,119.65 145.01,119.12 144.84,118.95 144.41,118.95 144.26,119.1 144.26,119.36 v1(144.46,119.57)
  BOTTOM w0.152: v1(214.69,51.54) 215.22,51.01 U4.10 ; R501.2 v1(227.09,31.17) ; R622.2 141.87,117.93 142.86,118.92 143.34,118.92 143.99,119.57 v1(144.46,119.57) 146.7,119.57 147.79,120.66 147.79,124.9 150.79,127.91 150.79,130.37 150.27,130.9 145.5,130.9 144.81,131.59 144.81,132.09 139.75,137.14 134.91,137.14 130.78,133.02 115.98,133.02 112.7,136.3 112.7,144.15 111.33,145.51 69.77,145.51 65.62,141.36 64.94,141.36 64.02,140.45 v1(63.73,140.45) ; v1(186.9,30.32) 187.42,29.79 U156.10 ; v1(155.32,113.41) 155.85,113.94 U9.10 ; v1(48.75,124.08) 48.22,123.55 U150.10 ; U30.10 179.91,140.54 v1(179.38,141.07) ; v1(213.56,60.96) 213.03,61.49 U6.10
  BOTTOM w0.216: U164.12 238.79,110.21 239.25,110.67 v1(239.53,110.67)
