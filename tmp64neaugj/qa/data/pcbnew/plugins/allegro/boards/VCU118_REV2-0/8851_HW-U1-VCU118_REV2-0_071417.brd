# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_C2_DM5: length 35.5
  TOP w0.152: U137.E2 v4(157.96,74.15) ; U1.BE40 139.74,82.34 v2(140.24,82.84)
  05_SIG2 w0.173: v4(157.96,74.15) 157.96,74.39 158.36,74.79 158.36,80.8 158.18,80.98 156.17,80.98 156.01,81.13 156.01,81.29 ; 142.63,84.37 141.6,83.34 140.9,83.34 140.4,82.84 v2(140.24,82.84)
  05_SIG2 w0.262: 156.01,81.29 156.01,81.38 156.18,81.55 157.07,81.55 157.48,81.95 157.48,83.01 156.16,84.32 155.97,84.32 155.7,84.05 155.51,84.05 155.31,84.25 155.31,84.45 155.57,84.71 155.57,84.91 155.37,85.11 155.17,85.11 154.94,84.88 154.76,84.88 154.56,85.08 154.56,85.27 154.78,85.5 154.78,85.7 154.13,86.36 144.61,86.36 142.63,84.37
DDR4_C2_DM6: length 71.2
  TOP w0.152: U138.E7 v4(157.96,92.25) ; U1.AY37 v2(135.24,79.84)
  07_SIG3 w0.173: 142.63,89.18 142.42,89.18 142.29,89.31 141.62,89.31 141.51,89.21 141.51,89.1 141.41,89 141.27,89 141.17,89.1 141.17,89.21 141.07,89.31 140.92,89.31 140.78,89.17 140.78,88.75 140.68,88.65 140.54,88.65 140.44,88.75 140.44,89.26 140.34,89.36 140.19,89.36 140.09,89.26 140.09,88.75 139.99,88.65 139.85,88.65 139.75,88.75 139.75,89.18 139.62,89.31 139.1,89.31 138.54,89.87 138.34,89.87 138.11,89.65 138.11,89.45 138.23,89.33 138.43,89.33 138.74,89.03 138.74,85.52 138.91,85.34 139.6,85.34 139.78,85.16 139.78,84.53 139.61,84.36 138.92,84.36 138.74,84.18 138.74,83.68 138.74,83.46 138.62,83.34 138.4,83.34 138.4,83.34 137.87,83.34 137.74,83.21 137.74,82.8 137.74,82.64 137.44,82.34 136.19,82.34 136.19,82.34 135.91,82.34 135.74,82.17 135.74,81.78 135.74,80.64 135.47,80.37 134.88,80.37 134.72,80.21 134.72,79.42 134.84,79.3 135.16,79.3 135.35,79.49 135.35,79.73 v2(135.24,79.84) ; v4(157.96,92.25) 157.96,92.55 157.86,92.65 156.99,92.65 156.76,92.42 156.76,91.88 156.87,91.77 157.12,91.77 157.23,91.66 157.23,91.34 157.15,91.26 156.57,91.26 156.41,91.41 156.41,91.71 156.31,91.81 156.08,91.81 156,91.73 156,91.36 155.9,91.26 155.76,91.26 155.66,91.36 155.66,91.73 155.56,91.83 155.42,91.83 155.31,91.73 155.31,91.42 155.2,91.31 155.06,91.31 154.97,91.4 154.97,91.7 154.87,91.8 154.72,91.8 154.62,91.7 154.62,91.38 154.51,91.27 154.37,91.27 154.28,91.36 154.28,91.91 154.2,91.99 154.03,91.99 153.97,91.92
  07_SIG3 w0.262: 153.97,91.92 153.36,91.31 152.93,91.31 152.77,91.15 152.77,89.89 152.54,89.66 151.68,89.66 151.49,89.85 151.49,90.05 151.32,90.22 150.12,90.22 150.05,90.28 140.2,90.28 140,90.47 139.42,90.47 139.22,90.27 139.22,89.99 139.46,89.75 139.9,89.75 139.91,89.75 149.9,89.75 150.05,89.6 150.05,89.36 149.67,88.98 149.42,88.98 149.22,89.18 142.63,89.18
DDR4_C2_DM7: length 58.8
  TOP w0.152: U1.AV35 v2(133.24,77.84) ; U138.E2 v4(157.96,88.25)
  14_SIG4 w0.089: 134.74,89.03 134.74,88.64 134.44,88.34 133.03,88.34 132.74,88.05 132.74,87.64 132.44,87.34 132.03,87.34 131.74,87.05 131.74,86.64 131.44,86.34 131.03,86.34 130.74,86.05 130.74,85.64 130.44,85.34 130.03,85.34 129.74,85.05 129.74,84.64 129.44,84.34 129.03,84.34 128.74,84.05 128.74,81.64 129.03,81.34 129.44,81.34 129.74,81.05 129.74,80.64 130.03,80.34 130.44,80.34 130.74,80.05 130.74,79.64 131.03,79.34 131.44,79.34 131.74,79.05 131.74,78.64 132.03,78.34 132.74,78.34 v2(133.24,77.84) ; 159.96,95.39 159.96,90.93 159.16,90.13 159.16,89.69 158.92,89.45 158.59,89.45 158.36,89.21 158.36,88.65 v4(157.96,88.25)
  14_SIG4 w0.14: 159.96,95.39 159.96,95.64 157.28,98.32 151.66,98.32 151.43,98.55 144.5,98.55 142.55,96.59 141.85,96.59 134.74,89.48 134.74,89.03
DDR4_C2_DM8: length 71.4
  TOP w0.152: U139.E7 v4(157.96,35.61) ; v2(140.24,71.84) 139.74,71.34 U1.BE29
  14_SIG4 w0.089: 141.71,71.37 140.71,71.37 v2(140.24,71.84) ; 159.96,38.23 159.96,37.11 159.96,37.11 159.96,37.04 159.72,36.81 158.7,36.81 158.69,36.81 158.59,36.81 158.36,36.57 158.36,36.2 158.06,35.9 158.06,35.71 v4(157.96,35.61)
  14_SIG4 w0.14: 159.96,38.23 159.96,39.2 159.77,39.39 158.61,39.39 158.42,39.59 158.42,39.97 158.61,40.16 159.77,40.16 159.96,40.35 159.96,40.73 159.77,40.92 158.61,40.92 158.42,41.11 158.42,41.55 158.59,41.72 160.01,41.72 160.16,41.87 160.16,42.22 159.98,42.4 159.43,42.4 159.27,42.57 159.27,43.49 159.43,43.66 159.94,43.66 160.11,43.83 160.11,44.06 159.94,44.23 159.43,44.23 159.1,44.57 158.86,44.57 158.7,44.4 158.7,42.57 158.53,42.4 158.29,42.4 158.12,42.57 158.12,44.4 157.96,44.57 157.72,44.57 157.55,44.4 157.55,42.57 157.38,42.4 154.79,42.4 154.49,42.4 153.7,41.62 153.7,41.17 153.5,40.97 152.99,40.97 152.59,41.37 152.59,41.86 151.68,42.77 151.68,43.21 150.94,43.94 147.87,43.94 147.68,44.13 147.68,47.72 146.94,48.47 146.94,49.78 146.94,49.78 146.94,51.26 145.36,52.84 145.36,58.26 144.83,58.79 144.34,58.79 144.01,59.12 144.01,62.56 143.42,63.15 143.42,70.39 142.44,71.37 141.71,71.37
DDR4_C2_DM9: length 58.7
  TOP w0.152: U1.BA29 135.74,71.34 v2(136.24,71.84) ; U139.E2 v4(157.96,31.61)
  03_SIG1 w0.173: 153.97,31.13 154.22,31.13 154.3,31.21 157.56,31.21 v4(157.96,31.61) ; v2(136.24,71.84) U1.BA29 135.02,71.34 134.74,71.06 134.74,70.58 134.5,70.34 134.04,70.34 134.03,70.34 133.74,70.05 133.74,69.64 133.74,66.64 135.01,65.36 135.47,65.36 135.74,65.09 135.74,63.62 136.02,63.34 136.44,63.34 136.74,63.05 136.74,62.64 137.03,62.34 137.5,62.34 137.74,62.11 137.74,61.64 138.03,61.34 138.44,61.34 138.74,61.05 138.74,60.6 138.99,60.34 139.45,60.34 139.74,60.06 139.74,59.62 140.01,59.34 140.46,59.34 140.74,59.07 140.74,48.67 141.05,48.36 141.5,48.36 141.76,48.1
  03_SIG1 w0.262: 153.97,31.13 152.92,31.13 150.29,33.76 150.29,36.28 141.76,44.81 141.76,48.1
DDR4_C2_DQ0: length 68.6
  TOP w0.152: U135.G2 v4(159.56,45.96) ; v2(139.24,72.84) U1.BD30
  07_SIG3 w0.173: 153.97,45.6 154.14,45.43 154.38,45.43 154.51,45.56 154.92,45.56 155.16,45.33 155.16,44.93 155.33,44.76 158.92,44.76 159.16,44.99 159.16,45.29 159.16,45.29 159.16,45.33 159.56,45.72 v4(159.56,45.96) ; v2(139.24,72.84) 139.24,72.55 139.74,72.05 139.74,72.01 139.74,69.51 139.9,69.34 140.51,69.34 140.74,69.12 140.74,67.63 141.03,67.34 141.44,67.34 141.71,67.08
  07_SIG3 w0.262: 153.97,45.6 153.8,45.77 153.8,46.46 153.33,46.92 152.92,46.92 152.51,46.52 152.21,46.52 151.64,47.09 151.64,47.4 151.99,47.74 151.99,47.95 151.83,48.11 151.62,48.11 151.23,47.72 151.14,47.72 150.87,47.98 150.87,48.21 151.11,48.44 151.11,49.14 150.72,49.53 149.56,49.53 149.25,49.84 149.25,51.87 148.19,52.93 146.98,52.93 145.4,54.51 144.91,54.51 144.39,55.03 144.39,55.27 144.25,55.41 144.01,55.41 143.87,55.27 143.87,54 143.73,53.86 143.45,53.86 143.31,54 143.31,55.27 143.17,55.41 142.81,55.41 142.67,55.55 142.67,55.8 142.83,55.97 144.25,55.97 144.39,56.11 144.39,56.39 144.25,56.53 142.86,56.53 142.72,56.67 142.72,56.92 142.88,57.09 144.25,57.09 144.39,57.23 144.39,57.51 144.25,57.64 142.81,57.64 142.67,57.78 142.67,58.01 142.86,58.2 144.25,58.2 144.39,58.34 144.39,58.62 144.25,58.76 142.81,58.76 142.67,58.9 142.67,59.13 142.86,59.32 144.25,59.32 144.39,59.46 144.39,59.74 144.25,59.88 142.81,59.88 142.67,60.02 142.67,60.25 142.86,60.44 144.25,60.44 144.39,60.58 144.39,60.86 144.24,61.01 142.83,61.01 142.69,61.14 142.69,61.37 142.87,61.56 144.27,61.56 144.42,61.7 144.42,61.98 144.28,62.12 143.06,62.12 142.92,62.25 142.92,65.6 141.92,66.6 141.92,66.87 141.71,67.08
DDR4_C2_DQ1: length 67.4
  TOP w0.152: U135.F7 v4(158.76,49.96) ; v2(140.24,72.84) U1.BE30
  07_SIG3 w0.173: 153.97,48.83 154.67,48.13 154.83,48.13 155.16,47.81 155.16,46.6 155.16,46.6 155.16,46.59 155.39,46.36 155.4,46.36 155.4,46.36 158.92,46.36 159.16,46.6 159.16,46.92 159.39,47.16 159.72,47.16 159.96,47.39 159.96,47.94 159.47,48.43 159.26,48.43 159.07,48.23 158.85,48.23 158.7,48.39 158.7,48.6 158.89,48.79 158.89,49.01 158.76,49.14 v4(158.76,49.96) ; v2(140.24,72.84) 140.53,72.84 141.03,72.34 141.44,72.34 141.71,72.08
  07_SIG3 w0.262: 141.71,72.08 142.39,71.39 142.39,68.32 143.33,67.39 144.25,67.39 144.55,67.08 144.55,64.75 146.93,62.37 148.68,62.37 148.82,62.23 148.82,61.74 148.71,61.63 147.38,61.63 147.24,61.49 147.24,61.21 147.38,61.07 148.68,61.07 148.81,60.94 148.81,60.66 148.67,60.52 147.38,60.52 147.24,60.37 147.24,60.09 147.38,59.95 148.68,59.95 148.84,59.8 148.84,59.52 148.72,59.4 147.38,59.4 147.24,59.26 147.24,58.98 147.38,58.84 148.68,58.84 148.82,58.69 148.82,58.41 148.69,58.28 147.38,58.28 147.24,58.14 147.24,57.86 147.38,57.72 148.7,57.72 148.86,57.56 148.86,57.29 148.74,57.16 147.38,57.16 147.24,57.02 147.24,56.74 147.38,56.6 148.7,56.6 148.85,56.45 148.85,56.17 148.73,56.04 147.38,56.04 147.24,55.9 147.24,55.62 147.38,55.48 148.67,55.48 148.82,55.34 148.82,55.06 148.68,54.93 147.38,54.93 147.24,54.79 147.24,54.51 147.38,54.37 148.61,54.37 150.17,52.8 150.64,52.8 150.9,52.54 150.9,52.27 151.04,52.13 151.61,52.13 151.84,51.9 151.84,51.58 151.61,51.35 151.54,51.35 151.31,51.12 151.31,50.76 151.46,50.61 151.79,50.61 151.89,50.71 152.21,50.71 152.44,50.48 152.44,50.15 152.34,50.05 152.34,49.73 152.65,49.42 153.38,49.42 153.97,48.83
DDR4_C2_DQ2: length 65.5
  TOP w0.152: U135.H3 v4(160.36,47.56) ; v2(139.24,74.84) U1.BD32
  07_SIG3 w0.173: 141.75,70.1 141.51,70.34 140.86,70.34 140.74,70.46 140.74,72.1 140.5,72.34 139.9,72.34 139.74,72.51 139.74,74.21 139.62,74.32 139.33,74.32 139.24,74.41 v2(139.24,74.84) ; v4(160.36,47.56) 160.36,47.32 159.96,46.92 159.96,46.59 159.72,46.36 159.39,46.36 159.16,46.13 159.16,45.79 158.93,45.56 155.39,45.56 155.16,45.79 155.16,46.13 154.93,46.36 154.38,46.36 154.2,46.53 154.2,47.15 153.97,47.39 153.97,47.67
  07_SIG3 w0.262: 153.97,47.67 153.42,48.21 152.73,48.21 151.92,49.02 151.92,49.24 150.27,50.89 150.22,50.89 149.89,51.21 149.89,52.16 148.39,53.66 147.16,53.66 146.59,54.24 146.59,55.02 146.45,55.16 145.18,55.16 145.04,55.3 145.04,55.58 145.18,55.72 146.45,55.72 146.59,55.86 146.59,56.14 146.45,56.28 145.18,56.28 145.04,56.41 145.04,56.69 145.18,56.83 146.45,56.83 146.59,56.97 146.59,57.25 146.45,57.39 145.18,57.39 145.04,57.53 145.04,57.81 145.18,57.95 146.45,57.95 146.59,58.09 146.59,58.37 146.45,58.51 145.18,58.51 145.04,58.65 145.04,58.93 145.18,59.07 146.45,59.07 146.59,59.21 146.59,59.49 146.45,59.63 145.18,59.63 145.04,59.77 145.04,60.05 145.18,60.19 146.45,60.19 146.59,60.33 146.59,60.61 146.45,60.75 145.18,60.75 145.04,60.89 145.04,61.16 145.18,61.3 146.45,61.3 146.59,61.44 146.59,61.77 146.15,62.21 145.93,62.21 145.68,61.95 145.46,61.95 145.31,62.11 145.31,62.32 145.56,62.58 145.56,62.79 145.41,62.95 145.19,62.95 144.94,62.69 144.72,62.69 144.57,62.85 144.57,63.06 144.82,63.32 144.82,63.53 144.67,63.69 144.45,63.69 144.2,63.43 143.98,63.43 143.83,63.59 143.83,63.8 144.08,64.06 144.08,64.27 143.72,64.63 143.72,66.02 141.75,68 141.75,70.1
DDR4_C2_DQ3: length 65.6
  TOP w0.152: v2(140.24,75.84) 139.74,75.34 ; U135.H7 v4(160.36,49.96)
  07_SIG3 w0.173: v2(140.24,75.84) 139.74,76.34 138.12,76.34 137.74,75.96 137.74,74.72 137.36,74.34 137.12,74.34 136.74,73.96 136.74,73.72 136.36,73.34 136.12,73.34 135.74,72.96 135.74,68.71 136.1,68.34 136.41,68.34 136.74,68.01 136.74,67.73 137.13,67.34 137.36,67.34 137.74,66.96 137.74,66.15 138.74,65.15 138.74,53.63 139.03,53.34 139.44,53.34 139.74,53.04 139.74,52.68 140.1,52.31 140.49,52.31 140.72,52.08 140.72,51.7 141.12,51.3 141.49,51.3 142.63,50.17 ; 162,44.71 162.05,44.76 162.05,48.17 160.36,49.86 v4(160.36,49.96)
  07_SIG3 w0.262: 142.63,50.17 150.45,42.34 150.67,42.34 152.05,40.97 158.26,40.97 162,44.71
DDR4_C2_DQ4: length 66.1
  TOP w0.152: v2(138.24,75.84) 137.74,75.34 ; U135.H2 v4(160.36,45.96)
  07_SIG3 w0.173: 160.56,44.71 160.76,44.91 160.76,45.56 v4(160.36,45.96) ; v2(138.24,75.84) 138.74,75.34 138.74,73.56 138.52,73.34 138.03,73.34 138.03,73.34 137.74,73.05 137.74,68.64 138.03,68.34 138.44,68.34 138.74,68.05 138.74,67.64 139.03,67.34 139.44,67.34 139.74,67.05 139.74,65.7 139.95,65.48 140.37,65.48 140.74,65.11 140.74,53.61 141,53.34 141.5,53.34 141.84,53 142.15,53 142.59,52.56
  07_SIG3 w0.262: 160.56,44.71 158.99,43.14 158.87,43.14 158.73,43.28 158.73,43.59 158.59,43.73 158.31,43.73 158.17,43.59 158.17,43.28 158.03,43.14 157.75,43.14 157.61,43.28 157.61,43.59 157.47,43.73 157.19,43.73 157.05,43.59 157.05,43.28 156.91,43.14 156.63,43.14 156.49,43.28 156.49,43.59 156.35,43.73 156.07,43.73 155.93,43.59 155.93,43.28 155.8,43.14 155.52,43.14 155.38,43.28 155.38,43.59 155.24,43.73 154.96,43.73 154.82,43.59 154.82,43.28 154.68,43.14 154.26,43.14 153.63,43.77 152.29,43.77 150.8,45.26 150.34,45.26 149.92,45.69 149.72,45.69 149.48,45.44 149.27,45.44 149.07,45.64 149.07,45.83 149.46,46.22 149.46,46.68 148.88,47.26 148.69,47.26 148.16,46.73 147.97,46.73 147.77,46.93 147.77,47.14 148.29,47.66 148.29,47.86 148.09,48.05 147.9,48.05 147.37,47.53 147.17,47.53 146.98,47.73 146.98,47.92 147.5,48.45 147.5,48.65 147.34,48.81 147.02,48.81 146.72,48.51 146.23,48.51 145.34,49.4 145.34,49.63 145.71,50 145.71,51.15 145.57,51.29 144.86,51.29 144.72,51.43 144.72,51.71 144.86,51.85 145.73,51.85 145.86,51.98 145.86,52.22 145.17,52.91 144.84,52.91 144.68,52.74 144.68,52.42 144.35,52.09 143.85,52.09 143.37,52.56 142.59,52.56
DDR4_C2_DQ5: length 65.4
  TOP w0.152: U135.H8 v4(160.36,51.56) ; v2(139.24,75.84) 138.74,75.34
  07_SIG3 w0.173: 141.44,74.34 139.99,74.34 139.74,74.6 139.74,75.34 v2(139.24,75.84) ; v4(160.36,51.56) 159.96,51.96 159.96,53.09
  07_SIG3 w0.262: 141.44,74.34 141.71,74.34 141.76,74.39 145.64,74.39 148.28,71.74 148.28,70.33 148.59,70.02 149.71,70.02 151.08,68.65 151.08,56.57 151.35,56.29 151.61,56.29 151.75,56.15 151.75,54.75 151.89,54.61 152.31,54.61 152.45,54.75 152.45,56.15 152.59,56.29 154.03,56.29 154.26,56.06 154.26,53.7 154.49,53.47 154.81,53.47 155.04,53.7 155.04,56.06 155.27,56.29 155.6,56.29 155.83,56.06 155.83,53.29 156.06,53.06 156.38,53.06 156.61,53.29 156.61,56.06 156.84,56.29 157.17,56.29 157.4,56.06 157.4,53.29 157.63,53.06 157.95,53.06 158.18,53.29 158.18,53.55 158.41,53.78 158.85,53.78 159.08,54.01 159.08,54.33 158.85,54.56 158.41,54.56 158.18,54.79 158.18,56.54 158.41,56.77 159.63,56.77 159.96,56.44 159.96,55.95 159.96,55.95 159.96,53.09
DDR4_C2_DQ6: length 68.6
  TOP w0.152: U135.J3 v4(161.16,47.56) ; v2(138.24,73.84) U1.BC31
  07_SIG3 w0.173: 141.99,51.56 141.76,51.79 141.76,52.06 141.48,52.34 141.01,52.34 140.74,52.61 140.74,53.05 140.44,53.34 139.99,53.34 139.74,53.6 139.74,65.06 138.74,66.06 138.74,67.05 138.44,67.34 138.03,67.34 137.74,67.64 137.74,68.05 137.44,68.34 137.03,68.34 136.74,68.64 136.74,73.05 137.03,73.34 137.42,73.34 137.92,73.84 v2(138.24,73.84) ; v4(161.16,47.56) 161.62,47.1 161.62,44.98 161.34,44.7 161.31,44.7
  07_SIG3 w0.262: 141.99,51.56 142.19,51.56 142.55,51.92 142.76,51.92 142.9,51.78 142.9,51.47 142.69,51.27 142.69,51.06 142.91,50.84 143.05,50.84 143.65,51.44 143.85,51.44 144.05,51.24 144.05,51.04 143.51,50.51 143.51,50.31 143.69,50.13 143.92,50.13 144.44,50.65 144.64,50.65 144.84,50.45 144.84,50.25 144.27,49.68 144.27,49.47 150.01,43.73 151.35,43.73 151.94,43.13 151.94,42.85 151.92,42.85 151.71,42.65 151.71,42.24 152.18,41.77 152.4,41.77 152.54,41.91 152.54,42.4 152.67,42.53 153.74,42.53 153.99,42.29 153.99,41.66 154.12,41.52 154.4,41.52 154.54,41.66 154.54,42.46 154.68,42.6 154.96,42.6 155.1,42.46 155.1,41.66 155.24,41.52 155.52,41.52 155.66,41.66 155.66,42.46 155.8,42.6 156.08,42.6 156.22,42.46 156.22,41.66 156.36,41.52 156.64,41.52 156.78,41.66 156.78,42.46 156.92,42.6 157.2,42.6 157.34,42.46 157.34,41.66 157.48,41.52 157.76,41.52 157.9,41.66 157.9,42.46 158.04,42.6 159.2,42.6 161.31,44.7
DDR4_C2_DQ7: length 67.6
  TOP w0.152: U135.J7 v4(161.16,49.96) ; v2(139.24,73.84) U1.BD31
  07_SIG3 w0.089: 159.96,44.74 159.93,44.71
  07_SIG3 w0.173: 159.96,44.74 159.96,46.13 160.19,46.36 160.63,46.36 160.76,46.48 160.76,47.92 159.96,48.72 159.96,50.18 160.14,50.36 160.76,50.36 v4(161.16,49.96) ; v2(139.24,73.84) 139.24,73.54 138.74,73.04 138.74,68.53 138.92,68.34 139.61,68.34 139.74,68.21 139.74,67.48 139.87,67.34 140.61,67.34 140.74,67.21 140.74,65.66 140.87,65.53 141.12,65.53 141.45,65.86 141.83,65.86 142.01,65.69 142.01,64.9
  07_SIG3 w0.262: 142.01,64.9 142.01,54.06 142.85,53.21 143.99,53.21 144.34,53.56 145.44,53.56 146.71,52.28 147.92,52.28 148.6,51.6 148.6,51.27 148.46,51.13 147.95,51.13 147.57,51.51 146.66,51.51 146.36,51.21 146.36,50.71 146.5,50.57 148.39,50.57 148.56,50.41 148.56,50.13 148.44,50.02 146.5,50.02 146.36,49.88 146.36,49.6 146.5,49.46 148.46,49.46 148.6,49.32 148.6,48.47 148.74,48.32 148.94,48.32 149.48,48.86 149.68,48.86 149.89,48.66 149.89,48.48 149.33,47.93 149.33,47.73 150.16,46.91 150.8,46.91 151.61,46.09 151.61,45.9 151.49,45.78 151.49,45.58 151.69,45.39 151.89,45.39 152.01,45.5 153.09,45.5 154.36,44.23 159.45,44.23 159.93,44.71
DDR4_C2_DQ8: length 54.8
  TOP w0.152: U1.BA32 v2(136.24,74.84) ; U135.A3 v4(154.76,47.56)
  14_SIG4 w0.089: v2(136.24,74.84) 136.74,74.34 137.44,74.34 137.74,74.64 137.74,75.05 138.03,75.34 138.44,75.34 138.74,75.64 138.74,76.05 139.03,76.34 139.44,76.34 139.74,76.64 139.74,77.05 140.03,77.34 141.46,77.34 141.71,77.09 ; 153.97,48.29 154.58,48.29 154.76,48.12 v4(154.76,47.56)
  14_SIG4 w0.14: 141.71,77.09 142.76,76.04 143.03,76.04 143.62,76.63 143.89,76.63 144.16,76.36 144.16,76.1 143.57,75.5 143.57,75.23 143.84,74.96 144.11,74.96 144.7,75.56 144.97,75.56 145.24,75.29 145.24,75.02 144.64,74.43 144.64,74.16 144.91,73.89 145.18,73.89 145.78,74.48 146.04,74.48 146.31,74.21 146.31,73.94 145.72,73.35 145.72,73.08 146.97,71.83 146.97,67.91 147.4,67.48 149.8,67.48 150.22,67.06 150.22,64.59 147.24,61.62 147.24,60.95 148.6,59.6 148.6,54.19 151.19,51.6 151.19,50.05 152.94,48.29 153.97,48.29
DDR4_C2_DQ9: length 52.6
  TOP w0.152: 136.74,75.34 v2(137.24,75.84) ; U135.B8 v4(155.56,51.56)
  14_SIG4 w0.089: v4(155.56,51.56) 155.56,51.32 155.96,50.92 155.96,49.79 155.72,49.56 154.23,49.56 153.97,49.83 ; 141.71,79.34 140.03,79.34 139.74,79.05 139.74,78.64 139.44,78.34 139.03,78.34 138.74,78.05 138.74,77.64 138.44,77.34 138.03,77.34 137.74,77.05 137.74,76.55 137.24,76.05 v2(137.24,75.84)
  14_SIG4 w0.14: 153.97,49.83 153.77,50.02 153.77,50.57 153.47,50.88 152.96,50.88 152.59,51.25 152.59,52.04 149.89,54.73 149.89,60.54 149.66,60.78 149.25,60.78 149.02,61.01 149.02,61.57 151.51,64.06 151.51,67.59 150.27,68.83 149,68.83 148.74,69.09 148.74,71.68 148.6,71.82 148.5,71.82 148.36,71.96 148.36,72.24 148.5,72.38 148.6,72.38 148.74,72.52 148.74,74.05 144.49,78.29 144.23,78.29 144,78.07 143.73,78.07 143.46,78.34 143.46,78.61 143.69,78.83 143.69,79.1 143.44,79.34 141.71,79.34
DDR4_C2_DQ10: length 54
  TOP w0.152: U135.C3 v4(156.36,47.56) ; U1.BA30 v2(136.24,72.84)
  14_SIG4 w0.089: v4(156.36,47.56) 156.76,47.16 156.76,46.59 156.52,46.36 156.2,46.36 155.96,46.12 155.96,46.1 155.96,46.09 155.96,44.71 ; v2(136.24,72.84) 136.74,72.34 138.44,72.34 138.74,72.64 138.74,73.05 139.03,73.34 139.44,73.34 139.74,73.64 139.74,74.05 140.03,74.34 141.46,74.34 141.66,74.15
  14_SIG4 w0.14: 141.66,74.15 144.82,70.98 144.82,63.8 145.3,63.31 145.3,60.15 146.66,58.79 146.66,53.37 148.37,51.66 148.37,49.02 149.08,48.31 149.08,45.72 149.22,45.59 149.48,45.59 149.93,46.03 149.93,46.67 150.11,46.85 150.75,46.85 152.54,45.07 152.54,44.43 153.06,43.91 153.38,43.91 153.59,43.7 155.9,43.7 156.15,43.96 156.15,44.24 155.96,44.44 155.96,44.71
DDR4_C2_DQ11: length 54.5
  TOP w0.152: U135.C7 v4(156.36,49.96) ; U1.BA31 v2(136.24,73.84)
  14_SIG4 w0.089: v4(156.36,49.96) 156.36,49.58 155.85,49.07 153.97,49.07 ; 141.71,78.34 140.03,78.34 139.74,78.05 139.74,77.64 139.44,77.34 139.03,77.34 138.74,77.05 138.74,76.64 138.44,76.34 137.95,76.34 137.74,76.13 137.74,75.64 137.44,75.34 136.03,75.34 135.74,75.05 135.74,74.34 v2(136.24,73.84)
  14_SIG4 w0.14: 153.97,49.07 153.73,49.07 153.43,49.38 152.86,49.38 151.89,50.35 151.89,51.82 149.25,54.46 149.25,59.87 148.16,60.95 148.16,61.62 150.86,64.32 150.86,67.32 150,68.18 147.93,68.18 147.67,68.45 147.67,70.35 148.05,70.72 148.05,71.11 147.67,71.49 147.67,72.39 147.25,72.8 147.04,72.8 146.85,72.99 146.85,73.37 147.04,73.56 147.51,73.56 147.77,73.82 147.77,74.03 144.43,77.37 142.68,77.37 141.71,78.34
DDR4_C2_DQ12: length 56.2
  TOP w0.152: U135.C2 v4(156.36,45.96) ; U1.AW31 v2(134.24,73.84)
  14_SIG4 w0.089: v4(156.36,45.96) 156.76,45.56 156.76,44.71 ; 141.81,72.99 141.46,73.34 140.03,73.34 139.74,73.05 139.74,72.64 139.44,72.34 139.03,72.34 138.74,72.05 138.74,71.64 138.44,71.34 136.03,71.34 135.74,71.64 135.74,72.05 135.44,72.34 135.03,72.34 134.74,72.64 134.74,73.29 134.24,73.79 v2(134.24,73.84)
  14_SIG4 w0.14: 141.81,72.99 144.12,70.68 144.12,63.51 144.65,62.97 144.65,59.88 146.01,58.52 146.01,53.1 147.67,51.44 147.67,48.72 148.38,48.01 148.38,46.04 148.38,46.04 148.38,45.01 148.66,44.73 149.62,44.73 150.3,45.42 150.77,45.42 151.84,44.35 151.84,44.14 152.4,43.58 152.4,43.1 153.04,42.46 153.52,42.46 154.11,43.05 156.31,43.05 156.76,43.49 156.76,44.71
DDR4_C2_DQ13: length 55.3
  TOP w0.152: U1.AW32 v2(134.24,74.84) ; U135.C8 v4(156.36,51.56)
  14_SIG4 w0.089: v4(156.36,51.56) 156.76,51.96 156.76,52.97 156.63,53.09 ; v2(134.24,74.84) 133.74,75.34 133.74,77.05 134.03,77.34 134.44,77.34 134.74,77.64 134.74,78.05 135.03,78.34 135.44,78.34 135.74,78.64 135.74,79.05 136.03,79.34 136.44,79.34 136.74,79.64 136.74,80.05 137.03,80.34 137.44,80.34 137.74,80.64 137.74,81.05 138.03,81.34 138.44,81.34 138.74,81.64 138.74,82.05 139.03,82.34 142.63,82.34
  14_SIG4 w0.14: 142.63,82.34 143.08,82.34 143.3,82.56 145.4,82.56 150.29,77.67 151.27,77.67 152.35,76.6 152.35,70.36 154.13,68.58 154.13,65.18 154.29,65.01 154.29,55.44 156.63,53.09
DDR4_C2_DQ14: length 54.8
  TOP w0.152: U1.AY32 v2(135.24,74.84) ; U135.D3 v4(157.16,47.56)
  14_SIG4 w0.089: 141.67,75.13 141.46,75.34 140.03,75.34 139.74,75.05 139.74,74.64 139.44,74.34 139.03,74.34 138.74,74.05 138.74,73.64 138.44,73.34 135.03,73.34 134.74,73.64 134.74,74.74 134.84,74.84 v2(135.24,74.84) ; 153.97,45.98 154.16,45.98 154.57,45.56 154.92,45.56 155.16,45.79 155.16,46.12 155.39,46.36 155.72,46.36 155.96,46.59 155.96,48.14 156.39,48.57 157.67,48.57 157.84,48.4 157.84,48.09 157.67,47.92 157.52,47.92 v4(157.16,47.56)
  14_SIG4 w0.14: 153.97,45.98 153.67,45.98 153.27,45.57 153.27,45.56 153.03,45.56 151.72,46.87 151.72,47.54 151,48.26 150.3,48.26 149.07,49.49 149.07,51.88 147.3,53.64 147.3,59.06 145.95,60.42 145.95,63.81 145.52,64.25 145.52,71.28 141.67,75.13
DDR4_C2_DQ15: length 54.7
  TOP w0.152: U135.D7 v4(157.16,49.96) ; 134.74,75.34 v2(135.24,75.84)
  14_SIG4 w0.089: v2(135.24,75.84) 134.74,76.34 134.74,77.05 135.03,77.34 135.39,77.34 135.74,77.69 135.74,78.05 136.03,78.34 136.44,78.34 136.74,78.64 136.74,79.05 137.03,79.34 137.44,79.34 137.74,79.64 137.74,80.05 138.03,80.34 138.44,80.34 138.74,80.64 138.74,81.05 139.03,81.34 142.63,81.34 ; 155.5,53.09 155.96,52.63 155.96,51.39 156.19,51.16 156.52,51.16 156.76,50.92 156.76,50.36 v4(157.16,49.96)
  14_SIG4 w0.14: 155.5,53.09 155.15,53.44 154,53.44 152.83,54.61 152.83,62.26 153.67,63.09 153.67,64.72 153.39,65 153.39,68.1 151.51,69.98 151.51,73.33 151,73.84 151,74.3 151.51,74.8 151.51,75.23 144.93,81.8 143.89,81.8 143.43,81.34 142.63,81.34
DDR4_C2_DQ16: length 46.2
  TOP w0.152: U136.G2 v4(159.56,60.06) ; U1.AV30 v2(133.24,72.84)
  05_SIG2 w0.173: v4(159.56,60.06) 159.16,60.46 159.16,61.09 159.32,61.26 159.8,61.26 159.96,61.41 159.96,61.93 160.09,62.06 160.24,62.06 160.5,62.32 160.5,62.62 160.37,62.75 159.15,62.75 159,62.9 157.19,62.9 156.88,63.21 153.98,63.21 153.97,63.23 ; v2(133.24,72.84) 133.62,72.84 134.12,72.34 134.44,72.34 134.74,72.05 134.74,71.64 135.03,71.34 135.44,71.34 135.74,71.05 135.74,70.67 136.07,70.34 136.44,70.34 136.74,70.05 136.74,69.64 137.03,69.34 137.44,69.34 137.74,69.05 137.74,68.64 138.03,68.34 138.44,68.34 138.74,68.05 138.74,67.64 139.03,67.34 139.44,67.34 139.74,67.05 139.74,66.64 140.13,66.25 141.68,66.25 142.63,65.31
  05_SIG2 w0.262: 142.63,65.31 142.77,65.17 142.99,65.17 143.21,65.39 143.41,65.39 143.6,65.19 143.6,64.99 143.38,64.77 143.38,64.57 143.58,64.38 143.78,64.38 144,64.6 144.2,64.6 144.39,64.4 144.39,64.2 144.17,63.98 144.17,63.78 144.37,63.58 144.57,63.58 144.79,63.81 144.99,63.81 145.18,63.61 145.18,63.41 144.96,63.19 144.96,62.99 145.16,62.79 145.36,62.79 145.58,63.02 145.78,63.02 145.97,62.82 145.97,62.62 145.75,62.4 145.75,62.2 146.66,61.3 148.6,61.3 149.14,60.76 152.85,60.76 153.09,61 153.09,61.64 152.52,62.21 152.52,63.65 152.72,63.85 153.34,63.85 153.97,63.23
DDR4_C2_DQ17: length 45.6
  TOP w0.152: U1.AW30 v2(134.24,72.84) ; U136.F7 v4(158.76,64.06)
  05_SIG2 w0.173: v4(158.76,64.06) 158.36,63.66 157.79,63.66 157.79,63.66 157.74,63.66 157.56,63.84 157.56,64.26 157.36,64.46 154.59,64.46 154.36,64.69 154.36,65.18 153.97,65.57 ; v2(134.24,72.84) 134.09,72.84 133.59,73.34 133.03,73.34 132.74,73.64 132.74,74.05 133.03,74.34 134.44,74.34 134.74,74.05 134.74,73.64 135.03,73.34 135.44,73.34 135.74,73.05 135.74,72.64 136.03,72.34 136.44,72.34 136.74,72.05 136.74,71.64 137.03,71.34 137.44,71.34 137.74,71.05 137.74,70.64 138.03,70.34 138.44,70.34 138.74,70.05 138.74,69.64 139.03,69.34 139.44,69.34 139.74,69.05 139.74,68.64 140.03,68.34 142.29,68.34 142.63,68
  05_SIG2 w0.262: 153.97,65.57 153.72,65.82 153.72,66.59 153.47,66.83 153.47,67.31 153,67.78 151.3,67.78 150.96,67.44 150.96,62.9 150.75,62.7 150.05,62.7 149.88,62.87 149.88,63.56 149.74,63.7 149.46,63.7 149.32,63.56 149.32,62.77 149.18,62.63 148,62.63 142.63,68
DDR4_C2_DQ18: length 45.1
  TOP w0.152: 131.74,75.34 v2(132.24,75.84) ; U136.H3 v4(160.36,61.66)
  05_SIG2 w0.173: v2(132.24,75.84) 131.74,76.34 131.74,77.05 132.03,77.34 132.44,77.34 132.74,77.64 132.74,78.05 133.03,78.34 134.44,78.34 134.74,78.05 134.74,77.64 135.03,77.34 135.44,77.34 135.74,77.05 135.74,76.64 136.03,76.34 136.44,76.34 136.74,76.05 136.74,75.64 137.03,75.34 137.44,75.34 137.74,75.05 137.74,74.64 138.03,74.34 138.44,74.34 138.74,74.05 138.74,73.64 139.03,73.34 139.44,73.34 139.74,73.05 139.74,72.64 140.03,72.34 142.63,72.34 ; 160.99,67.19 161.56,66.62 161.56,62.86 v4(160.36,61.66)
  05_SIG2 w0.262: 160.99,67.19 157.75,70.43 144.71,70.43 142.8,72.34 142.63,72.34
DDR4_C2_DQ19: length 42.6
  TOP w0.152: U1.AU34 v2(132.24,76.84) ; U136.H7 v4(160.36,64.06)
  05_SIG2 w0.173: 160.19,67.19 160.76,66.62 160.76,64.46 v4(160.36,64.06) ; v2(132.24,76.84) 132.54,76.84 133.04,77.34 134.44,77.34 134.74,77.05 134.74,76.64 135.03,76.34 135.44,76.34 135.74,76.05 135.74,75.64 136.03,75.34 136.44,75.34 136.74,75.05 136.74,74.64 137.03,74.34 137.44,74.34 137.74,74.05 137.74,73.64 138.03,73.34 138.44,73.34 138.74,73.05 138.74,72.64 139.03,72.34 139.44,72.34 139.74,72.05 139.74,71.64 140.03,71.34 142.5,71.34 142.63,71.22
  05_SIG2 w0.262: 160.19,67.19 159.42,67.96 159.23,67.96 158.6,67.34 158.41,67.34 158.21,67.53 158.21,67.73 158.83,68.35 158.83,68.55 158.63,68.75 158.43,68.75 157.81,68.13 157.62,68.13 157.42,68.32 157.42,68.52 158.04,69.14 158.04,69.34 157.59,69.78 144.06,69.78 142.63,71.22
DDR4_C2_DQ20: length 46.6
  TOP w0.152: U1.AT31 v2(131.24,73.84) ; U136.H2 v4(160.36,60.06)
  05_SIG2 w0.173: v4(160.36,60.06) 160.76,59.66 160.76,58.81 ; v2(131.24,73.84) U1.AT31 130.74,71.64 131.03,71.34 131.44,71.34 131.74,71.05 131.74,70.64 132.03,70.34 132.44,70.34 132.74,70.05 132.74,69.64 133.03,69.34 133.44,69.34 133.74,69.05 133.74,68.64 134.03,68.34 134.44,68.34 134.74,68.05 134.74,67.64 135.03,67.34 135.44,67.34 135.74,67.05 135.74,66.64 136.03,66.34 136.44,66.34 137.74,65.05 137.74,64.64 138.03,64.34 138.44,64.34 138.74,64.05 138.74,63.64 139.03,63.34 139.44,63.34 139.74,63.05 139.74,62.64 140.03,62.34 140.47,62.34 140.74,62.07 140.74,61.58 141,61.32 141.71,61.32 142.63,60.41
  05_SIG2 w0.262: 160.76,58.81 160.76,58.4 157.66,55.3 154.56,55.3 153.64,54.38 149.16,54.38 143.13,60.41 142.63,60.41
DDR4_C2_DQ21: length 44.9
  TOP w0.152: U1.AU32 v2(132.24,74.84) ; U136.H8 v4(160.36,65.66)
  05_SIG2 w0.173: v4(160.36,65.66) 159.96,66.06 159.96,66.62 159.64,66.94 155.88,66.94 155.79,67.03 155.79,67.19 ; 142.63,69.94 142.23,70.34 140.03,70.34 139.74,70.64 139.74,71.05 139.44,71.34 139.03,71.34 138.74,71.64 138.74,72.05 138.44,72.34 138.03,72.34 137.74,72.64 137.74,73.05 137.44,73.34 137.03,73.34 136.74,73.64 136.74,74.05 136.44,74.34 136.03,74.34 135.74,74.64 135.74,75.05 135.44,75.34 135.03,75.34 134.74,75.64 134.74,76.05 134.44,76.34 133.03,76.34 132.74,76.05 132.74,75.34 v2(132.24,74.84)
  05_SIG2 w0.262: 142.63,69.94 143.43,69.14 146.51,69.14 146.65,69 146.65,68.21 146.79,68.07 147.02,68.07 147.2,68.26 147.2,69 147.34,69.14 154.36,69.14 154.59,68.91 154.79,68.91 155.21,69.33 155.41,69.33 155.61,69.13 155.61,68.94 154.8,68.13 154.8,67.91 154.98,67.73 155.18,67.73 156.69,69.24 156.9,69.24 157.09,69.05 157.09,68.85 155.79,67.54 155.79,67.19
DDR4_C2_DQ22: length 46.1
  TOP w0.152: U1.AU31 v2(132.24,73.84) ; U136.J3 v4(161.16,61.66)
  05_SIG2 w0.173: v2(132.24,73.84) U1.AU31 131.74,71.64 132.03,71.34 132.44,71.34 132.74,71.05 132.74,70.64 133.03,70.34 133.44,70.34 133.74,70.05 133.74,69.64 134.03,69.34 134.44,69.34 134.74,69.05 134.74,68.64 135.03,68.34 135.44,68.34 135.74,68.05 135.74,67.64 136.03,67.34 136.44,67.34 136.74,67.05 136.74,66.64 137.03,66.34 137.59,66.34 138.74,65.2 138.74,64.64 139.03,64.34 139.44,64.34 139.74,64.05 139.74,63.64 140.03,63.34 140.58,63.34 140.77,63.15 140.77,62.54 140.97,62.34 141.65,62.34 141.95,62.04 141.95,61.6 142.23,61.32 142.63,61.32 ; v4(161.16,61.66) 160.76,61.26 160.76,60.69 160.52,60.46 160.19,60.46 159.96,60.22 159.96,58.81
  05_SIG2 w0.262: 142.63,61.32 143.15,61.32 148.95,55.52 152.63,55.52 153.36,56.24 157.69,56.24 159.96,58.51 159.96,58.81
DDR4_C2_DQ23: length 45.6
  TOP w0.152: U136.J7 v4(161.16,64.06) ; U1.AV31 v2(133.24,73.84)
  05_SIG2 w0.173: v2(133.24,73.84) 133.53,73.84 134.03,73.34 134.44,73.34 134.74,73.05 134.74,72.64 135.03,72.34 135.44,72.34 135.74,72.05 135.74,71.64 136.03,71.34 136.44,71.34 136.74,71.05 136.74,70.64 137.03,70.34 137.44,70.34 137.74,70.05 137.74,69.64 138.03,69.34 138.44,69.34 138.74,69.05 138.74,68.64 139.03,68.34 139.44,68.34 139.74,68.05 139.74,67.64 140.03,67.34 142.36,67.34 142.63,67.08 ; 153.97,64.27 154.59,63.64 157.11,63.64 157.48,63.27 158.78,63.27 158.95,63.45 159.13,63.45 159.23,63.35 159.23,63.23 159.31,63.14 159.49,63.14 159.58,63.23 159.58,63.55 159.68,63.65 159.86,63.65 159.94,63.57 159.94,63.23 160.03,63.14 160.2,63.14 160.29,63.23 160.29,63.49 160.39,63.58 160.56,63.58 160.65,63.5 160.65,63.23 160.74,63.14 161.02,63.14 161.16,63.27 v4(161.16,64.06)
  05_SIG2 w0.262: 153.97,64.27 153.74,64.5 153.74,64.83 153.07,65.5 153.07,65.81 152.91,65.97 152.55,65.97 152.42,66.1 152.42,66.63 152.31,66.73 151.79,66.73 151.65,66.59 151.65,61.73 151.35,61.43 149.54,61.43 148.99,61.99 147.72,61.99 142.63,67.08
DDR4_C2_DQ24: length 59.8
  TOP w0.152: 129.74,75.34 v2(130.24,75.84) ; U136.A3 v4(154.76,61.66)
  03_SIG1 w0.173: 142.63,79.22 142.38,79.22 142.19,79.03 142.19,78.31 141.89,78.01 141.89,77.69 142.2,77.39 142.2,76.96 142.11,76.87 141.84,76.87 141.73,76.98 141.73,77.19 141.58,77.34 133.03,77.34 132.74,77.05 132.74,76.64 132.44,76.34 130.95,76.34 130.45,75.84 v2(130.24,75.84) ; v4(154.76,61.66) 154.76,62.21 154.51,62.46 154.51,62.76 154.6,62.85 154.72,62.85 155.08,62.5 155.22,62.5 155.34,62.61 155.34,62.74 155.2,62.88 155.2,63 155.33,63.13 155.5,63.13 155.66,62.97 155.79,62.97 155.96,63.13 155.96,64.31 155.81,64.46 155.3,64.46 155.16,64.6 155.16,65.12 155.03,65.26 154.11,65.26 154.01,65.36 154.01,65.98 153.97,66.02
  03_SIG1 w0.262: 153.97,66.02 153.72,66.27 153.72,67.34 153.47,67.59 153.47,68.15 153.29,68.33 152.73,68.33 150.83,70.23 150.39,70.23 149.99,70.63 149.61,70.63 149.21,70.23 148.39,70.23 148.22,70.4 148.22,71.1 148.41,71.3 149.29,71.3 149.47,71.48 149.47,71.74 149.29,71.92 148.4,71.92 148.22,72.1 148.22,72.36 148.4,72.54 149.29,72.54 149.47,72.72 149.47,72.97 149.29,73.15 148.26,73.15 148.08,73.33 148.08,73.63 148.56,74.12 148.74,74.12 149.09,73.77 149.49,73.77 149.82,74.1 149.82,74.42 149.53,74.71 149.53,79.37 148.97,79.93 148.77,79.93 148.61,79.77 148.61,79.14 148.49,79.02 148.19,79.02 148.04,79.17 148.04,79.87 147.9,80.01 147.63,80.01 147.49,79.87 147.49,79.44 147.18,79.13 147.18,78.77 147.03,78.63 146.77,78.63 146.62,78.78 146.62,79.07 146.48,79.21 145.5,79.21 145.32,79.03 144.75,79.03 144.55,79.22 142.63,79.22
DDR4_C2_DQ25: length 58.8
  TOP w0.152: U1.AT34 v2(131.24,76.84) ; U136.B8 v4(155.56,65.66)
  03_SIG1 w0.173: 155.32,67.19 155.25,67.13 154.5,67.13 154.31,66.93 154.31,66.24 154.49,66.06 155.37,66.06 155.56,65.87 v4(155.56,65.66) ; v2(131.24,76.84) 131.45,76.84 131.95,77.34 132.44,77.34 132.74,77.64 132.74,78.05 133.03,78.34 141.5,78.34 141.74,78.58 141.74,80.01 142.4,80.67 142.63,80.67
  03_SIG1 w0.262: 142.63,80.67 142.71,80.67 142.85,80.53 142.85,80.01 142.99,79.87 143.27,79.87 143.41,80.01 143.41,80.53 143.55,80.67 143.83,80.67 143.97,80.53 143.97,80.01 144.11,79.87 144.39,79.87 144.53,80.01 144.53,80.53 144.67,80.67 144.95,80.67 145.09,80.53 145.09,80.01 145.23,79.87 145.51,79.87 145.65,80.01 145.65,80.53 145.79,80.67 146.07,80.67 146.21,80.53 146.21,80.01 146.35,79.87 146.63,79.87 146.77,80.01 146.77,80.53 146.9,80.67 149.18,80.67 150.12,79.73 150.12,79.69 150.17,79.64 150.17,76.61 150.67,76.11 150.67,75.72 150.3,75.34 150.3,74.95 150.67,74.58 150.67,73.96 150.13,73.42 150.13,71.41 150.53,71 151.05,71 152.3,69.76 152.82,69.76 152.97,69.6 152.97,69.15 153.11,69.01 153.39,69.01 153.53,69.15 153.53,69.62 153.67,69.76 153.94,69.76 154.09,69.6 154.09,67.97 154.23,67.83 154.51,67.83 154.71,68.03 154.71,70.48 154.91,70.69 155.24,70.69 155.39,70.54 155.39,70.2 155.53,70.06 156.1,70.06 156.34,69.82 156.34,69.64 156.2,69.5 155.53,69.5 155.39,69.36 155.39,69.08 155.53,68.94 156.2,68.94 156.34,68.8 156.34,68.52 156.2,68.38 155.53,68.38 155.39,68.24 155.39,67.27 155.32,67.19
DDR4_C2_DQ26: length 63.5
  TOP w0.152: U136.C3 v4(156.36,61.66) ; U1.AT29 130.74,71.34 v2(131.24,71.84)
  03_SIG1 w0.173: 142.63,74.61 141.93,74.61 141.66,74.34 132.85,74.34 132.74,74.23 132.74,73.46 132.62,73.34 131.95,73.34 131.74,73.13 131.74,72.61 131.24,72.11 v2(131.24,71.84) ; 156.04,58.81 155.96,58.9 155.96,59.26 155.96,59.26 155.96,61.57 156.05,61.66 v4(156.36,61.66)
  03_SIG1 w0.262: 156.04,58.81 156.26,58.59 160.21,58.59 160.35,58.45 160.35,54.96 159.74,54.36 158.86,54.36 158.6,54.62 158.6,55.55 158.34,55.8 155.04,55.8 154.86,55.98 153.24,55.98 152.98,56.24 152.98,56.61 153.12,56.75 154.14,56.75 154.35,56.96 154.35,57.31 154.2,57.45 153.12,57.45 152.84,57.74 152.84,61.61 152.83,61.62 152.83,61.75 150.85,63.73 150.85,66.4 149.51,67.74 146.8,67.74 146.58,67.52 146.58,67.07 146.44,66.92 145.99,66.92 145.64,67.27 145.64,70.08 143.13,72.59 143.13,74.45 142.96,74.61 142.63,74.61
DDR4_C2_DQ27: length 62.5
  TOP w0.152: U1.AT30 v2(131.24,72.84) ; U136.C7 v4(156.36,64.06)
  03_SIG1 w0.173: v4(156.36,64.06) 156.36,63.02 155.16,61.82 155.16,58.81 ; v2(131.24,72.84) 131.24,73.14 131.74,73.64 131.74,74.14 131.94,74.34 132.44,74.34 132.74,74.64 132.74,75.05 133.03,75.34 142.63,75.34
  03_SIG1 w0.262: 155.16,58.81 155.16,58.73 155.8,58.09 156.39,58.09 156.6,57.88 156.6,57.41 156.73,57.28 157.14,57.28 157.35,57.49 157.35,57.89 157.56,58.09 159.64,58.09 159.88,57.85 159.88,56.72 159.58,56.43 159.17,56.43 158.99,56.61 158.99,57.24 158.8,57.43 158.43,57.43 158.24,57.24 158.24,56.55 157.97,56.28 155.76,56.28 155.5,56.55 155.5,57.33 154.17,58.66 154.17,61.61 154.01,61.78 154.01,62.5 153.75,62.75 153.38,62.75 153.32,62.68 152.84,62.68 151.98,63.55 151.98,63.92 152.24,64.18 152.4,64.18 152.57,64.35 152.57,64.74 152.38,64.92 152,64.92 151.69,65.24 151.69,66.75 150.01,68.43 146.7,68.43 146.41,68.73 146.41,71.4 145.72,72.09 144.55,72.09 143.79,72.85 143.79,74.85 143.3,75.34 142.63,75.34
DDR4_C2_DQ28: length 61.6
  TOP w0.152: U136.C2 v4(156.36,60.06) ; v2(129.24,72.84) U1.AP30
  03_SIG1 w0.173: v2(129.24,72.84) 129.74,72.34 130.44,72.34 130.74,72.05 130.74,71.64 131.03,71.34 131.44,71.34 131.74,71.64 131.74,72.05 132.03,72.34 132.44,72.34 132.74,72.64 132.74,73.05 133.03,73.34 142.3,73.34 142.52,73.13 142.52,72.26 142.63,72.16 ; v4(156.36,60.06) 156.76,59.66 160.52,59.66 160.76,59.42 160.76,59.01 160.95,58.81
  03_SIG1 w0.262: 160.95,58.81 161.21,58.56 161.21,54.88 160.1,53.77 158.45,53.77 157.73,54.48 157.2,54.48 156.97,54.71 156.97,54.96 156.74,55.19 156.42,55.19 156.19,54.96 156.19,54.71 155.96,54.48 155.63,54.48 155.4,54.71 155.4,54.96 155.17,55.19 154.85,55.19 154.62,54.96 154.62,54.71 154.39,54.48 152.76,54.48 152.2,55.04 152.2,61.35 150.17,63.37 147.47,63.37 144.96,65.89 144.96,69.82 142.63,72.16
DDR4_C2_DQ29: length 63.2
  TOP w0.152: U1.AR30 v2(130.24,72.84) ; U136.C8 v4(156.36,65.66)
  03_SIG1 w0.173: 156.76,67.19 156.76,66.06 v4(156.36,65.66) ; 142.63,82.44 141.53,81.34 141.03,81.34 140.74,81.05 140.74,80.64 140.44,80.34 132.97,80.34 132.74,80.11 132.74,79.64 132.44,79.34 132.03,79.34 131.74,79.05 131.74,78.64 131.44,78.34 131.03,78.34 130.74,78.05 130.74,77.64 130.44,77.34 130.03,77.34 129.74,77.05 129.74,76.64 129.44,76.34 129.03,76.34 128.74,76.05 128.74,73.64 129.03,73.34 129.74,73.34 v2(130.24,72.84)
  03_SIG1 w0.262: 142.63,82.44 143.18,82.99 143.56,82.99 143.7,82.86 143.7,82.14 143.84,82 144.11,82 144.25,82.14 144.25,82.86 144.39,82.99 144.67,82.99 144.81,82.86 144.81,82.14 144.95,82 145.23,82 145.37,82.14 145.37,82.86 145.51,82.99 145.79,82.99 145.93,82.86 145.93,82.14 146.07,82 146.35,82 146.49,82.14 146.49,82.86 146.63,82.99 146.91,82.99 147.05,82.86 147.05,82.14 147.19,82 147.47,82 147.61,82.14 147.61,82.86 147.75,82.99 148.03,82.99 148.17,82.86 148.17,82.14 148.31,82 148.59,82 148.73,82.14 148.73,82.86 148.86,82.99 149.26,82.99 150.66,81.59 151.76,81.59 151.96,81.39 151.96,72.05 152.91,71.09 153.4,71.09 154.04,71.73 155.77,71.73 157.89,69.62 157.89,68.32 156.76,67.19
DDR4_C2_DQ30: length 63.3
  TOP w0.152: v2(128.24,72.84) U1.AN30 ; U136.D3 v4(157.16,61.66)
  03_SIG1 w0.173: v2(128.24,72.84) 127.74,73.34 127.03,73.34 126.74,73.64 126.74,76.05 127.03,76.34 127.44,76.34 127.74,76.64 127.74,77.05 128.03,77.34 128.44,77.34 128.74,77.64 128.74,78.1 128.98,78.34 129.44,78.34 129.74,78.64 129.74,79.05 130.03,79.34 130.44,79.34 130.74,79.64 130.74,81.05 131.03,81.34 131.44,81.34 131.74,81.64 131.74,82.05 132.03,82.34 140.44,82.34 140.74,82.64 140.74,83.05 141.03,83.34 141.51,83.34 142.51,84.34 142.63,84.34 ; 158.92,67.19 158.36,66.63 158.36,63.32 157.16,62.12 v4(157.16,61.66)
  03_SIG1 w0.262: 158.92,67.19 159.03,67.3 159.03,69.8 156.08,72.75 154.64,72.75 154.23,73.15 154.23,81.81 153.22,82.83 152.94,82.83 151.61,84.16 150.43,84.16 150.24,84.34 142.63,84.34
DDR4_C2_DQ31: length 61.1
  TOP w0.152: U136.D7 v4(157.16,64.06) ; v2(128.24,73.84) U1.AN31
  03_SIG1 w0.173: v2(128.24,73.84) 127.83,73.84 127.74,73.93 127.74,76.17 127.91,76.34 128.64,76.34 128.74,76.44 128.74,77.17 128.91,77.34 129.62,77.34 129.74,77.46 129.74,78.2 129.88,78.34 130.57,78.34 130.74,78.51 130.74,79.12 130.96,79.34 131.6,79.34 131.74,79.48 131.74,81.17 131.91,81.34 140.44,81.34 140.74,81.64 140.74,82.05 141.03,82.34 141.88,82.34 142.06,82.52 142.06,83 142.63,83.56 ; 157.56,67.19 157.56,67.18 157.56,64.16 157.45,64.06 v4(157.16,64.06)
  03_SIG1 w0.262: 142.63,83.56 142.72,83.66 149.78,83.66 149.98,83.46 149.98,83.19 150.81,82.36 151.14,82.36 151.28,82.5 151.28,83.03 151.42,83.17 151.69,83.17 152.05,82.8 152.05,82.45 152.2,82.3 152.42,82.3 152.6,82.12 152.6,75.39 152.91,75.08 153.35,75.08 153.72,74.71 153.72,74.17 153.26,73.71 152.88,73.71 152.6,73.43 152.6,72.75 152.96,72.39 153.99,72.39 154.14,72.25 155.92,72.25 158.55,69.62 158.55,68.17 157.56,67.19
DDR4_C2_DQ32: length 45
  TOP w0.152: U137.G2 v4(159.56,74.15) ; v2(140.24,76.84) U1.BE34
  07_SIG3 w0.173: v4(159.56,74.15) 159.56,73.92 159.72,73.75 159.72,73.75 159.96,73.52 159.96,73.19 159.96,73.19 160.19,72.95 160.52,72.95 160.76,73.19 160.76,73.53 160.99,73.75 161.35,73.75 161.74,73.36 161.74,72.91 ; v2(140.24,76.84) 140.81,76.27 142.01,76.27
  07_SIG3 w0.262: 161.74,72.91 162.11,72.53 162.11,71.82 162.45,71.48 162.45,67.73 162.22,67.49 161.69,67.49 161.53,67.66 161.53,68.07 161.39,68.21 161.11,68.21 160.97,68.07 160.97,67.53 160.83,67.39 160.55,67.39 160.41,67.53 160.41,68.07 160.27,68.21 159.99,68.21 159.85,68.07 159.85,67.53 159.71,67.39 159.43,67.39 159.29,67.53 159.29,68.07 159.15,68.21 158.87,68.21 158.73,68.07 158.73,67.53 158.59,67.39 158.31,67.39 158.17,67.53 158.17,68.07 158.03,68.21 157.75,68.21 157.61,68.07 157.61,67.53 157.48,67.39 157.2,67.39 157.06,67.53 157.06,68.07 156.92,68.21 156.64,68.21 156.5,68.07 156.5,67.53 156.36,67.39 156.08,67.39 155.94,67.53 155.94,68.07 155.8,68.21 155.52,68.21 155.38,68.07 155.38,67.53 155.24,67.39 154.23,67.39 149.81,71.81 149.81,72.05 146.33,75.53 146.32,75.53 146.22,75.63 146.22,75.63 146.17,75.68 142.94,75.68 142.94,75.68 142.6,75.68 142.01,76.27
DDR4_C2_DQ33: length 43.1
  TOP w0.152: v2(141.24,76.84) U1.BF34 ; U137.F7 v4(158.76,78.15)
  07_SIG3 w0.173: 141.71,76.89 141.28,76.89 v2(141.24,76.84) ; v4(158.76,78.15) 158.76,77.23 159.48,76.51 159.48,76.43 159.96,75.96 159.96,75.59 159.95,75.59 159.95,75.58 159.73,75.35 159.35,75.35 159.16,75.16 159.16,75.12 159.16,75.12 159.16,72.91
  07_SIG3 w0.262: 141.71,76.89 142.44,76.89 143,76.32 146.41,76.32 146.43,76.3 146.47,76.3 150.36,72.41 150.86,72.41 151.32,71.95 151.32,71.26 153.33,69.25 154.39,69.25 154.56,69.08 154.56,68.73 154.7,68.6 154.98,68.6 155.12,68.73 155.12,69.24 155.26,69.38 155.54,69.38 155.68,69.24 155.68,68.86 155.82,68.72 156.1,68.72 156.24,68.86 156.24,69.24 156.38,69.38 156.66,69.38 156.8,69.24 156.8,68.86 156.94,68.72 157.22,68.72 157.36,68.86 157.36,69.24 157.5,69.38 157.77,69.38 157.91,69.24 157.91,68.86 158.05,68.72 158.33,68.72 158.47,68.86 158.47,69.24 158.61,69.38 158.89,69.38 159.03,69.24 159.03,68.86 159.17,68.72 159.45,68.72 159.59,68.86 159.59,69.24 159.73,69.38 160.01,69.38 160.15,69.24 160.15,68.86 160.29,68.72 160.57,68.72 160.71,68.86 160.71,69.24 160.85,69.38 161.6,69.38 161.79,69.56 161.79,69.85 161.42,70.23 161.42,70.54 161.79,70.91 161.79,71.32 160.79,72.32 159.74,72.32 159.16,72.91
DDR4_C2_DQ34: length 44.1
  TOP w0.152: U137.H3 v4(160.36,75.75) ; v2(138.24,77.84) U1.BC35
  07_SIG3 w0.089: 161.87,81.23 161.87,81.29
  07_SIG3 w0.173: 141.71,83.34 141.03,83.34 140.74,83.05 140.74,82.64 140.44,82.34 140.03,82.34 139.74,82.05 139.74,81.64 139.44,81.34 139.03,81.34 138.74,81.05 138.74,80.64 138.44,80.34 138.03,80.34 137.74,80.05 137.74,78.54 138.24,78.04 v2(138.24,77.84) ; 161.87,81.23 162.36,80.74 162.36,75.29 161.62,74.55 160.99,74.55 160.76,74.32 160.76,73.99 160.52,73.75 160.19,73.75 159.96,73.99 159.96,75.12 160.36,75.52 v4(160.36,75.75)
  07_SIG3 w0.262: 161.87,81.29 161.87,81.65 158.12,85.4 144.46,85.4 142.41,83.34 141.71,83.34
DDR4_C2_DQ35: length 43.3
  TOP w0.152: U137.H7 v4(160.36,78.15) ; v2(138.24,78.84) U1.BC36
  07_SIG3 w0.173: v4(160.36,78.15) 160.68,78.15 160.76,78.23 160.76,81.29 ; v2(138.24,78.84) 138.24,78.52 138.41,78.34 139.44,78.34 139.74,78.64 139.74,80.05 140.03,80.34 140.44,80.34 140.74,80.64 140.74,81.05 141.03,81.34 141.47,81.34 141.71,81.58
  07_SIG3 w0.262: 141.71,81.58 141.97,81.84 142.74,81.84 144.99,84.09 149.68,84.09 150.05,83.73 150.05,82.75 150.19,82.61 151.01,82.61 151.36,82.95 151.36,83.4 151.55,83.59 152.28,83.59 152.45,83.42 152.45,83.2 152.33,83.08 152.04,83.08 151.89,82.93 151.89,82.66 152.01,82.53 152.66,82.53 153,82.88 153.35,82.88 153.75,82.48 153.87,82.48 154.25,82.85 154.25,83.01 153.83,83.42 153.83,83.71 154.01,83.88 154.6,83.88 154.78,83.7 154.78,83.37 154.89,83.26 155.24,83.26 155.34,83.36 155.34,83.49 155.48,83.63 155.76,83.63 155.9,83.49 155.9,83.35 156,83.26 156.37,83.26 156.44,83.33 156.44,83.48 156.58,83.62 156.86,83.62 156.95,83.54 156.95,82.81 157.12,82.64 157.96,82.64 158.07,82.75 158.07,83.06 157.94,83.2 157.54,83.2 157.45,83.28 157.45,84 157.66,84.21 157.95,84.21 159.85,82.31 159.85,82.11 159.68,81.95 159.68,81.75 159.88,81.55 160.08,81.55 160.24,81.72 160.44,81.72 160.76,81.4 160.76,81.29
DDR4_C2_DQ36: length 41
  TOP w0.152: U137.H2 v4(160.36,74.15) ; v2(139.24,78.84) U1.BD36
  07_SIG3 w0.173: 141.71,82.57 141.48,82.34 141.03,82.34 140.74,82.05 140.74,81.64 140.44,81.34 140.03,81.34 139.74,81.05 139.74,80.64 139.44,80.34 139.03,80.34 138.74,80.05 138.74,79.34 v2(139.24,78.84) ; v4(160.36,74.15) 160.36,74.38 160.43,74.45 160.43,74.46 160.76,74.79 160.76,75.12 160.99,75.35 161.32,75.35 161.56,75.59 161.56,80.8 161.25,81.1 161.25,81.29
  07_SIG3 w0.262: 141.71,82.57 142.55,82.57 143.27,83.29 144.72,84.74 149.97,84.74 150.48,84.24 153.46,84.24 153.67,84.45 153.67,84.61 153.77,84.71 154.04,84.71 154.15,84.6 154.15,84.45 154.29,84.32 154.49,84.32 154.6,84.43 154.6,84.77 154.74,84.92 155.08,84.92 155.22,84.78 155.22,84.24 155.36,84.1 155.64,84.1 155.77,84.24 155.77,84.78 155.91,84.92 156.19,84.92 156.33,84.78 156.33,84.24 156.47,84.1 156.75,84.1 156.89,84.24 156.89,84.78 157.03,84.92 157.93,84.92 161.25,81.59 161.25,81.29
DDR4_C2_DQ37: length 40.8
  TOP w0.152: U137.H8 v4(160.36,79.75) ; v2(140.24,79.84) U1.BE37
  07_SIG3 w0.173: v4(160.36,79.75) 160.11,79.75 159.96,79.9 159.96,80.91 ; v2(140.24,79.84) 140.48,80.08 140.55,80.08 140.81,80.34 141.4,80.34 141.71,80.65 141.71,80.75
  07_SIG3 w0.262: 141.71,80.75 141.89,80.93 142.78,80.93 143,81.15 143.34,81.15 143.47,81.28 143.47,81.62 145.23,83.38 145.57,83.38 145.65,83.31 145.65,82.89 145.79,82.75 146.06,82.75 146.2,82.89 146.2,83.31 146.34,83.45 146.62,83.45 146.76,83.31 146.76,82.89 146.9,82.75 147.18,82.75 147.32,82.89 147.32,83.31 147.46,83.45 147.74,83.45 147.88,83.31 147.88,82.85 148.01,82.72 148.29,82.72 148.44,82.87 148.44,83.31 148.58,83.45 149.25,83.45 149.4,83.29 149.4,82.47 150.46,81.41 150.84,81.41 151.05,81.61 151.05,81.85 151.18,81.98 151.45,81.98 151.61,81.82 151.61,81.46 151.75,81.32 151.97,81.32 152.11,81.46 152.11,81.74 152.26,81.89 152.54,81.89 152.66,81.77 152.66,81.48 152.75,81.39 153.42,81.39 153.74,81.07 153.74,80.79 153.85,80.67 154.15,80.67 154.29,80.81 154.29,81.23 153.99,81.53 153.99,81.91 154.26,82.18 154.54,82.18 154.68,82.04 154.68,81.46 154.82,81.32 155.1,81.32 155.24,81.46 155.24,82.04 155.38,82.18 155.66,82.18 155.8,82.04 155.8,81.18 155.94,81.04 156.22,81.04 156.36,81.18 156.36,82.04 156.5,82.18 156.78,82.18 156.91,82.04 156.91,81.14 157.03,81.02 157.32,81.02 157.47,81.17 157.47,82.04 157.61,82.18 157.91,82.18 158.12,81.98 158.12,81.09 158.22,80.98 158.52,80.98 158.63,81.09 158.63,82.01 158.77,82.15 158.97,82.15 159.09,82.02 159.09,81.23 159.23,81.1 159.78,81.1 159.96,80.91
DDR4_C2_DQ38: length 41.7
  TOP w0.152: v2(141.24,78.84) U1.BF36 ; U137.J3 v4(161.16,75.75)
  07_SIG3 w0.173: v4(161.16,75.75) 161.16,76.29 161.07,76.38 160,76.38 159.81,76.57 159.81,76.75 159.92,76.86 161.06,76.86 161.2,76.99 161.2,77.22 161.04,77.37 159.8,77.37 159.52,77.09 159.37,77.09 159.16,77.3 159.16,78.33 158.93,78.55 158.58,78.55 158.36,78.33 158.36,77.02 158.28,76.94 158.01,76.94 157.92,77.02 157.92,77.59 157.79,77.73 157.54,77.73 157.45,77.64 157.45,76.99 157.36,76.9 157.18,76.9 157.09,76.99 157.09,77.64 157,77.73 156.82,77.73 156.74,77.64 156.74,76.99 156.65,76.9 156.47,76.9 156.38,76.99 156.38,77.64 156.29,77.73 156.11,77.73 156.02,77.64 156.02,76.99 155.94,76.9 155.76,76.9 155.67,76.99 155.67,77.64 155.58,77.73 155.4,77.73 155.31,77.64 155.31,76.99 155.22,76.9 155.05,76.9 154.96,76.99 154.96,77.64 154.87,77.73 154.69,77.73 154.6,77.64 154.6,76.99 154.51,76.9 154.34,76.9 154.25,76.99 154.25,77.58 154.13,77.7 153.97,77.7 ; v2(141.24,78.84) 141.82,78.84 141.98,78.67
  07_SIG3 w0.262: 153.97,77.7 152.83,77.7 152.58,77.45 152.58,74.07 152.45,73.94 152.16,73.94 151.89,74.21 151.89,74.7 151.71,74.89 151.21,74.89 150.95,75.14 150.23,75.14 147.24,78.14 144.2,78.14 143.66,78.67 141.98,78.67
DDR4_C2_DQ39: length 41.3
  TOP w0.152: v2(141.24,79.84) U1.BF37 ; U137.J7 v4(161.16,78.15)
  07_SIG3 w0.173: 153.97,79.65 154.26,79.35 159.72,79.35 159.96,79.12 159.96,77.98 160.18,77.75 160.76,77.75 v4(161.16,78.15) ; 141.71,80.05 141.45,80.05 v2(141.24,79.84)
  07_SIG3 w0.262: 153.97,79.65 153.45,80.17 152.87,80.17 152.58,79.88 152.12,79.88 151.96,80.04 151.96,80.52 151.82,80.66 151.54,80.66 151.33,80.45 151.33,79.07 151.16,78.89 150.57,78.89 150.28,79.19 149.82,79.19 149.69,79.32 149.69,79.83 150.17,80.32 150.17,80.76 149.78,81.16 149.58,81.16 149.45,81.03 149.45,80.71 149.34,80.6 149.06,80.6 148.96,80.7 148.96,81.82 148.76,82.02 148.51,82.02 148.38,81.89 148.38,80.75 148.21,80.59 147.96,80.59 147.84,80.7 147.84,82 147.7,82.14 147.42,82.14 147.28,82 147.28,80.74 147.15,80.61 146.87,80.61 146.72,80.75 146.72,82 146.58,82.14 146.31,82.14 146.17,82 146.17,80.74 146.02,80.59 145.74,80.59 145.61,80.73 145.61,82 145.47,82.14 145.19,82.14 145.05,82 145.05,81.63 144.91,81.49 144.26,81.49 144.12,81.35 144.12,81.07 144.26,80.93 144.91,80.93 145.05,80.79 145.05,80.64 144.47,80.05 144.19,80.05 143.74,80.51 143.26,80.51 142.81,80.05 141.71,80.05
DDR4_C2_DQ40: length 37.9
  TOP w0.152: v2(139.24,79.84) U1.BD37 ; U137.A3 v4(154.76,75.75)
  05_SIG2 w0.173: v4(154.76,75.75) 154.14,75.14 153.97,75.14 ; v2(139.24,79.84) 139.51,79.84 140.01,79.34 140.44,79.34 140.74,79.05 140.74,78.64 141.03,78.34 141.54,78.34 141.89,78.69 142.19,78.69 142.34,78.54
  05_SIG2 w0.262: 142.34,78.54 142.34,77.15 142.56,76.94 142.83,76.94 142.96,77.08 142.96,78.49 143.16,78.69 143.48,78.69 143.62,78.56 143.62,77.82 143.86,77.57 148.5,77.57 148.91,77.99 150.02,77.99 150.17,77.84 150.17,77.07 150.02,76.93 143.55,76.93 143.4,76.78 143.4,76.42 143.58,76.23 149.38,76.23 150.29,75.32 150.58,75.32 151,75.74 151.66,75.74 152.26,75.14 153.97,75.14
DDR4_C2_DQ41: length 38.9
  TOP w0.152: v2(140.24,80.84) 139.74,80.34 U1.BE38 ; U137.B8 v4(155.56,79.75)
  05_SIG2 w0.173: v4(155.56,79.75) 155.16,79.35 155.16,78.79 155.16,78.78 155.38,78.55 155.72,78.55 155.96,78.32 155.96,77.81 156.05,77.72 156.7,77.72 156.79,77.62 156.79,77.28 156.71,77.2 156.45,77.2 156.37,77.12 156.37,76.9 156.21,76.74 156.06,76.74 155.82,76.98 155.65,76.98 155.41,76.74 154.06,76.74 153.97,76.84 ; v2(140.24,80.84) 140.48,80.84 140.98,80.34 142.46,80.34 142.63,80.18
  05_SIG2 w0.262: 153.97,76.84 153.77,77.04 153.77,77.21 153.32,77.66 152.84,77.66 152.6,77.9 152.6,81.27 152.78,81.45 153.44,81.45 153.77,81.78 153.77,82.59 153.45,82.9 152.28,82.9 152.14,83.04 152.14,83.16 152.01,83.29 151.73,83.29 151.58,83.13 151.58,83.04 151.4,82.86 150.88,82.86 150.54,82.52 150.17,82.52 149.99,82.7 149.99,83.14 149.85,83.28 149.57,83.28 149.43,83.14 149.43,83.04 149.29,82.9 148.48,82.9 148.32,82.74 148.32,82.4 148.46,82.26 149.22,82.26 149.37,82.11 149.37,81.83 149.24,81.7 148.69,81.7 148.54,81.55 148.54,81.28 148.68,81.14 149.13,81.14 149.27,81 149.27,80.72 149.14,80.58 148.51,80.58 148.4,80.47 148.4,80.19 148.56,80.02 148.84,80.02 148.95,79.91 148.95,79.63 148.78,79.46 148.15,79.46 147.85,79.77 147.18,79.77 147.04,79.63 146.43,79.63 146.29,79.77 144.92,79.77 144.63,80.05 142.75,80.05 142.63,80.18
