# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_C2_DQ42: length 34.2
  TOP w0.152: U137.C3 v4(156.36,75.75) ; v2(138.24,81.84) 137.74,81.34 U1.BC39
  05_SIG2 w0.173: v2(138.24,81.84) 137.74,81.34 137.74,80.64 138.03,80.34 138.44,80.34 138.74,80.05 138.74,79.64 139.03,79.34 139.44,79.34 139.74,79.05 139.74,78.64 140.03,78.34 140.44,78.34 140.74,78.05 140.74,77.64 141.03,77.34 141.4,77.34 142.51,76.23 142.63,76.23 ; 153.97,74.06 154.46,74.55 155.84,74.55 155.96,74.67 155.96,75.35 v4(156.36,75.75)
  05_SIG2 w0.262: 153.97,74.06 153.74,73.83 152.34,73.83 151.6,74.58 149.82,74.58 148.82,75.58 145.05,75.58 144.92,75.45 144.92,75.17 145.06,75.03 148.26,75.03 148.4,74.89 148.4,74.65 148.23,74.47 144.38,74.47 142.63,76.23
DDR4_C2_DQ43: length 35.3
  TOP w0.152: v2(139.24,82.84) 138.74,82.34 U1.BD40 ; U137.C7 v4(156.36,78.15)
  05_SIG2 w0.173: v4(156.36,78.15) U137.C7 156.76,79.2 156.61,79.35 156.11,79.35 155.96,79.5 155.96,79.98 155.79,80.15 155.39,80.15 155.16,80.39 155.16,81.29 ; v2(139.24,82.84) 139.74,82.34 141.66,82.34 141.75,82.44 141.75,83 141.84,83.09 142.12,83.09 142.18,83.04 142.18,82.39 142.29,82.27 142.63,82.27
  05_SIG2 w0.262: 142.63,82.27 142.64,82.27 142.75,82.38 142.75,83.07 142.9,83.22 143.21,83.22 143.33,83.1 143.33,82.37 143.43,82.27 143.8,82.27 143.92,82.39 143.92,84.57 145.02,85.67 146.13,85.67 146.7,85.11 147.3,85.11 147.44,85.25 147.44,85.51 147.58,85.65 147.86,85.65 148,85.51 148,85.25 148.14,85.11 148.42,85.11 148.56,85.25 148.56,85.51 148.7,85.65 148.98,85.65 149.12,85.51 149.12,85.25 149.26,85.11 149.53,85.11 149.67,85.25 149.67,85.47 149.89,85.68 153.23,85.68 155.44,83.47 156.27,83.47 156.74,83 156.74,82.49 156.38,82.13 155.36,82.13 155.16,81.92 155.16,81.29
DDR4_C2_DQ44: length 36.8
  TOP w0.152: U1.BB38 136.74,80.34 v2(137.24,80.84) ; U137.C2 v4(156.36,74.15)
  05_SIG2 w0.173: 142.63,75.16 141.44,76.34 141.03,76.34 140.74,76.64 140.74,77.05 140.44,77.34 140.03,77.34 139.74,77.64 139.74,78.05 139.44,78.34 139.03,78.34 138.74,78.64 138.74,79.05 138.44,79.34 138.03,79.34 137.74,79.64 137.74,80.12 137.24,80.62 v2(137.24,80.84) ; v4(156.36,74.15) 156.36,73.97 155.96,73.57 155.96,72.91
  05_SIG2 w0.262: 155.96,72.91 155.96,72.68 155.57,72.3 155.03,72.3 154.8,72.07 154.8,71.81 154.57,71.58 154.25,71.58 154.02,71.81 154.02,72.07 153.79,72.3 152.84,72.3 152.28,72.86 151.81,72.86 151.39,73.28 151.39,73.67 151.18,73.88 150.32,73.88 150.17,73.74 150.17,72.86 150.01,72.7 146.7,72.7 146.56,72.84 146.56,73.12 146.7,73.26 149.39,73.26 149.54,73.41 149.54,73.68 149.4,73.82 146.14,73.82 146,73.68 146,72.84 145.86,72.7 145.09,72.7 142.63,75.16
DDR4_C2_DQ45: length 38.1
  TOP w0.152: U137.C8 v4(156.36,79.75) ; U1.BB39 136.74,81.34 v2(137.24,81.84)
  05_SIG2 w0.173: 142.63,74.2 141.49,75.34 141.03,75.34 140.74,75.64 140.74,76.05 140.44,76.34 140.03,76.34 139.74,76.64 139.74,77.05 139.44,77.34 139.03,77.34 138.74,77.64 138.74,78.05 138.44,78.34 138.03,78.34 137.74,78.64 137.74,79.05 137.44,79.34 137.03,79.34 136.74,79.64 136.74,81.09 137.24,81.59 v2(137.24,81.84) ; 156.76,72.91 156.76,75.93 157.56,76.73 157.56,79.94 157.34,80.15 156.76,80.15 v4(156.36,79.75)
  05_SIG2 w0.262: 156.76,72.91 156.76,72.6 155.28,71.11 152.66,71.11 151.5,72.27 150.51,72.27 150.29,72.05 144.78,72.05 142.63,74.2
DDR4_C2_DQ46: length 39.6
  TOP w0.152: v2(138.24,80.84) 137.74,80.34 U1.BC38 ; U137.D3 v4(157.16,75.75)
  05_SIG2 w0.173: 142.63,85.47 141.5,84.34 141.03,84.34 140.74,84.05 140.74,83.64 140.44,83.34 139.03,83.34 138.74,83.05 138.74,81.34 v2(138.24,80.84) ; v4(157.16,75.75) 157.56,75.35 157.56,73.99 157.79,73.75 158.12,73.75 158.36,73.99 158.36,74.32 158.59,74.55 158.92,74.55 159.16,74.79 159.16,80.72 158.59,81.29
  05_SIG2 w0.262: 158.59,81.29 158.59,82.03 157.99,82.63 157.99,83.15 154.08,87.05 144.21,87.05 142.63,85.47
DDR4_C2_DQ47: length 38.4
  TOP w0.152: U137.D7 v4(157.16,78.15) ; v2(139.24,80.84) 138.74,80.34 U1.BD38
  05_SIG2 w0.173: v2(139.24,80.84) 139.74,80.34 140.44,80.34 140.74,80.05 140.74,79.64 141.03,79.34 142.63,79.34 ; v4(157.16,78.15) 157.16,76.83 156.58,76.25 154.46,76.25 154.17,75.96 153.97,75.96
  05_SIG2 w0.262: 153.97,75.96 153.82,75.96 153.44,76.34 152.99,76.34 152.83,76.51 151.79,76.51 151.36,76.94 151.36,77.23 151.74,77.6 151.74,77.88 151.33,78.29 151.33,78.6 151.82,79.1 151.82,79.47 151.72,79.57 151.43,79.57 151.29,79.72 151.29,80 151.42,80.13 151.79,80.13 151.94,80.28 151.94,80.56 151.82,80.69 151.46,80.69 151.31,80.83 151.31,81.11 151.45,81.25 151.67,81.25 151.94,81.51 151.94,81.94 151.8,82.08 151.38,82.08 151.25,81.94 151.25,81.78 151.14,81.67 150.13,81.67 149.95,81.49 149.95,80.67 150.25,80.37 150.25,79.85 149.95,79.55 149.95,78.84 149.76,78.65 148.38,78.65 148.27,78.54 148.27,78.37 148.11,78.22 147.84,78.22 147.71,78.35 147.71,78.83 147.56,78.98 147.28,78.98 147.15,78.85 147.15,78.37 147,78.22 146.72,78.22 146.59,78.35 146.59,78.83 146.44,78.98 146.16,78.98 146.03,78.85 146.03,78.37 145.88,78.22 145.6,78.22 145.47,78.35 145.47,78.97 145.33,79.11 145.05,79.11 144.92,78.98 144.92,78.37 144.76,78.22 144.48,78.22 144.36,78.35 144.36,79.18 144.19,79.34 142.63,79.34
DDR4_C2_DQ48: length 74.2
  TOP w0.152: U1.BB36 v2(137.24,78.84) ; U138.G2 v4(159.56,88.25)
  07_SIG3 w0.173: 131.74,89.49 131.74,80.71 132.11,80.34 132.44,80.34 132.74,80.05 132.74,79.64 133.03,79.34 133.44,79.34 133.74,79.05 133.74,78.64 134.03,78.34 134.44,78.34 134.74,78.05 134.74,77.64 135.03,77.34 135.44,77.34 135.74,77.05 135.74,76.64 136.03,76.34 136.44,76.34 136.74,76.64 136.74,77.05 137.03,77.34 137.44,77.34 137.74,77.64 137.74,78.05 137.24,78.55 v2(137.24,78.84) ; 163.96,95.39 163.96,95.38 163.96,89.67 163.73,89.45 163.4,89.45 163.16,89.21 163.16,88.88 162.92,88.65 162.54,88.65 162.13,88.24 162.13,87.8 161.38,87.05 160.19,87.05 159.96,87.28 159.96,87.62 159.56,88.02 v4(159.56,88.25)
  07_SIG3 w0.262: 131.74,89.49 131.74,92.31 137.38,97.96 140.25,97.96 142.78,100.49 143.89,100.49 144.16,100.22 149.19,100.22 149.33,100.36 156.41,100.36 157.14,99.62 159.72,99.62 163.96,95.39
DDR4_C2_DQ49: length 74.1
  TOP w0.152: U138.F7 v4(158.76,92.25) ; U1.BB37 v2(137.24,79.84)
  07_SIG3 w0.173: 132.66,90.96 132.66,89.13 132.74,89.06 132.74,80.71 133.11,80.34 133.33,80.34 133.74,79.94 133.74,79.7 134.1,79.34 134.35,79.34 134.74,78.96 134.74,78.73 135.13,78.34 135.38,78.34 135.74,77.99 135.74,77.64 136.03,77.34 136.44,77.34 136.74,77.64 136.74,79.34 v2(137.24,79.84) ; v4(158.76,92.25) 159.16,92.65 160.52,92.65 160.76,92.42 160.76,88.88 160.52,88.65 160.19,88.65 159.96,88.42 159.96,88.08 160.19,87.85 161.32,87.85 161.7,88.22 161.7,88.55 162.59,89.45 162.93,89.45 163.16,89.68 163.16,95.28 163.05,95.39
  07_SIG3 w0.262: 163.05,95.39 160.06,98.37 157.15,98.37 156.69,98.82 156.69,99.16 156.14,99.71 149.59,99.71 149.45,99.57 147.84,99.57 147.24,98.97 146.65,98.97 146.43,99.19 142.71,99.19 140.81,97.3 137.64,97.3 132.66,92.32 132.66,90.96
DDR4_C2_DQ50: length 70.5
  TOP w0.152: U1.BA39 135.74,81.34 v2(136.24,81.84) ; U138.H3 v4(160.36,89.85)
  07_SIG3 w0.173: v2(136.24,81.84) 136.15,81.76 136.15,81.48 136.32,81.31 137.49,81.31 137.74,81.55 137.74,82.22 137.86,82.34 138.44,82.34 138.74,82.64 138.74,83.09 138.99,83.34 139.44,83.34 139.74,83.64 139.74,84.09 140,84.35 140.51,84.35 140.79,84.63 140.79,84.94 140.44,85.29 140.04,85.29 139.74,85.59 139.74,88.2 139.85,88.32 140.56,88.32 140.74,88.14 140.74,85.52 140.94,85.32 141.5,85.32 141.73,85.09 141.96,85.09 142.19,85.32 142.19,85.57 142.06,85.7 141.83,85.7 141.71,85.83 141.71,86.04 141.81,86.14 142.52,86.14 142.62,86.24 142.62,86.39 142.47,86.54 141.81,86.54 141.71,86.64 141.71,86.79 142.03,87.12 142.03,88.02 141.88,88.16 141.61,88.16 141.53,88.09 141.53,87.48 141.44,87.39 141.24,87.39 141.12,87.51 141.12,88.42 141.25,88.55 141.46,88.55 141.83,88.93 142.21,88.93 142.47,88.67 142.47,87.1 142.62,86.94 142.63,86.94 ; 153.97,90.88 153.98,90.9 157.43,90.9 157.56,91.03 157.56,91.71 157.69,91.84 157.92,91.84 158.05,91.71 158.05,91.05 158.17,90.93 158.36,90.93 158.47,91.03 158.47,91.24 158.64,91.41 158.8,91.41 158.9,91.31 158.9,91.1 159.02,90.98 159.33,90.98 159.49,91.14 159.98,91.14 160.06,91.22 160.06,91.64 160.15,91.73 160.28,91.73 160.4,91.61 160.4,90.38 160.29,90.27 160.17,90.27 160.06,90.38 160.06,90.62 159.96,90.73 159.89,90.73 159.79,90.64 159.79,90.19 159.97,90.02 159.97,89.88 160.09,89.76 160.26,89.76 v4(160.36,89.85)
  07_SIG3 w0.262: 142.63,86.94 142.84,86.94 142.99,87.1 142.99,88.37 143.14,88.52 143.36,88.52 143.51,88.37 143.51,87.35 143.67,87.2 143.88,87.2 144.04,87.35 144.04,88.37 144.19,88.52 144.41,88.52 144.56,88.37 144.56,87.35 144.71,87.2 144.93,87.2 145.08,87.35 145.08,88.37 145.24,88.52 145.45,88.52 145.61,88.37 145.61,87.35 145.76,87.2 145.98,87.2 146.13,87.35 146.13,88.37 146.28,88.52 146.5,88.52 146.65,88.37 146.65,87.35 146.81,87.2 147.02,87.2 147.18,87.35 147.18,88.37 147.33,88.52 147.55,88.52 147.7,88.37 147.7,87.35 147.85,87.2 148.07,87.2 148.22,87.35 148.22,88.37 148.38,88.52 148.92,88.52 149.12,88.32 149.12,88.14 148.74,87.76 148.74,87.35 148.89,87.2 149.58,87.2 149.77,87.39 149.77,88.16 150.62,89.01 153.32,89.01 153.44,89.13 153.44,90.48 153.84,90.88 153.97,90.88
DDR4_C2_DQ51: length 71.5
  TOP w0.152: v2(136.24,82.84) 135.74,82.34 U1.BA40 ; U138.H7 v4(160.36,92.25)
  07_SIG3 w0.173: 139.34,90.96 139.29,90.91 138.9,90.91 137.42,89.42 137.42,89.28 137.74,88.96 137.74,85.45 137.84,85.34 138.43,85.34 138.69,85.08 138.69,84.58 138.46,84.35 137.93,84.35 137.74,84.16 137.74,83.64 137.44,83.34 136.96,83.34 136.78,83.16 136.78,82.93 136.69,82.84 v2(136.24,82.84) ; v4(160.36,92.25) 160.2,92.25 159.71,91.76 159.71,91.61 159.61,91.51 159.48,91.51 159.36,91.63 159.36,91.78 159.22,91.92 159.08,91.92 158.98,91.82 158.48,91.82 158.36,91.94 158.36,93.22 158.12,93.45 156.92,93.45 156.76,93.28 156.76,92.89 156.52,92.65 156.12,92.65 155.96,92.81 155.96,94.12 156.08,94.25 158.13,94.25 158.36,94.48 158.36,94.96 158.22,95.09 155.34,95.09 155.16,94.91 155.16,92.77 155.04,92.65 154.52,92.65 154.33,92.84 154.33,93.48 154.25,93.57 154.08,93.57 153.97,93.45 153.97,92.84 ; 140.38,90.94 140.36,90.96
  07_SIG3 w0.262: 140.36,90.96 140.04,91.28 139.67,91.28 139.34,90.96 ; 153.97,92.84 153.13,92 152.27,92 152.1,91.83 152.1,90.9 151.94,90.74 151.74,90.74 151.51,90.97 151.51,91.85 151.36,92 141.36,92 140.91,92.45 140.6,92.45 140.34,92.19 140.34,91.87 140.74,91.47 150.3,91.47 150.46,91.31 150.46,91.09 150.3,90.94 140.38,90.94
DDR4_C2_DQ52: length 70.1
  TOP w0.152: v2(134.24,82.84) 133.74,82.34 U1.AW40 ; U138.H2 v4(160.36,88.25)
  07_SIG3 w0.173: v4(160.36,88.25) 160.59,88.25 160.99,88.65 161.32,88.65 161.66,88.99 161.66,89.17 161.5,89.34 161.5,89.54 161.64,89.68 162.21,89.68 162.32,89.79 162.32,90.02 162.23,90.11 161.65,90.11 161.56,90.2 161.56,90.42 161.69,90.55 162.72,90.55 162.8,90.64 162.8,90.84 162.68,90.96 162.01,90.96 161.94,91.04 161.94,91.41 162.03,91.5 162.15,91.5 162.32,91.34 162.6,91.34 162.71,91.45 162.71,91.6 162.36,91.96 162.36,95.17 162.14,95.39 ; v2(134.24,82.84) 133.91,82.84 133.74,83.02 133.74,89 133.43,89.3 133.15,89.3 133.05,89.41 133.05,90.55 133.45,90.96
  07_SIG3 w0.262: 133.45,90.96 133.58,91.08 133.58,91.41 133.32,91.67 133.32,91.98 133.44,92.1 133.65,92.1 134.15,91.6 134.37,91.6 134.52,91.75 134.52,91.97 133.98,92.51 133.98,92.73 134.14,92.88 134.35,92.88 134.89,92.34 135.11,92.34 135.26,92.49 135.26,92.71 134.72,93.25 134.72,93.47 134.88,93.62 135.09,93.62 135.63,93.08 135.85,93.08 136,93.23 136,93.45 135.46,93.99 135.46,94.21 135.62,94.36 135.83,94.36 136.37,93.82 136.59,93.82 136.74,93.97 136.74,94.19 136.2,94.73 136.2,94.95 136.36,95.1 136.57,95.1 137.11,94.56 137.33,94.56 137.48,94.71 137.48,94.93 136.94,95.47 136.94,95.69 137.1,95.84 137.31,95.84 137.85,95.3 138.07,95.3 138.22,95.45 138.22,95.67 137.75,96.14 137.75,96.36 138.02,96.64 138.56,96.64 138.68,96.52 138.68,96.32 138.83,96.16 139.05,96.16 139.2,96.32 139.2,96.52 139.34,96.65 139.54,96.65 139.71,96.48 139.71,96.14 139.86,95.99 140.08,95.99 140.23,96.14 140.23,96.4 140.39,96.55 140.98,96.55 142.97,98.55 145.92,98.55 146.27,98.19 147.38,98.19 148.1,98.91 148.28,98.91 148.53,98.66 148.75,98.66 149.01,98.91 149.25,98.91 149.58,98.58 151.61,98.58 151.84,98.35 152.37,98.35 152.76,98.75 153.08,98.75 153.47,98.35 156.21,98.35 156.83,97.73 159.79,97.73 162.14,95.39
DDR4_C2_DQ53: length 70.5
  TOP w0.152: v2(135.24,82.84) 134.74,82.34 U1.AY40 ; U138.H8 v4(160.36,93.85)
  07_SIG3 w0.173: 137.63,91.32 137.39,91.07 137.39,90.91 137.55,90.75 137.55,90.63 137.36,90.44 137.22,90.44 136.82,90.84 136.68,90.84 136.57,90.74 136.57,90.59 136.97,90.19 136.97,90.05 136.73,89.81 136.59,89.81 135.5,90.9 135.34,90.9 135.24,90.8 135.24,90.67 135.45,90.46 135.45,90.32 135.36,90.24 135.15,90.24 135.04,90.13 135.04,89.91 134.74,89.61 134.74,89.47 134.84,89.37 134.98,89.37 135.17,89.56 135.31,89.56 135.43,89.44 135.57,89.44 135.67,89.54 135.67,89.68 135.56,89.8 135.56,89.94 135.69,90.08 135.83,90.08 136.35,89.57 136.35,89.42 136.24,89.32 135.99,89.32 135.74,89.07 135.74,85.52 135.93,85.32 136.44,85.32 136.68,85.08 136.68,84.57 136.49,84.38 135.92,84.38 135.74,84.19 135.74,83.46 135.65,83.37 135.31,83.37 135.24,83.3 v2(135.24,82.84) ; v4(160.36,93.85) 160.36,94.09 160.76,94.49 160.76,94.92 160.44,95.24
  07_SIG3 w0.262: 160.44,95.24 159.99,95.69 159.74,95.69 159.59,95.54 159.35,95.54 159.2,95.69 159.2,95.86 159.4,96.06 159.4,96.28 159.23,96.44 156.21,96.44 155.62,97.04 153.17,97.04 152.6,96.47 152.6,93.42 152.49,93.3 152.13,93.3 152.02,93.41 152.02,96.26 151.85,96.42 151.63,96.42 151.46,96.26 151.46,93.45 151.31,93.3 151.06,93.3 150.9,93.46 150.9,96.68 150.72,96.86 150.13,96.86 149.96,96.69 149.96,96.52 150.29,96.19 150.29,94.66 149.98,94.34 149.98,94.12 150.09,94.01 150.09,93.8 149.93,93.64 149.72,93.64 149.61,93.75 149.39,93.75 148.94,93.3 147.52,93.3 147.01,93.82 146.79,93.82 146.38,93.41 146.17,93.41 146.01,93.56 146.01,93.78 146.42,94.19 146.42,94.4 146.2,94.62 146.2,95.46 146.09,95.57 145.66,95.57 145.51,95.72 145.51,95.98 145.69,96.16 146.2,96.16 146.41,96.37 146.41,96.6 146.25,96.75 144.93,96.75 144.92,96.76 143.6,96.76 142.73,95.9 142.73,95.03 142.17,94.47 140.79,94.47 137.63,91.32
DDR4_C2_DQ54: length 73.4
  TOP w0.152: U138.J3 v4(161.16,89.85) ; v2(135.24,80.84) 134.74,80.34 U1.AY38
  07_SIG3 w0.173: v2(135.24,80.84) 135.24,81.27 135.1,81.41 134.8,81.41 134.67,81.28 134.67,80.55 134.47,80.34 133.93,80.34 133.73,80.54 133.73,82.12 133.93,82.32 134.57,82.32 134.74,82.49 134.74,84.18 134.88,84.32 135.38,84.32 135.71,84.64 135.71,85.08 135.44,85.35 134.98,85.35 134.74,85.59 134.74,89.01 134.31,89.43 133.81,89.43 133.62,89.62 133.62,89.88 133.74,90 134.62,90 134.72,90.1 134.72,90.24 134.62,90.34 133.83,90.34 133.73,90.44 133.73,90.61 133.96,90.84 134.73,90.84 134.84,90.96 ; 161.21,95.39 161.56,95.03 161.56,94.37 161.43,94.25 160.99,94.25 160.76,94.02 160.76,93.69 160.99,93.45 161.43,93.45 161.56,93.32 161.56,91.9 161.46,91.8 161.21,91.8 161.11,91.7 161.11,91.51 161.21,91.4 161.48,91.4 161.58,91.3 161.58,90.98 161.51,90.91 161.23,90.91 161.16,90.84 v4(161.16,89.85)
  07_SIG3 w0.262: 161.21,95.39 159.5,97.09 156.57,97.09 156.18,97.47 155.95,97.71 152.9,97.71 152.27,97.08 151.56,97.08 151.14,97.51 149.64,97.51 149.14,98 148.39,98 147.91,97.53 146.2,97.53 146.07,97.4 145.19,97.4 145.03,97.56 145.03,97.71 144.88,97.87 144.66,97.87 144.51,97.71 144.51,97.56 144.35,97.41 144.14,97.41 143.98,97.56 143.98,97.74 143.83,97.89 143.61,97.89 143.46,97.74 143.46,97.56 142.85,96.95 142.3,96.95 141.94,96.6 141.94,96.21 142.09,96.07 142.09,95.3 141.96,95.18 141.53,95.18 141.45,95.25 141.45,95.7 141.3,95.86 140.99,95.86 140.85,95.72 140.85,95.45 140.12,94.72 139.85,94.72 139.58,94.98 139.58,95.34 139.39,95.53 139.2,95.53 138.8,95.13 138.8,94.91 139.43,94.28 139.43,94.06 139.27,93.91 139.06,93.91 138.43,94.54 138.21,94.54 138.06,94.39 138.06,94.17 138.69,93.54 138.69,93.32 138.53,93.17 138.32,93.17 137.69,93.8 137.47,93.8 137.32,93.65 137.32,93.43 137.95,92.8 137.95,92.58 137.79,92.43 137.58,92.43 136.95,93.06 136.73,93.06 136.58,92.91 136.58,92.69 137.21,92.06 137.21,91.84 137.05,91.69 136.84,91.69 136.21,92.32 135.99,92.32 135.84,92.17 135.84,91.95 136.47,91.32 136.47,91.1 136.31,90.95 136.1,90.95 135.47,91.58 135.25,91.58 135.1,91.43 135.1,91.21 134.84,90.96
DDR4_C2_DQ55: length 73.3
  TOP w0.152: U1.AY39 134.74,81.34 v2(135.24,81.84) ; U138.J7 v4(161.16,92.25)
  07_SIG3 w0.173: 138.24,91.01 138.24,90.72 136.74,89.22 136.74,85.49 136.91,85.32 137.46,85.32 137.72,85.07 137.72,84.57 137.52,84.37 136.88,84.37 136.74,84.23 136.74,83.64 136.44,83.34 136.03,83.34 135.74,83.05 135.74,82.65 135.49,82.4 135.11,82.4 134.99,82.28 134.99,82.09 v2(135.24,81.84) ; 153.94,93.95 154.18,93.95 154.31,94.08 154.31,95.02 154.15,95.17 153.97,95.17 153.87,95.07 153.87,94.49 153.77,94.39 153.34,94.39 153.21,94.51 153.21,94.74 153.49,95.02 153.49,95.33 153.21,95.61 153.21,96.22 153.37,96.37 153.59,96.37 153.72,96.24 154.08,96.24 154.2,96.37 154.46,96.37 154.56,96.27 154.56,95.91 154.41,95.76 154.41,95.46 154.67,95.19 154.87,95.19 154.97,95.29 154.97,96.29 155.08,96.39 155.4,96.39 155.54,96.25 155.54,96.08 155.32,95.86 155.32,95.54 155.42,95.44 155.61,95.44 155.71,95.54 155.71,95.78 155.81,95.88 156,95.88 156.1,95.78 156.1,95.54 156.2,95.44 156.37,95.44 156.47,95.55 156.47,95.74 156.58,95.84 156.77,95.84 156.87,95.74 156.87,95.55 156.97,95.45 157.15,95.45 157.26,95.55 157.26,95.74 157.36,95.84 157.56,95.84 157.66,95.74 157.66,95.55 157.77,95.45 157.98,95.45 158.07,95.54 158.07,95.72 158.16,95.82 158.38,95.82 158.48,95.71 158.48,95.52 158.91,95.1 159.87,95.1 159.96,95.01 159.96,94.38 159.83,94.25 158.59,94.25 158.36,94.02 158.36,93.68 158.59,93.45 160.53,93.45 160.76,93.22 160.76,92.88 161.16,92.48 v4(161.16,92.25)
  07_SIG3 w0.262: 153.94,93.95 153.62,93.95 153.41,93.75 153.41,93.2 152.87,92.66 150.77,92.66 150.39,93.04 150.16,93.04 149.78,92.66 146,92.66 145.54,93.12 145,93.12 144.54,92.66 141.62,92.66 141.39,92.89 141.39,93.12 141.54,93.27 144.46,93.27 144.63,93.45 144.63,93.67 144.51,93.79 143.51,93.79 143.42,93.89 143.42,94.06 143.79,94.43 144.59,94.43 145,94.02 145.33,94.02 145.55,94.23 145.55,94.72 145.28,94.99 144.24,94.99 144.09,95.14 144.09,95.36 144.24,95.51 144.74,95.51 144.84,95.61 144.84,96.02 144.74,96.12 143.9,96.12 143.38,95.6 143.38,94.76 142.85,94.23 142.85,93.95 142.72,93.83 141.06,93.83 138.24,91.01
DDR4_C2_DQ56: length 58.7
  TOP w0.152: U1.AW35 v2(134.24,77.84) ; U138.A3 v4(154.76,89.85)
  14_SIG4 w0.089: 142.63,83.33 142.62,83.33 142.6,83.32 139.01,83.32 138.74,83.05 138.74,82.64 138.44,82.34 138.03,82.34 137.74,82.05 137.74,81.64 137.44,81.34 137.03,81.34 136.74,81.05 136.74,80.64 136.44,80.34 136.03,80.34 135.74,80.05 135.74,79.64 135.44,79.34 135.03,79.34 134.74,79.05 134.74,78.64 134.24,78.14 v2(134.24,77.84) ; 155.16,87 155.16,89.45 v4(154.76,89.85)
  14_SIG4 w0.14: 155.16,87 155.16,86.94 155.33,86.76 155.9,86.76 156.09,86.57 156.09,86.4 156.28,86.21 156.66,86.21 156.85,86.4 156.85,86.71 157.07,86.93 160.97,86.93 161.13,86.77 161.13,86.25 161.02,86.15 160.55,86.15 160.38,85.98 160.38,85.62 160.53,85.48 161.03,85.48 161.22,85.29 161.22,84.91 161.03,84.72 160.72,84.72 160.53,84.53 160.53,81.53 160.08,81.08 153.98,81.08 153.58,81.48 152.41,81.48 152.22,81.29 152.22,78.51 152.03,78.32 151.65,78.32 151.46,78.51 151.46,81.56 151.25,81.76 150.28,81.76 150.07,81.56 150.07,79.97 149.88,79.78 149.5,79.78 149.31,79.97 149.31,81.29 149.12,81.48 148.34,81.48 146.49,83.33 142.63,83.33
DDR4_C2_DQ57: length 58.6
  TOP w0.152: U138.B8 v4(155.56,93.85) ; U1.AW36 v2(134.24,78.84)
  14_SIG4 w0.089: 141.6,87.34 140.03,87.34 139.74,87.05 139.74,86.64 139.44,86.34 139.03,86.34 138.74,86.05 138.74,85.64 138.44,85.34 138.03,85.34 137.74,85.05 137.74,84.64 137.44,84.34 137.03,84.34 136.74,84.05 136.74,83.64 136.44,83.34 136.03,83.34 135.74,83.05 135.74,82.64 135.44,82.34 135.03,82.34 134.74,82.05 134.74,81.64 134.44,81.34 134.03,81.34 133.74,81.05 133.74,80.48 133.52,80.27 133.06,80.27 132.74,79.95 132.74,79.57 132.98,79.33 133.68,79.33 134.17,78.84 v2(134.24,78.84) ; 153.97,92.65 155,92.65 155.16,92.81 155.16,93.45 v4(155.56,93.85)
  14_SIG4 w0.14: 141.6,87.34 142.08,87.34 144.35,85.08 147.87,85.08 148.07,84.88 148.07,84.2 148.64,83.63 149.62,83.63 149.79,83.8 149.79,84.11 150,84.32 151.36,84.32 151.57,84.1 151.57,83.82 151.76,83.64 152.14,83.64 152.34,83.83 152.34,84.52 152.63,84.82 152.63,85.56 152.4,85.8 152.19,85.8 152.05,85.66 152.05,85.15 151.86,84.96 151.48,84.96 151.29,85.14 151.29,85.89 150.99,86.2 149.46,86.2 149.27,86.01 149.27,85.68 149.44,85.52 150,85.52 150.14,85.38 150.14,85.03 149.99,84.89 148.89,84.89 148.7,85.08 148.7,86.02 148.5,86.21 148.2,86.21 147.99,86.01 147.99,85.78 147.9,85.68 147.35,85.68 147.15,85.88 147.15,86.66 147.34,86.85 149.67,86.85 150.88,86.85 151.46,86.85 152.22,87.61 152.22,91.03 153.84,92.65 153.97,92.65
DDR4_C2_DQ58: length 54.6
  TOP w0.152: U1.AU40 131.74,82.34 v2(132.24,82.84) ; U138.C3 v4(156.36,89.85)
  14_SIG4 w0.089: v2(132.24,82.84) 132.24,83.14 132.74,83.64 132.74,84.05 133.03,84.34 134.44,84.34 134.74,84.64 134.74,85.05 135.03,85.34 135.44,85.34 135.74,85.64 135.74,86.05 136.03,86.34 136.44,86.34 136.74,86.64 136.74,87.05 137.03,87.34 137.44,87.34 137.74,87.64 137.74,88.05 138.03,88.34 138.44,88.34 138.74,88.64 138.74,89.21 ; 153.97,90.27 154.63,90.93 156.6,90.93 156.69,91.02 156.69,91.28 156.56,91.41 155.9,91.41 155.81,91.5 155.81,91.74 155.91,91.83 156.58,91.83 156.76,92.01 156.76,94.95 156.55,95.16 156.31,95.16 ; 154.55,87 154.29,87.26 154.29,89.99 154.68,90.38 156.21,90.38 156.36,90.23 v4(156.36,89.85)
  14_SIG4 w0.14: 154.55,87 155.37,86.18 155.37,85.92 155.19,85.74 154.97,85.74 154.65,86.05 153.87,86.83 153.87,90.18 153.97,90.27 ; 138.74,89.21 138.74,89.53 139.46,90.26 141.29,92.09 141.58,92.09 141.58,92.09 142.15,92.09 142.15,92.09 144.57,92.09 144.81,91.85 145.79,91.85 146,92.06 146.15,92.06 146.15,92.05 149.64,92.05 149.64,92.06 149.66,92.06 149.67,92.07 149.67,92.07 151.81,94.21 152.22,94.21 152.29,94.21 153.08,95 153.88,95 154.41,95.54 155.94,95.54 156.31,95.16
DDR4_C2_DQ59: length 55.9
  TOP w0.152: U138.C7 v4(156.36,92.25) ; U1.AV40 132.74,82.34 v2(133.24,82.84)
  14_SIG4 w0.089: v2(133.24,82.84) 133.24,82.44 133.33,82.34 134.44,82.34 134.74,82.64 134.74,83.05 135.03,83.34 135.44,83.34 135.74,83.64 135.74,84.05 136.03,84.34 136.44,84.34 136.74,84.64 136.74,85.05 137.03,85.34 137.44,85.34 137.74,85.64 137.74,86.05 138.03,86.34 138.44,86.34 138.74,86.64 138.74,87.05 139.03,87.34 139.44,87.34 139.74,87.64 139.74,88.05 140.03,88.34 140.74,88.34 141.04,88.04 ; 153.97,93.43 154.16,93.43 154.36,93.62 154.36,94.01 154.59,94.25 154.92,94.25 155.72,94.25 155.96,94.01 155.96,93.69 155.96,92.35 156.05,92.25 v4(156.36,92.25)
  14_SIG4 w0.14: 141.04,88.04 143.42,88.04 143.58,87.88 143.58,87.64 143.33,87.39 143.33,87.11 143.57,86.86 143.82,86.86 144.69,87.74 144.69,89.51 144.88,89.7 145.26,89.7 145.45,89.51 145.45,87.58 144.3,86.43 144.3,86.14 144.67,85.78 144.87,85.78 145.27,86.18 145.42,86.18 145.83,85.78 146.19,85.78 146.39,85.98 146.39,86.17 145.81,86.75 145.81,87.07 146.08,87.34 146.36,87.34 146.49,87.21 146.72,87.21 147.05,87.54 147.55,87.54 147.74,87.74 147.74,89.51 147.93,89.7 148.31,89.7 148.5,89.51 148.5,87.74 148.69,87.54 148.96,87.54 149.18,87.77 149.18,89.54 149.36,89.72 150.26,89.72 150.41,89.56 150.41,88.78 150.23,88.6 149.99,88.6 149.78,88.39 149.78,87.72 149.96,87.54 151.17,87.54 151.52,87.9 151.52,91.32 153.63,93.43 153.97,93.43
DDR4_C2_DQ60: length 56.9
  TOP w0.152: v2(132.24,80.84) 131.74,80.34 U1.AU38 ; U138.C2 v4(156.36,88.25)
  14_SIG4 w0.089: 136.74,89.22 136.74,88.64 136.44,88.34 136.03,88.34 135.74,88.05 135.74,87.64 135.44,87.34 135.03,87.34 134.74,87.05 134.74,86.64 134.44,86.34 133.03,86.34 132.74,86.05 132.74,85.64 132.44,85.34 132.03,85.34 131.74,85.05 131.74,84.64 131.44,84.34 131.03,84.34 130.74,84.05 130.74,81.64 131.03,81.34 131.4,81.34 131.9,80.84 v2(132.24,80.84) ; v4(156.36,88.25) 156.67,88.25 156.76,88.34 156.76,90.18 156.93,90.36 157.95,90.36 158.36,90.76 158.36,95.19 158.16,95.39
  14_SIG4 w0.14: 158.16,95.39 156.58,96.96 153.07,96.96 152.3,96.2 151.16,96.2 150.71,95.74 150.55,95.74 150.32,95.52 150.32,95.19 150.43,95.09 150.43,94.82 148.99,93.39 146.79,93.39 146.26,93.93 146.26,94.97 146.25,95.11 145.98,95.39 144.67,95.39 144.51,95.55 144.51,95.73 144.71,95.93 146.13,95.93 146.31,96.11 146.31,96.35 146.15,96.51 144.29,96.51 142.5,94.71 141.94,94.71 137.49,90.26 136.74,89.51 136.74,89.22
DDR4_C2_DQ61: length 56
  TOP w0.152: U138.C8 v4(156.36,93.85) ; U1.AU39 131.74,81.34 v2(132.24,81.84)
  14_SIG4 w0.089: v4(156.36,93.85) 156.36,94.04 156.26,94.14 155.96,94.44 155.96,94.49 155.96,94.81 155.72,95.05 154.59,95.05 154.36,94.81 154.36,94.52 154.14,94.3 153.97,94.3 ; v2(132.24,81.84) 132.64,81.84 132.74,81.94 132.74,83.1 132.98,83.34 134.5,83.34 134.74,83.58 134.74,84.14 134.94,84.34 135.5,84.34 135.74,84.58 135.74,85.12 135.96,85.34 136.56,85.34 136.74,85.52 136.74,86.13 136.95,86.34 137.52,86.34 137.74,86.56 137.74,87.12 137.96,87.34 138.47,87.34 138.74,87.61 138.74,88.13 138.95,88.34 139.57,88.34 139.7,88.47 139.7,88.96 139.84,89.09 140.8,89.09 140.94,88.96 140.94,88.68 141.08,88.54 141.5,88.54 141.71,88.74
  14_SIG4 w0.14: 153.97,94.3 153.5,94.3 152.49,93.29 152.34,93.29 152.27,93.36 152,93.36 151.73,93.09 151.73,92.82 151.79,92.76 151.79,92.59 151.43,92.23 151.24,92.23 151.17,92.3 150.9,92.3 150.63,92.03 150.63,91.77 150.69,91.7 150.69,91.49 149.62,90.42 149.36,90.42 149.17,90.61 149.17,91.18 149,91.36 148.59,91.36 148.41,91.18 148.41,90.61 148.22,90.42 147.84,90.42 147.65,90.61 147.65,91.18 147.47,91.36 147.07,91.36 146.89,91.18 146.89,88.33 146.75,88.2 146.28,88.2 146.15,88.33 146.15,90.94 145.95,91.14 145.56,91.14 145.36,90.94 145.36,90.61 145.17,90.42 144.55,90.42 144.36,90.61 144.36,91.21 144.18,91.39 143.8,91.39 143.6,91.19 143.6,90.47 143.4,90.28 143.02,90.28 142.84,90.46 142.84,91.16 142.65,91.35 142.26,91.35 142.07,91.16 142.07,90.61 141.88,90.42 141.48,90.42 141.24,90.65 140.84,90.65 140.07,89.88 140.07,89.73 140.23,89.57 143.82,89.57 143.99,89.39 143.99,88.9 143.83,88.74 141.71,88.74
DDR4_C2_DQ62: length 56.2
  TOP w0.152: v2(133.24,80.84) 132.74,80.34 U1.AV38 ; U138.D3 v4(157.16,89.85)
  14_SIG4 w0.089: 159.16,95.39 159.16,90.88 158.36,90.08 158.36,89.69 158.12,89.45 157.32,89.45 157.16,89.62 v4(157.16,89.85) ; 135.74,89.08 135.74,88.64 135.44,88.34 135.03,88.34 134.74,88.05 134.74,87.64 134.44,87.34 133.14,87.34 132.8,87 132.8,86.54 132.6,86.34 132.03,86.34 131.74,86.05 131.74,85.64 131.44,85.34 131.03,85.34 130.74,85.05 130.74,84.64 130.44,84.34 130.03,84.34 129.74,84.05 129.74,81.64 130.03,81.34 130.44,81.34 130.74,81.05 130.74,80.64 131.03,80.34 132.74,80.34 v2(133.24,80.84)
  14_SIG4 w0.14: 159.16,95.39 159.16,95.5 156.99,97.67 152.79,97.67 151.96,96.85 151.26,96.85 151.16,96.95 151.16,97.23 151.02,97.37 150.72,97.37 150.62,97.27 150.62,96.64 150.49,96.52 150.12,96.52 150,96.64 150,97.48 149.81,97.67 149.31,97.67 149.19,97.79 146.42,97.79 145.95,97.31 145.26,97.31 144.93,97.64 144.51,97.64 142.52,95.65 141.89,95.65 135.74,89.5 135.74,89.08
DDR4_C2_DQ63: length 55.3
  TOP w0.152: v2(133.24,81.84) 132.74,81.34 U1.AV39 ; U138.D7 v4(157.16,92.25)
  14_SIG4 w0.089: v2(133.24,81.84) 133.64,81.84 133.73,81.74 133.73,81.5 133.57,81.34 132.03,81.34 131.74,81.64 131.74,84.05 132.03,84.34 132.44,84.34 132.74,84.64 132.74,85.05 133.03,85.34 134.44,85.34 134.74,85.64 134.74,86.05 135.03,86.34 135.44,86.34 135.74,86.64 135.74,87.05 136.03,87.34 136.44,87.34 136.74,87.64 136.74,88.05 137.03,88.34 137.44,88.34 137.74,88.64 137.74,89.21 ; v4(157.16,92.25) 157.16,90.95 157.31,90.8 157.9,90.8 158.01,90.91 158.01,91.55 157.56,92.01 157.56,95 157.17,95.39
  14_SIG4 w0.14: 137.74,89.21 137.74,89.52 138.47,90.26 141.3,93.08 141.57,93.08 141.87,92.79 142.26,92.79 142.48,93.01 142.48,93.25 142.28,93.45 142.28,93.71 142.64,94.07 142.92,94.07 143.2,93.78 143.2,92.96 143.41,92.75 144.51,92.75 144.76,93.01 144.76,93.9 144.58,94.08 143.98,94.08 143.51,94.56 143.51,94.79 143.78,95.06 144.08,95.06 144.48,94.66 145.38,94.66 145.56,94.49 145.56,94.48 145.56,93.05 145.89,92.71 149.3,92.71 149.35,92.76 149.37,92.76 151.31,94.69 151.31,95.42 151.43,95.55 151.71,95.55 152.08,95.18 152.27,95.18 153.39,96.3 156.26,96.3 157.17,95.39
DDR4_C2_DQ64: length 70.9
  TOP w0.152: U139.G2 v4(159.56,31.61) ; v2(141.24,68.84) 140.74,68.34 U1.BF26
  14_SIG4 w0.089: 141.71,43.86 140.91,43.86 140.4,44.37 139.9,44.37 139.73,44.54 139.73,44.98 139.4,45.31 138.91,45.31 138.74,45.49 138.74,65.05 138.73,65.05 138.73,65.21 139.74,66.21 139.74,68.05 140.03,68.34 140.35,68.34 140.85,68.84 v2(141.24,68.84) ; 153.97,32.29 154.07,32.19 154.23,32.19 154.33,32.29 154.33,32.7 154.44,32.81 157.37,32.81 157.56,32.62 157.56,32.17 157.71,32.01 159.44,32.01 159.56,31.89 v4(159.56,31.61)
  14_SIG4 w0.14: 141.71,43.86 142.72,43.86 143.01,43.56 143.01,43.4 142.84,43.23 141.89,43.23 141.78,43.12 141.78,41.78 141.95,41.61 142.19,41.61 142.35,41.78 142.35,42.49 142.52,42.66 142.84,42.66 143.01,42.49 143.01,41.94 143.15,41.81 144.02,41.81 144.21,41.62 144.21,41.21 144.04,41.04 142.53,41.04 142.37,40.87 142.37,40.63 142.53,40.47 144.04,40.47 144.21,40.3 144.21,39.87 143.88,39.53 143.88,39.16 145,38.04 145.47,38.04 145.62,38.19 145.89,38.19 146.21,37.87 146.21,37.64 145.94,37.37 145.94,37.1 146.11,36.93 146.76,36.93 147.3,37.48 149.07,37.48 151.08,35.47 151.08,35.16 150.82,34.9 150.34,34.9 150.12,34.68 150.12,34.34 150.26,34.2 150.64,34.2 151.93,32.91 152.24,32.91 152.9,32.25 153.2,32.25 153.37,32.42 153.37,32.74 152.92,33.19 152.92,33.45 153.17,33.7 153.35,33.7 153.85,33.2 153.85,32.41 153.97,32.29
DDR4_C2_DQ65: length 69.6
  TOP w0.152: v2(141.24,69.84) 140.74,69.34 U1.BF27 ; U139.F7 v4(158.76,35.61)
  14_SIG4 w0.089: v2(141.24,69.84) 141.62,69.84 142.06,69.41 142.06,61.7 142.33,61.43 ; v4(158.76,35.61) 158.76,35.42 158.25,34.91 157.12,34.91 156.76,35.27 156.76,36.68 156.88,36.81 157.19,36.81 157.19,36.81 157.32,36.81 157.56,37.04 157.56,38.45 157.39,38.62 157.12,38.62
  14_SIG4 w0.14: 142.33,61.43 142.61,61.15 142.61,52.73 142.78,52.57 143.87,52.57 144.04,52.4 144.04,52.16 143.87,51.99 142.78,51.99 142.61,51.83 142.61,51.59 142.78,51.42 144.35,51.42 144.52,51.26 144.52,51.02 144.35,50.85 142.78,50.85 142.61,50.68 142.61,50.45 142.78,50.28 144.56,50.28 145.06,50.77 145.32,50.77 145.46,50.63 145.46,43.83 146.84,42.46 148.94,42.46 150.45,40.95 150.77,40.95 151.19,40.53 151.19,40.29 152.65,38.83 153.69,38.83 154.51,39.65 154.51,41.03 154.66,41.18 156.82,41.18 157,40.99 157,40.78 156.83,40.62 155.11,40.62 154.94,40.45 154.94,40.21 155.11,40.05 156.83,40.05 157,39.88 157,39.64 156.83,39.47 155.11,39.47 154.94,39.31 154.94,39.07 155.11,38.9 156.83,38.9 157.12,38.62
DDR4_C2_DQ66: length 71.5
  TOP w0.152: U1.BD28 138.74,70.34 v2(139.24,70.84) ; U139.H3 v4(160.36,33.21)
  14_SIG4 w0.089: 153.97,38.23 154.15,38.23 154.3,38.08 154.3,36.75 154.19,36.64 153.87,36.64 153.76,36.54 153.76,36.38 153.87,36.27 154.19,36.27 154.3,36.16 154.3,36.01 154.19,35.9 153.87,35.9 153.76,35.79 153.76,35.63 153.87,35.52 154.19,35.52 154.3,35.41 154.3,34.75 154.49,34.56 154.64,34.56 154.73,34.65 154.73,35.12 154.82,35.2 155,35.2 155.09,35.12 155.09,34.52 155.18,34.43 155.36,34.43 155.44,34.52 155.44,35.12 155.53,35.2 155.71,35.2 155.8,35.12 155.8,34.65 155.89,34.56 156.07,34.56 156.16,34.65 156.16,35.12 156.24,35.2 156.42,35.2 156.51,35.12 156.51,34.65 156.6,34.56 157.06,34.56 157.1,34.52 158.07,34.52 158.96,33.63 159.86,33.63 159.96,33.54 159.96,32.86 160.02,32.79 160.21,32.79 160.36,32.94 v4(160.36,33.21) ; v2(139.24,70.84) 139.66,70.84 139.75,70.75 139.75,70.48 139.89,70.34 140.55,70.34 140.74,70.16 140.74,69.5 140.89,69.34 141.55,69.34 141.71,69.19 141.71,61.47
  14_SIG4 w0.14: 141.71,61.47 141.87,61.3 141.87,49.06 142.01,48.92 142.27,48.92 142.42,49.07 142.42,49.48 142.57,49.63 142.92,49.63 143.09,49.47 143.09,49.34 143.23,49.2 143.51,49.2 143.64,49.33 143.64,49.43 143.79,49.58 144.53,49.58 144.7,49.41 144.7,49.29 144.56,49.15 144.46,49.15 144.32,49.01 144.32,48.73 144.46,48.59 144.56,48.59 144.7,48.45 144.7,43.46 146.48,41.68 148.73,41.68 149.91,40.5 149.91,40.06 149.55,39.69 149.55,39.3 149.73,39.12 149.92,39.12 150.06,39.26 150.06,39.4 150.32,39.65 150.52,39.65 150.72,39.45 150.72,39.22 150.32,38.81 150.32,38.54 150.46,38.4 150.7,38.4 151.31,39.01 151.54,39.01 152.07,38.48 152.07,38.32 151.93,38.18 151.74,38.18 151.57,38.34 151.44,38.34 151.3,38.2 151.3,38.01 151.92,37.39 152.49,37.39 152.63,37.53 152.63,38.05 152.76,38.18 153.09,38.18 153.21,38.05 153.21,37.26 153.4,37.07 153.66,37.07 153.8,37.21 153.8,38.07 153.95,38.23 153.97,38.23
DDR4_C2_DQ67: length 71.1
  TOP w0.152: U1.BE28 139.74,70.34 v2(140.24,70.84) ; U139.H7 v4(160.36,35.61)
  14_SIG4 w0.089: 157.62,39 157.62,38.94 158.36,38.21 158.36,37.04 158.12,36.81 157.8,36.81 157.69,36.7 157.69,36.7 157.56,36.57 157.56,35.44 157.79,35.21 158.12,35.21 158.36,35.45 158.36,35.58 158.36,35.58 158.36,35.77 158.59,36.01 159.96,36.01 v4(160.36,35.61) ; 141.71,70.4 140.96,70.4 140.53,70.84 v2(140.24,70.84)
  14_SIG4 w0.14: 157.62,39 157.62,41.43 157.24,41.82 154.68,41.82 154.08,41.22 154.08,40.27 153.41,39.6 152.87,39.6 151.92,40.56 151.92,41.16 150.79,42.28 150.1,42.28 149.64,42.75 149.23,43.16 147.13,43.16 146.24,44.05 146.24,44.26 146.38,44.4 146.88,44.4 147.02,44.54 147.02,44.82 146.88,44.96 146.38,44.96 146.24,45.1 146.24,45.38 146.38,45.52 146.88,45.52 147.02,45.66 147.02,45.94 146.88,46.08 146.38,46.08 146.24,46.22 146.24,46.5 146.38,46.64 146.88,46.64 147.02,46.77 147.02,47.05 146.88,47.19 146.38,47.19 146.24,47.33 146.24,51.02 145.43,51.83 144.91,51.83 144.71,52.03 144.71,57.99 144.56,58.14 144.22,58.14 144.02,57.94 144.02,53.47 143.84,53.29 143.56,53.29 143.36,53.49 143.36,62.27 142.72,62.9 142.72,69.86 142.18,70.4 141.71,70.4
DDR4_C2_DQ68: length 71.7
  TOP w0.152: v2(139.24,69.84) 138.74,69.34 U1.BD27 ; U139.H2 v4(160.36,31.61)
  14_SIG4 w0.089: v2(139.24,69.84) 139.62,69.84 139.74,69.73 139.74,68.57 139.51,68.34 138.9,68.34 138.74,68.18 138.74,67.67 138.41,67.34 137.93,67.34 137.74,67.15 137.74,66.54 137.59,66.39 136.98,66.39 136.74,66.15 136.74,45.52 136.91,45.34 137.44,45.34 137.74,45.05 137.74,44.64 138.03,44.34 138.44,44.34 138.74,44.05 138.74,43.46 138.91,43.29 139.5,43.29 139.74,43.06 139.74,42.45 139.42,42.14 ; v4(160.36,31.61) 160.36,31.61 160.62,31.61 160.71,31.52 160.71,31.37 160.55,31.22 160.16,31.22 159.96,31.02 159.96,30.64 159.72,30.41 156.99,30.41 156.76,30.64 156.76,30.97 156.52,31.21 154.42,31.21 154.31,31.09 154.31,30.76 154.14,30.6 153.97,30.6
  14_SIG4 w0.14: 153.97,30.6 152.39,30.6 152.22,30.76 152.22,30.92 152.03,31.11 151.65,31.11 151.46,30.92 151.46,30.76 151.29,30.6 150.68,30.6 150.37,30.91 150.37,32.49 150.15,32.7 149.68,32.7 149.46,32.49 149.46,31.81 149.29,31.65 149.01,31.65 148.82,31.84 148.82,32.51 148.63,32.7 147.28,32.7 145.15,34.83 145.15,35.03 145.45,35.33 145.45,35.56 145.28,35.73 145.05,35.73 144.75,35.43 144.55,35.43 144.34,35.64 144.34,35.84 144.64,36.14 144.64,36.37 144.47,36.54 144.24,36.54 143.94,36.24 143.74,36.24 143.54,36.45 143.54,36.65 143.83,36.94 143.83,37.18 143.67,37.35 143.43,37.35 143.13,37.05 142.93,37.05 142.73,37.26 142.73,37.45 143.03,37.75 143.03,37.99 142.86,38.16 142.62,38.16 142.32,37.86 142.13,37.86 141.92,38.07 141.92,38.26 142.22,38.56 142.22,38.8 142.05,38.97 141.81,38.97 141.51,38.67 141.32,38.67 139.42,40.56 139.42,42.14
DDR4_C2_DQ69: length 72.5
  TOP w0.152: U139.H8 v4(160.36,37.21) ; v2(140.24,69.84) 139.74,69.34 U1.BE27
  14_SIG4 w0.089: v2(140.24,69.84) 139.74,70.05 139.53,70.26 139.07,70.26 138.78,69.97 138.78,69.82 138.3,69.33 138.15,69.33 137.76,68.94 137.76,68.79 137.36,68.39 137.23,68.39 136.83,68 136.83,67.85 136.36,67.38 136.13,67.38 135.94,67.19 135,65.43 134.74,64.8 134.74,45.76 135.23,45.27 135.42,45.27 135.72,44.97 135.72,44.76 136.14,44.34 136.43,44.34 136.68,44.09 136.68,42.96 137.37,40.73 ; v4(160.36,37.21) 160.66,36.91 160.76,36.67 160.76,36.25 161,36.01 161.32,36.01 161.56,35.77 161.56,35.45 162.17,34.65 162.2,34.58 162.2,31.72 161.74,30.62
  14_SIG4 w0.14: 161.74,30.62 161.71,30.53 160.49,29.31 160,29.11 156.08,29.11 155.94,29.25 148.85,29.25 137.37,40.73
DDR4_C2_DQ70: length 72.6
  TOP w0.152: U139.J3 v4(161.16,33.21) ; v2(139.24,67.84) 138.74,67.34 U1.BD25
  14_SIG4 w0.089: v4(161.16,33.21) 161.16,32.94 161.01,32.79 160.82,32.79 160.76,32.86 160.76,33.54 160.83,33.61 161.01,33.61 161.16,33.76 161.16,33.89 160.99,34.07 158.94,34.07 158.84,34.17 158.84,34.39 158.92,34.47 161.41,34.47 161.58,34.3 161.58,32.29 161.56,32.26 161.56,32.24 161.32,32.01 161.31,32.01 161.3,32.01 160.05,32.01 159.96,31.92 159.96,31.64 159.96,31.63 159.96,31.44 159.72,31.21 156.97,31.21 156.76,31.42 156.76,31.86 156.6,32.02 156.58,32.01 154.48,32.01 153.97,31.5 ; v2(139.24,67.84) 139.24,67.82 138.74,67.32 138.74,66.46 138.92,66.28 138.92,65.96 138.59,65.63 138.3,65.63 137.89,66.04 137.28,66.04 137.05,65.82 137.05,65.66 137.28,65.44 137.49,65.44 137.74,65.19 137.74,45.44 137.91,45.27 138.45,45.27 138.68,45.04 138.68,44.65 139,44.34 139.45,44.34 139.72,44.07 139.72,43.63 140.05,43.31
  14_SIG4 w0.14: 140.05,43.31 140.65,42.7 140.65,41.54 140.14,41.03 140.14,40.79 140.31,40.63 140.54,40.63 141.06,41.14 141.29,41.14 141.46,40.97 141.46,40.74 140.95,40.22 140.95,39.99 141.25,39.69 141.54,39.69 141.77,39.92 142.09,39.92 146.15,35.85 146.15,34.75 147.45,33.45 150.39,33.45 151.12,32.72 151.12,32.1 151.37,31.85 152.31,31.85 152.86,31.3 153.77,31.3 153.97,31.5
DDR4_C2_DQ71: length 73
  TOP w0.152: U1.BD26 138.74,68.34 v2(139.24,68.84) ; U139.J7 v4(161.16,35.61)
  14_SIG4 w0.089: 160.76,30.62 160.76,30.97 160.99,31.21 161.3,31.21 161.9,31.8 161.9,34.47 161.35,35.01 161.24,35.01 161.02,34.79 158.9,34.79 158.79,34.89 158.79,35.01 158.96,35.18 160.95,35.18 161.16,35.39 v4(161.16,35.61) ; 137.74,41.31 137.74,44.13 137.52,44.34 137.03,44.34 136.74,44.64 136.74,44.67 136.74,44.68 136.74,45.05 136.44,45.34 135.93,45.34 135.74,45.53 135.74,65.36 135.85,65.47 136.14,65.47 136.24,65.58 136.24,65.74 136.14,65.84 135.85,65.84 135.74,65.95 135.74,66.09 135.94,66.29 136.42,66.29 136.74,66.6 136.74,67.05 137.03,67.34 137.44,67.34 137.74,67.64 137.74,68.05 138.03,68.34 138.42,68.34 138.92,68.84 v2(139.24,68.84)
  14_SIG4 w0.14: 160.76,30.62 160.76,30.51 160.17,29.92 159.82,29.77 156.63,29.77 156.48,29.92 149.12,29.92 148.64,30.41 148.64,30.61 148.77,30.74 148.77,30.94 148.47,31.23 148.27,31.23 148.14,31.1 147.94,31.1 137.74,41.31
DDR4_C2_DQ72: length 59
  TOP w0.152: U1.BC25 137.74,67.34 v2(138.24,67.84) ; U139.A3 v4(154.76,33.21)
  03_SIG1 w0.173: v4(154.76,33.21) 155.96,34.41 155.96,36.57 155.72,36.81 154.28,36.81 153.97,37.12 ; v2(138.24,67.84) 137.84,67.84 137.74,67.74 137.74,66.61 138,66.34 139.37,66.34 139.74,65.98 139.74,63.58 139.96,63.36 140.52,63.36 140.74,63.15 140.74,62.7 141.12,62.32 141.47,62.32 142.45,61.33 142.63,61.33
  03_SIG1 w0.262: 153.97,37.12 153.88,37.2 153.88,37.21 152.49,38.6 152.49,38.9 151.82,39.57 151.82,40.07 151.02,40.88 150.15,40.88 145.72,45.31 145.72,50.22 145.9,50.39 146.23,50.39 146.38,50.24 146.38,45.77 146.57,45.59 146.86,45.59 147.04,45.77 147.04,50.82 146.75,51.11 145.96,51.11 145.75,51.32 145.75,58.65 143.06,61.33 142.63,61.33
DDR4_C2_DQ73: length 58.7
  TOP w0.152: U1.BC26 137.74,68.34 v2(138.24,68.84) ; U139.B8 v4(155.56,37.21)
  03_SIG1 w0.173: 154.03,37.96 154.38,37.61 155.45,37.61 155.56,37.5 v4(155.56,37.21) ; 142.63,62.63 142.04,62.63 141.79,62.88 141.79,63.18 141.58,63.4 140.96,63.4 140.74,63.62 140.74,67.17 140.56,67.34 139.03,67.34 138.74,67.64 138.74,68.1 138.24,68.6 v2(138.24,68.84)
  03_SIG1 w0.262: 142.63,62.63 142.68,62.63 145.92,59.39 147.04,59.39 147.35,59.08 147.35,58.42 147.12,58.19 146.58,58.19 146.41,58.01 146.41,57.59 146.58,57.41 147.12,57.41 147.35,57.18 147.35,56.85 147.12,56.62 146.62,56.62 146.41,56.41 146.41,56.05 146.62,55.84 147.13,55.84 147.35,55.63 147.35,55.27 147.13,55.05 146.62,55.05 146.41,54.84 146.41,54.54 146.59,54.36 147.18,54.36 147.35,54.19 147.35,53.78 147.18,53.62 146.61,53.62 146.41,53.42 146.41,51.94 146.58,51.77 146.86,51.77 147.04,51.95 147.04,52.8 147.23,52.98 147.49,52.98 147.7,52.77 147.7,45.47 148.73,44.44 148.73,44.11 148.53,43.92 148.53,43.59 148.76,43.36 149.09,43.36 149.28,43.56 149.61,43.56 149.86,43.31 149.86,42.93 150.34,42.44 150.93,42.44 151.22,42.15 151.22,41.74 152.47,40.49 152.47,39.91 152.89,39.5 153.29,39.5 154.56,40.77 154.56,41.61 154.81,41.86 155.27,41.86 155.46,41.67 155.46,40.7 154.03,39.27 154.03,37.96
DDR4_C2_DQ74: length 59
  TOP w0.152: U1.BB28 136.74,70.34 v2(137.24,70.84) ; U139.C3 v4(156.36,33.21)
  03_SIG1 w0.173: 159.16,39 159.16,34.18 159.07,34.09 158.77,34.09 158.59,34.26 158.59,34.86 158.48,34.97 158.2,34.97 158.11,34.89 158.11,34.18 158.02,34.09 156.46,34.09 156.36,33.98 v4(156.36,33.21) ; v2(137.24,70.84) 137.74,71.34 141.44,71.34 142.63,70.16
  03_SIG1 w0.262: 142.63,70.16 143.54,69.25 143.54,65.43 146.91,62.05 148.21,62.05 149.69,60.57 149.69,60.54 149.92,60.31 149.92,54.63 150.44,54.1 150.93,54.1 151.74,53.29 151.74,50.72 152.58,49.89 152.58,46.05 153.75,44.88 153.75,44.53 154.2,44.07 158.72,44.07 159.16,43.64 159.16,39
DDR4_C2_DQ75: length 56.6
  TOP w0.152: U1.BC28 137.74,70.34 v2(138.24,70.84) ; U139.C7 v4(156.36,35.61)
  03_SIG1 w0.173: v2(138.24,70.84) 138.48,70.84 138.98,70.34 141.44,70.34 142.63,69.16 ; v4(156.36,35.61) 156.36,34.69 156.58,34.47 157.39,34.47 157.56,34.64 157.56,38.59 157.96,39
  03_SIG1 w0.262: 142.63,69.16 142.89,68.9 142.89,65.16 146.66,61.39 147.93,61.39 149.27,60.05 149.27,54.33 150.24,53.37 150.62,53.37 151.08,52.91 151.08,49.96 151.26,49.78 151.63,49.78 151.89,49.52 151.89,48.88 151.6,48.59 151.27,48.59 151.05,48.38 151.05,47.83 151.24,47.64 151.78,47.64 151.92,47.5 151.92,46.88 151.7,46.66 151.22,46.66 151.08,46.52 151.08,46.15 151.34,45.89 151.82,45.89 152.5,45.21 152.5,44.2 152.76,43.94 153.42,43.94 153.82,43.54 158.06,43.54 158.48,43.12 158.48,39.51 157.96,39
DDR4_C2_DQ76: length 59.5
  TOP w0.152: U139.C2 v4(156.36,31.61) ; U1.AY27 134.74,69.34 v2(135.24,69.84)
  03_SIG1 w0.173: v2(135.24,69.84) 134.74,69.34 134.74,66.4 135.35,65.78 136.06,65.78 136.74,65.11 136.74,63.58 136.97,63.34 137.5,63.34 137.73,63.12 137.73,63.06 137.74,63.05 137.74,62.6 137.99,62.34 138.5,62.34 138.74,62.1 138.74,61.56 138.96,61.34 139.53,61.34 139.74,61.13 139.74,60.58 139.97,60.34 140.58,60.34 140.74,60.18 140.74,59.64 141.03,59.34 141.54,59.34 ; v4(156.36,31.61) 156.36,31.92 156.27,32.01 154.28,32.01 154.05,31.78 153.97,31.78
  03_SIG1 w0.262: 153.97,31.78 153.21,31.78 151.83,33.15 151.83,33.4 152.03,33.59 152.28,33.59 153.47,32.41 153.71,32.41 153.88,32.57 153.88,32.92 152.35,34.44 151.96,34.44 151.41,33.89 151.16,33.89 150.94,34.11 150.94,35.18 151.08,35.32 151.43,35.32 151.57,35.46 151.57,35.94 151.43,36.08 151.08,36.08 150.94,36.22 150.94,36.55 142.39,45.1 142.39,48.28 141.78,48.89 141.78,59.1 141.54,59.34
DDR4_C2_DQ77: length 60.6
  TOP w0.152: v2(135.24,70.84) 134.74,70.34 U1.AY28 ; U139.C8 v4(156.36,37.21)
  03_SIG1 w0.173: v4(156.36,37.21) 155.96,37.61 155.96,38.68 156.27,39 ; v2(135.24,70.84) 135.74,70.34 136.44,70.34 136.74,70.05 136.74,69.88 136.74,69.64 137.03,69.34 137.19,69.34 137.19,69.34 138.28,69.34 138.44,69.34 138.74,69.05 138.74,68.79 138.74,68.64 139.03,68.34 139.19,68.34 139.19,68.34 141.51,68.34 141.76,68.09 141.76,64.47 142.63,63.6
  03_SIG1 w0.262: 142.63,63.6 146.15,60.07 147.29,60.07 147.99,59.38 147.99,53.72 148.39,53.32 148.39,45.77 150.22,43.94 150.65,43.94 151.87,42.72 151.87,42.01 153.05,40.83 153.69,40.83 153.95,41.09 153.95,41.78 154.59,42.42 155.96,42.42 156.08,42.3 156.08,40.58 155.07,39.57 155.07,39.31 155.26,39.12 155.51,39.12 156.74,40.36 156.74,42.24 156.93,42.42 157.15,42.42 157.41,42.16 157.41,40.14 156.27,39
DDR4_C2_DQ78: length 58.1
  TOP w0.152: v2(136.24,69.84) 135.74,69.34 U1.BA27 ; U139.D3 v4(157.16,33.21)
  03_SIG1 w0.173: v4(157.16,33.21) 157.16,33.49 157.28,33.61 159.72,33.61 159.96,33.37 159.96,32.12 159.85,32.01 156.99,32.01 156.76,32.24 156.76,32.57 156.52,32.81 154.92,32.81 154.59,32.81 154.36,33.04 154.36,33.35 153.97,33.74 ; 141.78,59.94 141.37,60.36 141.04,60.36 140.76,60.63 140.76,60.97 140.4,61.34 140,61.34 139.74,61.6 139.74,62.05 139.44,62.34 139,62.34 138.74,62.61 138.74,63.05 138.44,63.34 138.02,63.34 137.74,63.63 137.74,65.32 137.56,65.49 136.88,65.49 135.74,66.64 135.74,69.34 v2(136.24,69.84)
  03_SIG1 w0.262: 153.97,33.74 152.24,35.47 152.24,36.22 142.98,45.48 142.98,48.66 142.67,48.97 142.67,58.5 142.24,58.93 142.24,59.49 141.78,59.94
DDR4_C2_DQ79: length 58.1
  TOP w0.152: v2(137.24,69.84) 136.74,69.34 U1.BB27 ; U139.D7 v4(157.16,35.61)
  03_SIG1 w0.173: v4(157.16,35.61) 156.76,36.01 156.76,38.76 156.99,39 ; v2(137.24,69.84) 137.74,70.34 138.44,70.34 138.74,70.05 138.74,69.64 139.03,69.34 141.44,69.34 141.73,69.06
  03_SIG1 w0.262: 156.99,39 157.91,39.91 157.91,42.59 157.54,42.96 154.16,42.96 153.58,42.37 152.85,42.37 152.58,42.64 152.58,43.22 151.79,44.01 151.79,44.78 151.33,45.24 150.19,45.24 149.89,45.54 149.89,46.12 149.66,46.35 149.28,46.35 149.05,46.58 149.05,46.9 149.28,47.13 149.68,47.13 149.91,47.36 149.91,47.69 149.68,47.92 149.28,47.92 149.05,48.15 149.05,48.47 149.28,48.7 149.71,48.7 149.94,48.93 149.94,49.26 149.71,49.49 149.28,49.49 149.05,49.72 149.05,50.04 149.28,50.27 150.11,50.27 150.34,50.5 150.34,50.83 150.11,51.06 149.28,51.06 149.05,51.29 149.05,51.61 149.28,51.84 149.66,51.84 149.89,52.07 149.89,52.73 148.63,53.99 148.63,59.78 147.68,60.73 146.41,60.73 142.32,64.82 142.32,68.47 141.73,69.06
DDR4_C2_DQS0_C: length 66
  TOP w0.145: v4(158.76,47.56) U135.F3 ; v2(141.24,73.84) U1.BF31
  07_SIG3 w0.178: 153.97,51.45 154.09,51.45 154.36,51.18 154.36,49.77 155.79,48.34 156.13,48.34 156.31,48.51 156.31,48.87 156.48,49.05 156.84,49.05 157.02,48.87 157.02,48.51 157.2,48.34 158.2,48.34 158.76,47.77 v4(158.76,47.56)
  07_SIG3 w0.208: v2(141.24,73.84) 141.55,73.53 142.61,73.53 143.35,72.79 143.35,68.71 143.68,68.38 143.86,68.38 144.03,68.55 144.03,73.32 144.35,73.63 144.88,73.63 145.2,73.32 145.2,72 145.63,71.56 145.63,69.47 145.77,69.33 146.19,69.33 146.36,69.49 146.36,71.51 146.68,71.83 147.08,71.83 147.53,71.38 147.53,69.42 147.67,69.28 149.39,69.28 149.8,68.87 149.8,68.44 149.47,68.11 147.71,68.11 147.57,67.97 147.57,67.63 147.24,67.3 146.71,67.3 146.4,67.62 146.4,67.97 146.26,68.11 145.77,68.11 145.63,67.97 145.63,65.21 147.39,63.45 149.08,63.45 149.91,62.62 149.91,54.59 150.65,53.86 153.19,53.86 153.82,53.23 153.82,52.46 153.47,52.12 153.13,52.12 152.91,51.89 152.91,51.59 153.05,51.45 153.97,51.45
DDR4_C2_DQS0_T: length 66.1
  TOP w0.145: v2(141.24,72.84) U1.BF30 ; U135.G3 v4(159.56,47.56)
  07_SIG3 w0.178: 153.97,51.14 154.05,51.06 154.05,49.64 155.67,48.03 158.07,48.03 158.36,47.74 158.36,47.39 158.59,47.16 158.92,47.16 159.32,47.56 v4(159.56,47.56)
  07_SIG3 w0.208: v2(141.24,72.84) 141.61,73.22 142.49,73.22 143.05,72.66 143.05,68.59 143.56,68.07 143.98,68.07 144.33,68.43 144.33,73.19 144.47,73.33 144.75,73.33 144.89,73.19 144.89,71.87 145.33,71.43 145.33,69.34 145.65,69.02 146.32,69.02 146.66,69.37 146.66,71.39 146.8,71.53 146.95,71.53 147.22,71.26 147.22,69.29 147.54,68.97 149.27,68.97 149.5,68.74 149.5,68.56 149.35,68.41 147.58,68.41 147.26,68.09 147.26,67.75 147.12,67.61 146.84,67.61 146.7,67.74 146.7,68.09 146.38,68.41 145.65,68.41 145.33,68.09 145.33,65.08 147.26,63.15 148.96,63.15 149.61,62.49 149.61,54.47 150.52,53.56 153.06,53.56 153.51,53.11 153.51,52.59 153.35,52.42 153.01,52.42 152.6,52.02 152.6,51.47 152.93,51.14 153.97,51.14
DDR4_C2_DQS1_C: length 53.6
  TOP w0.145: U135.A7 v4(154.76,49.96) ; U1.BA34 v2(136.24,76.84)
  14_SIG4 w0.107: v2(136.24,76.84) 136.24,76.43 136.15,76.35 135.85,76.35 135.77,76.43 135.77,77.09 135.92,77.24 136.55,77.24 136.85,77.54 136.85,78.03 137.06,78.24 138.54,78.24 138.84,78.54 138.84,80.02 139.06,80.24 142.55,80.24 142.6,80.19 142.63,80.19
  14_SIG4 w0.108: 153.97,51.65 153.98,51.63 154.02,51.63 154.12,51.54 154.12,50.48 154.64,49.96 v4(154.76,49.96)
  14_SIG4 w0.14: 153.97,51.65 151.46,54.15 151.46,62.66 152.2,63.4 152.2,67.94 149.63,70.51 149.63,74.09 148.51,75.21 148.51,75.66 148.79,75.93 148.79,76.15 148.56,76.38 148.34,76.38 148.08,76.11 147.61,76.11 147.16,76.56 147.16,77.03 147.43,77.29 147.43,77.51 147.2,77.74 146.99,77.74 146.72,77.47 146.25,77.47 145.81,77.92 145.81,78.38 146.07,78.65 146.07,78.87 145.85,79.1 145.63,79.1 145.36,78.83 144.9,78.83 144.45,79.28 144.45,79.74 144.82,80.12 144.82,80.31 144.6,80.54 144.35,80.54 144.01,80.19 142.63,80.19
DDR4_C2_DQS1_T: length 53.7
  TOP w0.145: v4(155.56,49.96) U135.B7 ; U1.AY34 v2(135.24,76.84)
  14_SIG4 w0.107: 142.63,80.5 142.6,80.5 142.55,80.45 138.98,80.45 138.64,80.11 138.64,78.62 138.46,78.44 136.98,78.44 136.65,78.11 136.65,77.62 136.47,77.44 135.84,77.44 v2(135.24,76.84)
  14_SIG4 w0.108: 154.18,51.86 154.2,51.84 154.2,51.8 154.36,51.64 154.36,50.58 154.58,50.36 155.15,50.36 v4(155.56,49.96)
  14_SIG4 w0.14: 154.18,51.86 153.55,52.5 151.76,54.28 151.76,62.54 152.5,63.27 152.5,68.07 149.94,70.64 149.94,74.22 148.82,75.34 148.82,75.53 149.09,75.81 149.09,76.28 148.69,76.68 148.22,76.68 147.95,76.42 147.74,76.42 147.47,76.69 147.47,76.9 147.74,77.17 147.74,77.64 147.33,78.04 146.86,78.04 146.59,77.78 146.38,77.78 146.11,78.05 146.11,78.26 146.38,78.52 146.38,79 145.97,79.4 145.5,79.4 145.23,79.13 145.02,79.13 144.75,79.4 144.75,79.62 145.13,79.99 145.13,80.44 144.72,80.84 144.23,80.84 143.88,80.5 142.63,80.5
DDR4_C2_DQS2_C: length 46.4
  TOP w0.145: v2(133.24,71.84) 132.74,71.34 U1.AV29 ; v4(158.76,61.66) U136.F3
  05_SIG2 w0.127: 142.46,63.85 142.46,63.93 142.15,64.24 140.99,64.24 140.63,64.59 140.63,65.08 140.31,65.41 139.61,65.41 138.63,66.39 138.63,67.01 138.4,67.24 137.99,67.24 137.63,67.6 137.63,68.01 137.4,68.24 136.99,68.24 136.63,68.59 136.63,69 136.4,69.24 135.99,69.24 135.63,69.59 135.63,70 135.4,70.24 134.99,70.24 134.63,70.6 134.63,71.01 134.4,71.24 133.99,71.24 133.63,71.59 133.63,72.01 133.4,72.24 132.98,72.24 132.77,72.02 132.77,71.62 132.94,71.45 133.13,71.45 133.24,71.56 v2(133.24,71.84)
  05_SIG2 w0.178: v4(158.76,61.66) 159.01,61.9 159.01,62.01 158.92,62.09 154.58,62.09 154.3,61.81 154.3,60.12 153.97,59.78 ; 142.63,63.68 142.46,63.85
  05_SIG2 w0.208: 153.97,59.78 153.86,59.68 152.61,59.68 152.43,59.5 152.43,57.39 152.09,57.06 151.58,57.06 151.19,57.45 151.19,59.55 151.06,59.68 150.08,59.68 149.95,59.55 149.95,58.14 149.64,57.83 148.89,57.83 148.47,58.25 148.47,59.95 148.36,60.06 146.24,60.06 142.63,63.68
