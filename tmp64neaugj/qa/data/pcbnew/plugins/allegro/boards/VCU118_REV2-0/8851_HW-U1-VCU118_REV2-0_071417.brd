# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FIREFLY_RX4_P: length 72.4
  TOP w0.104: J6.A14 41.64,64.58 arc(41.63,64.54) 41.61,64.5 41.53,64.43 arc(41.51,64.4) 41.5,64.36 41.5,64.04 arc(41.59,63.82) 41.81,63.73 42.44,63.73 arc(42.48,63.74) 42.51,63.76 v1(42.87,64.12)
  TOP w0.114: U1.D2 98.74,44.34 v2(98.24,43.84)
  05_SIG2 w0.109: v2(98.24,43.84) 98.24,43.55 arc(98.2,43.48) 98.13,43.44 95.23,43.44 arc(95.12,43.47) 95.02,43.53
  05_SIG2 w0.152: v1(42.87,64.12) 43.13,63.85 arc(43.18,63.82) 43.24,63.81 43.99,63.81 arc(44.19,63.89) 44.27,64.09 44.27,64.46 arc(44.51,65.04) 45.09,65.28 45.56,65.28 arc(45.64,65.31) 45.68,65.39 arc(45.71,65.47) 45.79,65.5 46.33,65.5 arc(46.41,65.47) 46.44,65.39 arc(46.47,65.31) 46.55,65.28 53.79,65.28 arc(55.3,64.98) 56.59,64.12 62.41,58.3 arc(62.78,57.74) 62.91,57.08 62.91,52.89 arc(63.11,51.93) 63.65,51.11 67.2,47.56 arc(68.81,46.49) 70.71,46.11 83.34,46.11 arc(83.9,46) 84.38,45.68 85.44,44.62 arc(86.64,43.82) 88.06,43.53 95.02,43.53
FIREFLY_SCL: length 82.6
  TOP w0.152: v1(45.39,88.44) 45.14,88.19 43.44,88.19 41.86,86.6 41.86,86.24 41.64,86.02 J6.8
  03_SIG1 w0.173: v1(59.85,141.42) 59.64,141.63 56.76,141.63 55.5,140.38 55.5,131.84 55.86,131.48 57.8,131.48 59.89,129.39 59.89,124.69 53.36,118.16 53.36,99.01 50.37,96.02 46.46,96.02 44.16,93.71 44.16,88.49 44.45,88.19 44.69,88.19 44.81,88.32 44.81,89.24 44.95,89.38 45.26,89.38 45.39,89.24 v1(45.39,88.44)
  BOTTOM w0.152: U28.20 57.67,143.29 59.54,141.42 v1(59.85,141.42) R94.2
FIREFLY_SDA: length 81.9
  TOP w0.152: J6.7 42.44,86.02 42.21,86.24 42.21,86.46 43.57,87.81 45.11,87.81 v1(45.39,87.53)
  03_SIG1 w0.173: v1(59.85,142.44) 59.6,142.19 56.53,142.19 54.95,140.61 54.95,131.61 55.63,130.93 57.57,130.93 59.34,129.16 59.34,124.92 52.81,118.39 52.81,99.24 50.14,96.57 46.16,96.57 43.61,94.01 43.61,88.26 44.23,87.64 45.28,87.64 v1(45.39,87.53)
  BOTTOM w0.152: R93.2 v1(59.85,142.44) 59.31,142.44 57.81,143.94 U28.19
FIREFLY_TX1_N: length 75.1
  TOP w0.104: v1(49.44,63.92) 49.08,63.56 arc(49.05,63.54) 49.01,63.53 47.96,63.53 arc(47.64,63.67) 47.5,63.99 47.5,64.36 arc(47.51,64.4) 47.53,64.43 47.61,64.5 arc(47.63,64.54) 47.64,64.58 J6.A2
  TOP w0.114: U1.G4 101.74,46.34 v2(101.24,45.84)
  03_SIG1 w0.109: v2(101.24,45.84) 101.24,46.13 arc(101.2,46.21) 101.13,46.24 101.02,46.24 arc(100.89,46.19) 100.84,46.06 100.84,44.62 arc(100.73,44.35) 100.46,44.24 96.12,44.24 arc(95.94,44.21) 95.79,44.11 arc(95.59,43.97) 95.35,43.92 94.97,43.92 arc(94.87,43.9) 94.79,43.85
  03_SIG1 w0.152: 94.79,43.85 86.2,43.85 arc(85.49,43.99) 84.88,44.39 84.02,45.26 arc(83.72,45.46) 83.37,45.53 79.91,45.53 arc(79.71,45.49) 79.54,45.37 arc(79.25,45.18) 78.92,45.11 69.5,45.11 arc(68,45.41) 66.74,46.26 63.76,49.23 arc(63.19,50.08) 63,51.08 63,57.19 arc(62.88,57.78) 62.54,58.28 59.83,60.99 arc(59.38,61.3) 58.84,61.4 48.61,61.4 arc(47.92,61.69) 47.63,62.38 47.63,62.85 arc(47.86,63.38) 48.39,63.61 49.07,63.61 arc(49.12,63.62) 49.17,63.65 v1(49.44,63.92)
FIREFLY_TX1_P: length 75.1
  TOP w0.104: J6.A3 47.14,64.58 arc(47.14,64.54) 47.17,64.5 47.24,64.43 arc(47.26,64.4) 47.27,64.36 47.27,63.99 arc(47.48,63.5) 47.96,63.3 49.01,63.3 arc(49.05,63.29) 49.08,63.27 v1(49.44,62.92)
  TOP w0.114: v2(101.24,46.84) U1.G5
  03_SIG1 w0.109: v2(101.24,46.84) 101.24,46.55 arc(101.2,46.48) 101.13,46.44 101.02,46.44 arc(100.75,46.33) 100.63,46.06 100.63,44.62 arc(100.58,44.5) 100.46,44.44 96.12,44.44 arc(95.87,44.39) 95.65,44.25 arc(95.52,44.16) 95.35,44.13 95.01,44.13 arc(94.9,44.15) 94.8,44.21 94.79,44.23
  03_SIG1 w0.152: 94.79,44.23 86.2,44.23 arc(85.63,44.34) 85.15,44.66 84.29,45.53 arc(83.86,45.81) 83.37,45.91 79.91,45.91 arc(79.57,45.84) 79.27,45.64 arc(79.11,45.53) 78.92,45.5 69.5,45.5 arc(68.15,45.76) 67.01,46.53 64.03,49.5 arc(63.55,50.23) 63.38,51.08 63.38,57.19 arc(63.23,57.92) 62.81,58.55 60.1,61.26 arc(59.52,61.65) 58.84,61.78 53.19,61.78 arc(53.06,61.84) 53,61.97 arc(52.95,62.1) 52.82,62.16 52.58,62.16 arc(52.45,62.1) 52.39,61.97 arc(52.34,61.84) 52.21,61.78 51.97,61.78 arc(51.84,61.84) 51.78,61.97 arc(51.73,62.1) 51.6,62.16 51.36,62.16 arc(51.23,62.1) 51.17,61.97 arc(51.12,61.84) 50.99,61.78 48.61,61.78 arc(48.19,61.96) 48.02,62.38 48.02,62.85 arc(48.13,63.11) 48.39,63.23 49.07,63.23 arc(49.12,63.21) 49.17,63.18 v1(49.44,62.92)
FIREFLY_TX2_N: length 66.3
  TOP w0.104: J6.B2 47.64,67.27 arc(47.63,67.33) 47.59,67.38 47.55,67.42 arc(47.53,67.44) 47.52,67.47 arc(47.51,67.5) 47.5,67.54 47.5,67.56 arc(47.56,67.72) 47.72,67.78 48.32,67.78 arc(48.43,67.73) 48.48,67.62 arc(48.52,67.51) 48.64,67.46 48.84,67.46 arc(48.95,67.51) 49,67.62 arc(49.05,67.73) 49.16,67.78 50.07,67.78 arc(50.11,67.77) 50.14,67.75 v1(50.5,67.4)
  TOP w0.114: v2(100.24,47.84) U1.F6
  03_SIG1 w0.109: v2(100.24,47.84) 100.24,48.13 arc(100.2,48.21) 100.13,48.24 94.95,48.24 arc(94.83,48.22) 94.72,48.15
  03_SIG1 w0.152: 94.72,48.15 90.17,48.15 arc(89.5,48.28) 88.92,48.67 86.97,50.62 arc(86.72,50.79) 86.42,50.85 85.4,50.85 arc(84.85,50.96) 84.39,51.27 83.76,51.89 arc(83.09,52.34) 82.3,52.5 68.91,52.5 arc(67.85,52.94) 67.41,54 67.41,58.22 arc(67.2,59.27) 66.61,60.16 61.41,65.36 arc(60.54,65.94) 59.51,66.14 55.64,66.14 arc(55.32,66.21) 55.04,66.39 53.93,67.5 arc(53.7,67.65) 53.43,67.71 50.87,67.71 arc(50.81,67.69) 50.76,67.66 v1(50.5,67.4)
FIREFLY_TX2_P: length 66.3
  TOP w0.104: v1(50.5,68.4) 50.14,68.04 arc(50.11,68.02) 50.07,68.01 47.72,68.01 arc(47.4,67.88) 47.27,67.56 47.27,67.55 arc(47.27,67.5) 47.25,67.46 arc(47.25,67.45) 47.24,67.45 47.18,67.39 arc(47.15,67.34) 47.14,67.28 J6.B3
  TOP w0.114: v2(100.24,48.84) U1.F7
  03_SIG1 w0.109: v2(100.24,48.84) 100.24,48.55 arc(100.2,48.48) 100.13,48.44 94.93,48.44 arc(94.82,48.47) 94.72,48.53
  03_SIG1 w0.152: v1(50.5,68.4) 50.76,68.13 arc(50.81,68.1) 50.87,68.09 53.43,68.09 arc(53.85,68) 54.2,67.77 55.31,66.66 arc(55.46,66.56) 55.64,66.52 59.51,66.52 arc(60.69,66.29) 61.68,65.62 66.88,60.43 arc(67.55,59.41) 67.79,58.22 67.79,54 arc(68.12,53.21) 68.91,52.88 82.3,52.88 arc(83.24,52.7) 84.03,52.16 84.65,51.54 arc(85,51.31) 85.4,51.23 86.42,51.23 arc(86.86,51.14) 87.24,50.89 89.19,48.94 arc(89.64,48.64) 90.17,48.53 94.72,48.53
FIREFLY_TX3_N: length 90.9
  TOP w0.104: v1(46.39,63.43) 46.1,63.72 arc(46.03,63.83) 46,63.96 46,64.47 arc(46.01,64.53) 46.05,64.58 46.09,64.62 arc(46.13,64.67) 46.14,64.73 J6.A5
  TOP w0.114: v2(99.24,45.84) 99.74,46.34 U1.E4
  03_SIG1 w0.109: v2(99.24,45.84) 99.24,46.13 arc(99.27,46.21) 99.35,46.24 99.46,46.24 arc(99.58,46.19) 99.64,46.06 99.64,45.77 arc(99.54,45.54) 99.31,45.44 94.74,45.44 arc(94.62,45.47) 94.53,45.53
  03_SIG1 w0.152: 94.53,45.53 86.51,45.53 arc(86.08,45.62) 85.71,45.86 85.41,46.17 arc(84.33,46.89) 83.05,47.14 79.14,47.14 arc(78.68,47.05) 78.28,46.79 arc(78.14,46.69) 77.98,46.66 69.29,46.66 arc(68.61,46.8) 68.03,47.18 65.46,49.75 arc(64.97,50.49) 64.8,51.36 64.8,57.17 arc(64.59,58.18) 64.02,59.04 60.72,62.34 arc(58.99,63.5) 56.94,63.91 55.05,63.91 arc(54.72,63.97) 54.44,64.16 53.72,64.88 arc(53.54,65) 53.34,65.04 50.22,65.04 arc(49.4,65.2) 48.71,65.66 48.57,65.8 arc(48.15,66.08) 47.65,66.18 39.72,66.18 arc(38.65,65.74) 38.2,64.67 38.2,62.34 arc(38.42,61.82) 38.94,61.61 42.9,61.61 arc(43.18,61.66) 43.42,61.82 arc(43.5,61.87) 43.59,61.89 45.32,61.89 arc(45.86,62.11) 46.08,62.65 46.08,63.06 arc(46.09,63.12) 46.12,63.17 v1(46.39,63.43)
FIREFLY_TX3_P: length 90.9
  TOP w0.104: v1(45.39,63.43) 45.66,63.71 arc(45.74,63.83) 45.77,63.97 45.77,64.46 arc(45.76,64.53) 45.72,64.58 45.67,64.63 arc(45.65,64.67) 45.64,64.72 J6.A6
  TOP w0.114: v2(99.24,46.84) U1.E5
  03_SIG1 w0.109: v2(99.24,46.84) 99.24,46.55 arc(99.27,46.48) 99.35,46.44 99.46,46.44 arc(99.73,46.33) 99.84,46.06 99.84,45.77 arc(99.68,45.4) 99.31,45.24 94.74,45.24 arc(94.62,45.22) 94.53,45.15
  03_SIG1 w0.152: 94.53,45.15 86.51,45.15 arc(85.93,45.27) 85.44,45.59 85.14,45.9 arc(84.18,46.54) 83.05,46.76 79.14,46.76 arc(78.82,46.7) 78.55,46.52 arc(78.29,46.34) 77.98,46.28 69.29,46.28 arc(68.46,46.44) 67.76,46.91 65.19,49.49 arc(64.62,50.34) 64.41,51.36 64.41,57.17 arc(64.24,58.04) 63.75,58.77 60.45,62.07 arc(58.84,63.15) 56.94,63.53 55.05,63.53 arc(54.57,63.62) 54.17,63.89 53.45,64.61 arc(53.4,64.65) 53.34,64.66 52.67,64.66 arc(52.4,64.55) 52.29,64.28 52.29,64.23 arc(51.9,63.84) 51.52,64.23 51.52,64.28 arc(51.41,64.55) 51.14,64.66 50.22,64.66 arc(49.26,64.85) 48.44,65.39 48.3,65.53 arc(48,65.73) 47.65,65.8 39.72,65.8 arc(38.92,65.47) 38.58,64.67 38.58,62.34 arc(38.69,62.09) 38.94,61.99 41.34,61.99 arc(41.41,62.02) 41.44,62.09 arc(41.47,62.16) 41.54,62.18 42.11,62.18 arc(42.18,62.16) 42.2,62.09 arc(42.23,62.02) 42.3,61.99 42.9,61.99 arc(43.04,62.01) 43.15,62.09 arc(43.36,62.23) 43.59,62.27 45.32,62.27 arc(45.59,62.38) 45.7,62.65 45.7,63.06 arc(45.68,63.12) 45.65,63.17 v1(45.39,63.43)
FIREFLY_TX4_N: length 79
  TOP w0.104: v1(46.39,69.22) 46.11,68.94 46.05,68.86 arc(46.01,68.77) 46,68.68 46,67.55 arc(46.01,67.51) 46.03,67.48 46.11,67.4 arc(46.13,67.37) 46.14,67.33 J6.B5
  TOP w0.114: U1.C4 97.74,46.34 v2(97.24,45.84)
  03_SIG1 w0.109: v2(97.24,45.84) arc(97.12,46.12) 96.84,46.24 95.22,46.24 arc(94.98,46.28) 94.77,46.4 arc(94.68,46.45) 94.58,46.47 94.44,46.47 arc(94.33,46.45) 94.22,46.38
  03_SIG1 w0.152: 94.22,46.38 88.37,46.38 arc(86.58,46.74) 85.06,47.75 84.55,48.27 arc(83.97,48.66) 83.28,48.79 82.73,48.79 arc(82.48,48.74) 82.26,48.6 81.82,48.15 arc(81.54,47.97) 81.22,47.9 68.89,47.9 arc(68.46,47.99) 68.1,48.23 66.37,49.97 arc(65.97,50.55) 65.83,51.25 65.83,57.04 arc(65.59,58.29) 64.88,59.35 61.37,62.86 arc(60.3,63.74) 59.08,64.39 arc(57.76,64.79) 56.39,64.92 55.38,64.92 arc(54.85,65.03) 54.4,65.33 54.15,65.58 arc(53.87,65.77) 53.54,65.83 50.46,65.83 arc(49.76,65.97) 49.17,66.36 48.35,67.18 arc(48.06,67.38) 47.72,67.45 43.59,67.45 arc(42.99,67.69) 42.75,68.28 42.75,70.22 arc(42.99,70.81) 43.59,71.06 45.35,71.06 arc(45.86,70.84) 46.08,70.33 46.08,69.59 46.09,69.53 arc(46.1,69.51) 46.12,69.48 v1(46.39,69.22)
FIREFLY_TX4_P: length 79
  TOP w0.104: v1(45.39,69.22) 45.69,68.92 45.74,68.85 arc(45.76,68.78) 45.77,68.71 arc(45.77,68.69) 45.77,68.68 45.77,67.55 arc(45.76,67.51) 45.74,67.48 45.67,67.4 arc(45.64,67.37) 45.64,67.33 J6.B6
  TOP w0.114: v2(97.24,46.84) U1.C5
  03_SIG1 w0.109: v2(97.24,46.84) 97.24,46.55 arc(97.21,46.48) 97.13,46.44 95.22,46.44 arc(95.05,46.47) 94.9,46.55 arc(94.76,46.64) 94.58,46.68 94.43,46.68 arc(94.32,46.7) 94.22,46.76
  03_SIG1 w0.152: v1(45.39,69.22) 45.65,69.48 arc(45.67,69.51) 45.68,69.53 45.7,69.59 45.7,70.33 arc(45.59,70.57) 45.35,70.68 44.77,70.68 arc(44.59,70.6) 44.51,70.42 arc(44.44,70.24) 44.26,70.16 44.16,70.16 arc(43.98,70.24) 43.9,70.42 43.9,70.52 arc(43.86,70.63) 43.75,70.68 43.59,70.68 arc(43.26,70.54) 43.13,70.22 43.13,69.79 arc(43.2,69.62) 43.36,69.56 arc(43.53,69.49) 43.6,69.32 43.6,69.18 arc(43.53,69.01) 43.36,68.95 arc(43.2,68.88) 43.13,68.71 43.13,68.28 arc(43.26,67.96) 43.59,67.83 43.76,67.83 arc(43.92,67.89) 43.98,68.05 arc(44.05,68.2) 44.2,68.27 44.37,68.27 arc(44.53,68.2) 44.59,68.05 arc(44.66,67.89) 44.81,67.83 47.72,67.83 arc(48.21,67.73) 48.62,67.45 49.44,66.63 arc(49.91,66.32) 50.46,66.21 53.54,66.21 arc(54.02,66.12) 54.42,65.85 54.67,65.6 arc(55,65.38) 55.38,65.3 56.39,65.3 arc(57.84,65.16) 59.23,64.74 arc(60.51,64.05) 61.63,63.13 65.15,59.62 arc(65.94,58.43) 66.22,57.04 66.22,51.25 arc(66.32,50.7) 66.63,50.24 68.37,48.5 arc(68.61,48.34) 68.89,48.29 81.22,48.29 arc(81.4,48.32) 81.55,48.42 81.99,48.87 arc(82.33,49.09) 82.73,49.17 83.28,49.17 arc(84.11,49.01) 84.82,48.54 85.33,48.02 arc(86.72,47.09) 88.37,46.76 94.22,46.76
FMC_HPC1_CLK0_M2C_N: length 148.8
  TOP w0.104: J2.H5 v1(171.86,167.13) ; v2(138.24,49.84) U1.BC8
  16_SIG5 w0.076: v2(138.24,49.84) 138.24,50.17 138.31,50.24 141.72,50.24 141.76,50.2 141.78,50.2
  16_SIG5 w0.089: v1(171.86,167.13) 172.62,167.9 173.54,167.9 173.9,167.54 173.9,155.89 176.92,152.87 176.92,142.67 176,141.75 176,123.91 175.45,123.37 175.45,116.42 166.9,107.87 166.19,107.87 162.27,103.96 161.65,103.96 160.63,102.93 160.63,98.66 158.69,96.73 156.23,96.73 154.32,94.82 154.32,53.48 151.05,50.2 141.78,50.2
FMC_HPC1_CLK0_M2C_P: length 148.9
  TOP w0.104: v2(138.24,50.84) U1.BC9 ; J2.H4 v1(173.13,167.13)
  16_SIG5 w0.076: v2(138.24,50.84) 138.24,50.52 138.31,50.44 141.72,50.44 141.76,50.48 141.78,50.48
  16_SIG5 w0.089: 141.78,50.48 150.93,50.48 154.04,53.59 154.04,94.94 156.11,97.01 158.58,97.01 160.35,98.78 160.35,103.05 161.54,104.24 162.16,104.24 166.08,108.15 166.79,108.15 175.17,116.54 175.17,123.48 175.72,124.03 175.72,141.85 175.77,141.91 176.64,142.78 176.64,152.75 173.62,155.77 173.62,167.43 173.43,167.62 172.74,167.62 172.44,167.32 172.44,166.73 172.55,166.62 172.95,166.62 173.13,166.8 v1(173.13,167.13)
FMC_HPC1_CLK1_M2C_N: length 161.8
  TOP w0.104: U1.AV13 132.74,55.34 v2(133.24,54.84) ; J2.G3 v1(174.4,165.86)
  18_SIG6 w0.076: 142.12,48.2 142.08,48.24 141.4,48.24 140.4,48.24 139.4,48.24 138.4,48.24 137.4,48.24 136.37,48.24 134.9,48.24 134.64,48.5 134.64,52.01 134.4,52.24 133.83,52.24 133.64,52.44 133.64,55.11 133.5,55.24 133.35,55.24 133.24,55.13 v2(133.24,54.84)
  18_SIG6 w0.089: v1(174.4,165.86) 175.17,166.64 176.01,166.64 176.44,166.2 176.44,145.59 174.15,143.3 174.15,139.03 172.94,137.83 172.94,106.51 172.57,106.14 172.57,104.4 172.86,104.11 172.86,99.08 171.42,97.64 168.41,97.64 166.21,95.43 154.96,95.43 154.33,94.8 154.33,89.48 152.13,87.28 150.9,87.28 149.78,86.15 149.78,70.18 146.27,66.68 146.27,51.71 142.77,48.2 142.12,48.2
FMC_HPC1_CLK1_M2C_P: length 161.6
  TOP w0.104: v2(133.24,55.84) 132.74,56.34 U1.AV14 ; J2.G2 v1(175.67,165.86)
  18_SIG6 w0.076: v2(133.24,55.84) 133.24,55.55 133.35,55.44 133.58,55.44 133.84,55.19 133.84,52.52 133.92,52.44 134.49,52.44 134.84,52.09 134.84,48.59 134.98,48.44 136.45,48.44 136.45,48.44 136.99,48.44 137.99,48.44 138.99,48.44 139.99,48.44 140.99,48.44 142.06,48.44 142.09,48.48 142.12,48.48
  18_SIG6 w0.089: v1(175.67,165.86) 175.67,165.62 175.49,165.44 175.18,165.44 175.02,165.61 175.02,166.09 175.29,166.36 175.89,166.36 176.16,166.09 176.16,145.71 173.87,143.41 173.87,139.15 172.66,137.95 172.66,106.62 172.29,106.26 172.29,104.29 172.59,104 172.59,99.2 171.3,97.92 168.29,97.92 166.09,95.71 154.84,95.71 154.05,94.92 154.05,89.59 152.01,87.56 150.79,87.56 149.5,86.26 149.5,70.3 145.99,66.8 145.99,51.82 142.65,48.48 142.12,48.48
FMC_HPC1_IIC_SCL: length 76
  TOP w0.14: U80.9 143.69,121.52 v1(144.34,122.17)
  TOP w0.152: J2.C30 v1(140.11,160.78)
  05_SIG2 w0.173: v1(144.34,122.17) 143.71,122.8 143.71,123.88 143.32,124.27 143.32,127.23 142.76,127.79 142.76,129.05 143.22,129.52 145.88,129.52 147.25,130.89 147.25,143.27 145.53,145 145.53,146.61 145.7,146.79 152.14,146.79 152.86,147.51 152.86,149.61 152.15,150.32 149.56,150.32 149.39,150.49 149.39,154.59 148.75,155.23 147.2,155.23 146.55,154.58 146.55,151.25 146.4,151.09 143.82,151.09 142.4,152.51 142.4,156.02 140.76,157.65 140.76,160.88 140.57,161.07 140.4,161.07 v1(140.11,160.78)
  BOTTOM w0.152: v1(144.34,122.17) 143.77,122.73 142.27,122.73 141.36,123.64 R626.2
FMC_HPC1_IIC_SDA: length 74.1
  TOP w0.14: U80.8 v1(143.19,120.87)
  TOP w0.152: J2.C31 v1(138.84,160.78)
  05_SIG2 w0.173: v1(143.19,120.87) 142.57,121.49 142.57,124.03 142.76,124.23 142.76,127 142.2,127.56 142.2,129.28 142.99,130.07 145.66,130.07 146.7,131.12 146.7,143.04 144.97,144.77 144.97,146.84 145.47,147.34 151.91,147.34 152.3,147.74 152.3,149.38 151.92,149.76 149.33,149.76 148.83,150.26 148.83,154.36 148.52,154.68 147.43,154.68 147.11,154.35 147.11,151.02 146.63,150.54 143.59,150.54 141.84,152.28 141.84,154.53 141.84,154.53 141.84,155.79 140.13,157.5 139.83,157.5 139.42,157.9 139.42,160.19 v1(138.84,160.78)
  BOTTOM w0.152: R625.2 142.53,120.21 v1(143.19,120.87)
FMC_HPC1_LA00_CC_N: length 147.7
  TOP w0.104: U1.BA9 v2(136.24,50.84) ; J2.G7 v1(169.32,165.86)
  16_SIG5 w0.076: v2(136.24,50.84) 135.91,50.84 135.84,50.92 135.84,52.01 136.07,52.24 137.4,52.24 137.64,52.01 137.64,51.59 137.99,51.24 141.88,51.24 141.93,51.2 141.94,51.2
  16_SIG5 w0.089: 141.94,51.2 142.4,51.2 145.51,51.2 149.13,54.82 149.13,58.54 150.33,59.74 150.74,59.74 152.59,61.59 152.59,85.48 153.35,86.25 153.35,95.9 154.3,96.84 155.04,96.84 155.85,97.66 157.26,97.66 158.21,98.61 158.21,101.73 158.57,102.09 158.57,102.96 159.97,104.36 159.97,105.96 160.34,106.34 163.21,106.34 169.82,112.95 169.82,116 173.28,119.46 173.28,138.19 174.03,138.94 174.03,142.46 174.62,143.05 174.62,153.74 171.36,157 171.36,166.19 170.92,166.64 170.09,166.64 v1(169.32,165.86)
FMC_HPC1_LA00_CC_P: length 147.8
  TOP w0.104: J2.G6 v1(170.59,165.86) ; U1.AY9 v2(135.24,50.84)
  16_SIG5 w0.076: 141.94,51.48 141.93,51.48 141.88,51.44 138.07,51.44 137.84,51.68 137.84,52.09 137.49,52.44 135.99,52.44 135.64,52.09 135.64,50.92 135.56,50.84 v2(135.24,50.84)
  16_SIG5 w0.089: v1(170.59,165.86) 170.59,165.55 170.47,165.43 170.11,165.43 169.97,165.57 169.97,166.12 170.21,166.36 170.8,166.36 171.08,166.08 171.08,156.88 174.35,153.62 174.35,143.17 173.75,142.57 173.75,139.06 173,138.31 173,119.58 169.54,116.12 169.54,113.06 163.1,106.62 160.23,106.62 159.69,106.08 159.69,104.47 158.29,103.08 158.29,102.2 157.93,101.84 157.93,98.72 157.14,97.93 155.73,97.93 154.92,97.12 154.18,97.12 153.07,96.02 153.07,86.36 152.31,85.59 152.31,61.71 150.62,60.02 150.21,60.02 148.85,58.65 148.85,54.94 145.39,51.48 141.94,51.48
FMC_HPC1_LA01_CC_N: length 145.9
  TOP w0.104: J2.D9 v1(166.78,162.05)
  TOP w0.152: v2(141.24,50.84) U1.BF9
  18_SIG6 w0.089: v1(166.78,162.05) 167.55,162.83 168.43,162.83 168.82,162.43 168.82,157.73 170.47,156.07 170.47,155.16 170.22,154.91 169.16,154.91 169.07,154.82 169.07,154.47 169.16,154.38 169.78,154.38 170.03,154.13 170.03,153.54 169.78,153.29 169.16,153.29 169.03,153.15 169.03,152.84 169.12,152.75 170.89,152.75 171.45,152.2 171.45,145.74 170.81,145.1 170.81,134.23 171.78,133.26 171.78,128.7 170.46,127.38 170.46,108.29 170.15,107.98 170.15,103.83 171.82,102.15 171.82,100.49 171.04,99.7 169.13,99.7 166.38,96.95 154.03,96.95 153.32,96.24 153.32,90.52 151.18,88.38 150.39,88.38 148.82,86.8 148.82,70.54 145.33,67.06 145.33,52.85 143.71,51.23 141.62,51.23 v2(141.24,50.84)
FMC_HPC1_LA01_CC_P: length 146.1
  TOP w0.104: J2.D8 v1(168.05,162.05)
  TOP w0.152: v2(141.24,51.84) U1.BF10
  18_SIG6 w0.089: v2(141.24,51.84) 141.57,51.51 143.59,51.51 145.05,52.96 145.05,67.17 148.54,70.66 148.54,86.92 150.28,88.66 151.06,88.66 153.04,90.63 153.04,96.36 153.91,97.23 166.26,97.23 169.01,99.98 170.92,99.98 171.54,100.61 171.54,102.04 169.87,103.71 169.87,108.1 170.18,108.41 170.18,127.5 171.5,128.82 171.5,133.14 170.53,134.11 170.53,145.21 171.17,145.85 171.17,152.08 170.78,152.47 169,152.47 168.75,152.73 168.75,153.27 169.05,153.57 169.66,153.57 169.75,153.65 169.75,154.01 169.66,154.1 169.05,154.1 168.8,154.35 168.8,154.94 169.05,155.19 170.11,155.19 170.2,155.28 170.2,155.96 168.54,157.61 168.54,162.32 168.31,162.55 167.67,162.55 167.34,162.22 167.34,161.62 167.47,161.48 167.95,161.48 168.05,161.58 v1(168.05,162.05)
FMC_HPC1_LA02_N: length 149.7
  TOP w0.104: v2(139.24,52.84) U1.BD11 ; J2.H8 v1(168.05,167.13)
  16_SIG5 w0.076: 141.84,52.48 141.83,52.48 141.78,52.44 139.05,52.44 138.84,52.66 138.84,52.77 138.91,52.84 v2(139.24,52.84)
  16_SIG5 w0.089: v1(168.05,167.13) 168.05,167.42 168.11,167.49 168.62,167.49 168.73,167.37 168.73,166.94 168.54,166.75 168.54,157.69 170.65,155.57 170.65,155.38 169.78,154.51 169.78,154.09 170.32,153.54 170.75,153.54 171.43,154.23 171.69,154.23 172.8,153.12 172.8,152.45 172.67,152.32 172.04,152.32 171.74,152.02 171.74,151.52 172.04,151.22 172.67,151.22 172.8,151.09 172.8,150.82 172.67,150.68 172.04,150.68 171.74,150.39 171.74,149.89 172.04,149.59 172.67,149.59 172.8,149.45 172.8,149.18 172.67,149.05 172.04,149.05 171.74,148.75 171.74,148.25 172.04,147.95 172.67,147.95 172.8,147.82 172.8,146.87 172.24,146.31 171.13,146.31 170.51,145.69 170.51,136.02 171.12,135.41 171.12,129.6 169.42,127.89 169.42,119.48 168.03,118.09 168.03,112.95 162.8,107.72 159.96,107.72 158.21,105.97 158.21,104.4 156.97,103.17 156.97,102.09 156.55,101.67 156.55,100.63 155.3,99.39 155.3,98.81 154.73,98.23 153.71,98.23 152.15,96.67 152.15,87.11 151.29,86.24 151.29,62.06 150.52,61.29 148.29,61.29 147.7,60.7 147.7,55.44 144.75,52.48 141.84,52.48
FMC_HPC1_LA02_P: length 149.3
  TOP w0.104: J2.H7 v1(169.32,167.13) ; v2(138.24,52.84) U1.BC11
  16_SIG5 w0.076: v2(138.24,52.84) 138.56,52.84 138.64,52.77 138.64,52.58 138.97,52.24 141.78,52.24 141.83,52.2 141.84,52.2
  16_SIG5 w0.089: 141.84,52.2 144.86,52.2 147.98,55.32 147.98,60.58 148.41,61.01 150.64,61.01 151.56,61.94 151.56,86.13 152.43,86.99 152.43,96.55 153.83,97.95 154.84,97.95 155.58,98.69 155.58,99.28 156.83,100.52 156.83,101.55 157.25,101.97 157.25,103.05 158.49,104.29 158.49,105.86 160.07,107.44 162.92,107.44 168.3,112.83 168.3,117.98 169.7,119.37 169.7,127.77 171.4,129.48 171.4,135.52 170.79,136.14 170.79,145.57 171.25,146.03 172.36,146.03 173.08,146.75 173.08,147.93 172.78,148.23 172.15,148.23 172.02,148.37 172.02,148.63 172.15,148.77 172.78,148.77 173.08,149.07 173.08,149.57 172.78,149.87 172.15,149.87 172.02,150 172.02,150.27 172.15,150.4 172.78,150.4 173.08,150.7 173.08,151.2 172.78,151.5 172.15,151.5 172.02,151.64 172.02,151.91 172.15,152.04 172.78,152.04 173.08,152.34 173.08,153.23 171.81,154.51 171.31,154.51 170.63,153.82 170.44,153.82 170.06,154.2 170.06,154.39 170.93,155.27 170.93,155.69 168.82,157.8 168.82,166.64 v1(169.32,167.13)
FMC_HPC1_LA03_N: length 151
  TOP w0.104: J2.G10 v1(165.51,165.86) ; v2(140.24,53.84) U1.BE12
  16_SIG5 w0.076: 141.88,53.48 141.86,53.48 141.82,53.44 140.05,53.44 139.84,53.66 139.84,53.77 139.91,53.84 v2(140.24,53.84)
  16_SIG5 w0.089: v1(165.51,165.86) 165.74,166.09 166.05,166.09 166.18,165.96 166.18,165.66 166,165.48 166,157.73 168.05,155.69 168.05,153.88 168.78,153.15 168.78,136.18 163.28,130.69 163.28,127.08 163.58,126.78 166.02,126.78 166.15,126.65 166.15,126.11 166.02,125.97 163.58,125.97 163.28,125.68 163.28,124.91 163.58,124.61 166.63,124.61 166.76,124.47 166.76,123.93 166.63,123.8 163.58,123.8 163.28,123.5 163.28,122.73 163.58,122.43 166.16,122.43 166.3,122.3 166.3,121.76 166.16,121.62 163.58,121.62 163.28,121.33 163.28,115.29 157.6,109.61 157.6,107.52 156.78,106.7 156.78,104.81 156.08,104.11 154.37,104.11 153.57,103.3 153.57,102.29 154.1,101.75 154.1,100.85 152.86,99.61 152.86,98.93 152.42,98.49 151.61,98.49 151.11,97.99 151.11,97.12 151.13,97.1 151.13,94.16 151.11,94.13 151.11,93.87 149.83,92.59 149.83,68.59 150.37,68.06 150.37,64.61 146.63,60.87 146.63,55.76 144.36,53.48 141.88,53.48
FMC_HPC1_LA03_P: length 151
  TOP w0.104: J2.G9 v1(166.78,165.86) ; v2(139.24,53.84) U1.BD12
  16_SIG5 w0.076: 141.88,53.2 141.86,53.2 141.82,53.24 139.97,53.24 139.64,53.58 139.64,53.77 139.56,53.84 v2(139.24,53.84)
  16_SIG5 w0.089: 141.88,53.2 144.47,53.2 146.91,55.64 146.91,60.76 150.65,64.49 150.65,68.17 150.11,68.71 150.11,92.48 151.39,93.75 151.39,94.02 151.41,94.04 151.41,97.22 151.39,97.24 151.39,97.87 151.73,98.21 152.54,98.21 153.14,98.82 153.14,99.49 154.38,100.73 154.38,101.87 153.85,102.4 153.85,103.19 154.49,103.83 156.19,103.83 157.06,104.7 157.06,106.59 157.88,107.4 157.88,109.49 163.56,115.17 163.56,121.21 163.7,121.35 166.28,121.35 166.57,121.64 166.57,122.41 166.28,122.71 163.7,122.71 163.56,122.85 163.56,123.39 163.7,123.52 166.75,123.52 167.04,123.82 167.04,124.59 166.75,124.89 163.7,124.89 163.56,125.02 163.56,125.56 163.7,125.69 166.14,125.69 166.43,125.99 166.43,126.76 166.14,127.06 163.7,127.06 163.56,127.2 163.56,130.57 169.06,136.07 169.06,153.27 168.33,154 168.33,155.81 166.28,157.85 166.28,165.37 v1(166.78,165.86)
FMC_HPC1_LA04_N: length 148
  TOP w0.104: v2(141.24,52.84) U1.BF11 ; J2.H11 v1(164.24,167.13)
  18_SIG6 w0.089: v2(141.24,52.84) 141.48,53.08 141.95,53.08 144.25,55.38 144.25,67.33 147.85,70.93 147.85,88.53 152.39,93.07 152.39,96.62 153.65,97.88 159.93,97.88 160.64,98.6 160.64,103.32 161.4,104.08 162.41,104.08 163.52,105.19 163.52,106.53 169.46,112.47 169.46,127.83 170.72,129.09 170.72,130.58 169.05,132.25 169.05,139.84 169.86,140.64 169.86,145.18 168.18,146.86 168.18,150.25 167.88,150.55 166.66,150.55 166.42,150.79 166.42,151.13 166.66,151.36 167.88,151.36 168.18,151.66 168.18,152.43 167.88,152.73 166.22,152.73 166.12,152.83 166.12,153.34 166.24,153.47 166.95,153.47 167.26,153.78 167.26,154.55 166.9,154.9 164.73,154.9 164.59,155.04 164.59,155.57 164.74,155.71 166.9,155.71 167.23,156.04 167.23,156.7 166.28,157.65 166.28,167.52 165.9,167.91 165.01,167.91 v1(164.24,167.13)
FMC_HPC1_LA04_P: length 148.4
  TOP w0.104: v2(141.24,53.84) U1.BF12 ; J2.H10 v1(165.51,167.13)
  18_SIG6 w0.089: v2(141.24,53.84) 141.03,53.64 141.03,53.46 141.12,53.36 141.83,53.36 143.97,55.5 143.97,67.44 147.57,71.05 147.57,88.64 152.12,93.18 152.12,96.74 153.54,98.16 159.81,98.16 160.36,98.71 160.36,103.43 161.29,104.36 162.29,104.36 163.24,105.31 163.24,106.65 169.18,112.59 169.18,127.94 170.44,129.21 170.44,130.46 168.77,132.13 168.77,139.95 169.58,140.76 169.58,145.06 167.9,146.74 167.9,150.14 167.76,150.27 166.54,150.27 166.14,150.67 166.14,151.24 166.54,151.64 167.76,151.64 167.9,151.77 167.9,152.31 167.76,152.45 166.11,152.45 165.84,152.72 165.84,153.46 166.13,153.75 166.83,153.75 166.98,153.89 166.98,154.43 166.79,154.62 164.61,154.62 164.31,154.92 164.31,155.68 164.62,155.99 166.79,155.99 166.95,156.15 166.95,156.58 166,157.53 166,167.41 165.78,167.63 165.13,167.63 164.85,167.35 164.85,166.86 164.98,166.72 165.39,166.72 165.51,166.84 v1(165.51,167.13)
FMC_HPC1_LA05_N: length 151.2
  TOP w0.104: U1.BF14 v2(141.24,55.84) ; J2.D12 v1(162.97,162.05)
  16_SIG5 w0.076: 142.34,55.49 142.32,55.49 142.28,55.45 141.04,55.45 140.84,55.66 140.84,55.77 140.91,55.84 v2(141.24,55.84)
  16_SIG5 w0.089: 142.34,55.49 143.01,55.49 144.71,57.19 144.71,68.31 147.24,70.85 147.24,93.21 145.83,94.63 145.83,96.83 147.69,98.69 147.69,99.41 148.84,100.56 148.84,101.44 149.86,102.45 149.86,103.15 150.86,104.15 150.86,105.36 151.26,105.76 151.26,108.69 153.78,111.21 153.78,111.75 153.64,111.88 153.18,111.88 152.88,112.18 152.88,112.95 153.18,113.25 153.64,113.25 153.78,113.38 153.78,116.08 154.08,116.38 154.91,116.38 155.21,116.08 155.21,115.63 155.34,115.5 155.88,115.5 156.01,115.63 156.01,116.08 156.31,116.38 156.83,116.38 156.97,116.52 156.97,117.04 156.82,117.19 154.08,117.19 153.78,117.49 153.78,118.26 154.08,118.56 154.63,118.56 154.76,118.69 154.76,119.23 154.63,119.36 154.08,119.36 153.78,119.66 153.78,120.44 155.51,122.17 156.45,122.17 156.98,122.7 157.8,122.7 158.08,122.98 158.08,125.1 158.42,125.44 159.41,125.44 159.78,125.07 159.78,123.71 160.02,123.48 160.8,123.48 161.21,123.88 161.21,128.03 160.51,128.72 156.49,128.72 156.13,129.08 156.13,129.75 156.47,130.09 160.95,130.09 161.09,130.22 161.09,130.54 160.86,130.76 158.7,130.76 158.45,131.02 158.45,131.6 158.73,131.89 160.21,131.89 160.5,132.18 160.5,134.76 161.55,135.82 161.55,151.37 163.46,153.28 163.46,161.67 163.64,161.85 163.64,162.26 163.49,162.41 163.32,162.41 v1(162.97,162.05)
FMC_HPC1_LA05_P: length 151
  TOP w0.104: J2.D11 v1(164.24,162.05) ; U1.BE14 v2(140.24,55.84)
  16_SIG5 w0.076: 142.34,55.21 142.32,55.21 142.28,55.25 140.96,55.25 140.64,55.58 140.64,55.77 140.56,55.84 v2(140.24,55.84)
  16_SIG5 w0.089: v1(164.24,162.05) 163.74,161.56 163.74,153.16 161.83,151.25 161.83,135.7 160.78,134.65 160.78,132.06 160.33,131.61 158.85,131.61 158.72,131.49 158.72,131.14 158.82,131.04 160.98,131.04 161.37,130.66 161.37,130.11 161.07,129.81 156.59,129.81 156.41,129.64 156.41,129.19 156.6,129 160.63,129 161.49,128.15 161.49,123.77 160.92,123.2 159.9,123.2 159.5,123.6 159.5,124.96 159.3,125.16 158.53,125.16 158.35,124.98 158.35,122.86 157.91,122.42 157.09,122.42 156.56,121.89 155.62,121.89 154.06,120.33 154.06,119.78 154.19,119.64 154.74,119.64 155.04,119.35 155.04,118.58 154.74,118.28 154.19,118.28 154.06,118.14 154.06,117.6 154.19,117.47 156.94,117.47 157.25,117.16 157.25,116.4 156.95,116.1 156.43,116.1 156.29,115.97 156.29,115.52 156,115.22 155.23,115.22 154.93,115.52 154.93,115.97 154.79,116.1 154.19,116.1 154.06,115.97 154.06,113.27 153.76,112.97 153.3,112.97 153.16,112.84 153.16,112.3 153.3,112.16 153.76,112.16 154.06,111.86 154.06,111.1 151.54,108.58 151.54,105.64 151.13,105.24 151.13,104.03 150.14,103.04 150.14,102.34 149.12,101.32 149.12,100.45 147.97,99.29 147.97,98.57 146.11,96.71 146.11,94.74 147.52,93.33 147.52,70.73 144.99,68.19 144.99,57.07 143.13,55.21 142.34,55.21
FMC_HPC1_LA06_N: length 150.2
  TOP w0.104: J2.C11 v1(164.24,160.78) ; U1.BE13 v2(140.24,54.84)
  16_SIG5 w0.076: v2(140.24,54.84) 139.91,54.84 139.84,54.77 139.84,54.66 140.05,54.44 141.92,54.44 141.96,54.48 141.98,54.48
  16_SIG5 w0.089: 141.98,54.48 143.44,54.48 145.65,56.69 145.65,67.92 148.18,70.46 148.18,92.51 150.21,94.54 150.21,96.72 148.79,98.14 148.79,99.21 149.82,100.23 151.11,100.23 151.48,100.61 151.48,101.64 152.26,102.41 152.26,107.1 155.39,110.23 155.8,110.23 158.57,113 159.49,113 161.73,115.24 161.73,116.58 161.32,116.99 159.86,116.99 159.56,117.29 159.56,118.04 159.84,118.33 160.8,118.33 160.97,118.49 160.97,122 162.14,123.17 162.14,132.74 163.37,133.97 163.37,139.55 164.8,140.98 164.8,142 166.29,143.5 166.29,144.27 166.03,144.54 163.66,144.54 163.37,144.84 163.37,145.61 163.66,145.9 165.75,145.9 165.89,146.04 165.89,146.58 165.75,146.71 163.66,146.71 163.37,147.01 163.37,147.78 163.66,148.08 165.75,148.08 165.89,148.21 165.89,148.75 165.75,148.89 163.19,148.89 162.81,149.26 162.81,150.9 164.29,152.38 166.72,152.38 166.86,152.51 166.86,153.05 166.72,153.19 164.69,153.19 164.39,153.48 164.39,154.25 164.69,154.55 166.72,154.55 166.86,154.69 166.86,155.31 166.55,155.62 165.03,155.62 164.73,155.92 164.73,160.4 164.9,160.57 164.9,161 164.8,161.09 164.55,161.09 v1(164.24,160.78)
FMC_HPC1_LA06_P: length 150
  TOP w0.104: U1.BD13 v2(139.24,54.84) ; J2.C10 v1(165.51,160.78)
  16_SIG5 w0.076: v2(139.24,54.84) 139.56,54.84 139.64,54.77 139.64,54.58 139.97,54.24 141.92,54.24 141.96,54.2 141.98,54.2
  16_SIG5 w0.089: 141.98,54.2 143.56,54.2 145.93,56.57 145.93,67.81 148.46,70.34 148.46,92.39 150.49,94.42 150.49,96.83 149.07,98.25 149.07,99.09 149.93,99.96 151.22,99.96 151.76,100.49 151.76,101.52 152.54,102.3 152.54,106.98 155.51,109.95 155.91,109.95 158.68,112.72 159.61,112.72 162.01,115.12 162.01,116.7 161.44,117.27 159.97,117.27 159.84,117.4 159.84,117.93 159.96,118.05 160.92,118.05 161.25,118.37 161.25,121.88 162.42,123.06 162.42,132.63 163.65,133.85 163.65,139.44 165.07,140.87 165.07,141.88 166.57,143.38 166.57,144.39 166.14,144.82 163.78,144.82 163.65,144.95 163.65,145.49 163.78,145.63 165.87,145.63 166.17,145.92 166.17,146.69 165.87,146.99 163.78,146.99 163.65,147.13 163.65,147.66 163.78,147.8 165.87,147.8 166.17,148.1 166.17,148.87 165.87,149.17 163.3,149.17 163.09,149.38 163.09,150.78 164.41,152.1 166.84,152.1 167.14,152.4 167.14,153.17 166.84,153.47 164.8,153.47 164.67,153.6 164.67,154.14 164.8,154.27 166.84,154.27 167.14,154.57 167.14,155.43 166.67,155.9 165.15,155.9 165.01,156.04 165.01,160.29 v1(165.51,160.78)
FMC_HPC1_LA07_N: length 152.8
  TOP w0.104: U1.BD15 v2(139.24,56.84) ; J2.H14 v1(160.43,167.13)
  16_SIG5 w0.076: v2(139.24,56.84) 138.91,56.84 138.84,56.92 138.84,61.01 139.07,61.24 140.49,61.24 140.84,61.59 140.84,70.01 141.07,70.24 141.54,70.24 141.58,70.2 141.6,70.2
  16_SIG5 w0.089: v1(160.43,167.13) 160.67,167.38 160.67,167.51 160.56,167.63 160.07,167.63 159.93,167.49 159.93,165.61 160.18,165.37 160.22,165.37 160.86,165.37 161.2,165.02 161.2,161.68 160.79,161.28 158.95,161.28 158.66,160.99 158.66,160.97 158.66,157.12 156.35,154.81 151.82,154.81 150.45,153.44 150.45,151.35 151.51,150.29 153.78,148.03 153.78,147.67 153.17,147.06 152.81,147.06 151.43,148.44 151.24,148.44 150.86,148.06 150.86,147.87 152.54,146.19 152.54,145.77 151.99,145.22 151.57,145.22 149.89,146.91 149.7,146.91 149.32,146.53 149.32,146.34 150.17,145.48 150.17,145.06 149.63,144.51 149.21,144.51 148.35,145.37 147.83,145.37 146.76,144.3 146.76,143.17 146.9,143.04 147.4,143.04 147.7,142.74 147.7,141.97 147.4,141.67 146.9,141.67 146.76,141.54 146.76,141 146.9,140.86 147.4,140.86 147.7,140.56 147.7,139.79 147.4,139.5 146.9,139.5 146.76,139.36 146.76,138.82 146.9,138.69 147.22,138.69 147.5,138.41 147.5,137.64 147.18,137.32 146.9,137.32 146.76,137.19 146.76,136.45 147.8,135.4 147.8,134.07 147.51,133.77 146.92,133.77 146.79,133.64 146.79,132.96 147.8,131.94 147.8,119.96 148.59,119.17 148.59,116.89 148.31,116.61 148.31,108.87 147.17,107.73 147.17,106.92 145.79,105.54 145.31,105.54 141.36,101.59 141.36,100.33 142.08,99.61 142.08,93.83 144.23,91.68 144.23,91.63 144.3,91.56 144.3,71.74 142.77,70.2 141.6,70.2
FMC_HPC1_LA07_P: length 154.3
  TOP w0.104: U1.BC15 v2(138.24,56.84) ; J2.H13 v1(161.7,167.13)
  16_SIG5 w0.076: v2(138.24,56.84) 138.56,56.84 138.64,56.92 138.64,61.09 138.99,61.44 140.4,61.44 140.64,61.68 140.64,70.09 140.99,70.44 141.54,70.44 141.58,70.48 141.6,70.48
  16_SIG5 w0.089: 141.6,70.48 142.65,70.48 144.02,71.85 144.02,91.44 143.95,91.51 143.95,91.56 141.8,93.71 141.8,99.5 141.08,100.22 141.08,101.71 145.2,105.82 145.68,105.82 146.89,107.04 146.89,107.85 148.03,108.99 148.03,116.72 148.31,117.01 148.31,119.05 147.53,119.84 147.53,131.83 146.51,132.84 146.51,133.75 146.81,134.05 147.39,134.05 147.53,134.19 147.53,135.29 146.48,136.33 146.48,137.3 146.78,137.6 147.06,137.6 147.22,137.76 147.22,138.3 147.1,138.41 146.78,138.41 146.48,138.71 146.48,139.48 146.78,139.78 147.29,139.78 147.42,139.91 147.42,140.45 147.29,140.58 146.78,140.58 146.48,140.88 146.48,141.65 146.78,141.95 147.29,141.95 147.42,142.08 147.42,142.62 147.29,142.76 146.78,142.76 146.48,143.06 146.48,144.42 147.71,145.65 148.47,145.65 149.32,144.79 149.51,144.79 149.9,145.17 149.9,145.36 149.04,146.22 149.04,146.64 149.58,147.19 150.01,147.19 151.69,145.5 151.88,145.5 152.26,145.88 152.26,146.07 150.58,147.76 150.58,148.18 151.12,148.72 151.54,148.72 152.93,147.34 153.05,147.34 153.5,147.78 153.5,147.91 151.31,150.1 150.17,151.24 150.17,153.56 151.71,155.09 156.24,155.09 158.38,157.24 158.38,161.1 158.84,161.56 160.68,161.56 160.92,161.8 160.92,164.91 160.74,165.09 160.34,165.09 160.11,165.09 160.1,165.09 160.06,165.09 159.81,165.34 159.65,165.5 159.65,167.61 159.95,167.91 160.68,167.91 160.95,167.63 160.95,167.28 161.33,166.9 161.47,166.9 v1(161.7,167.13)
FMC_HPC1_LA08_N: length 150.9
  TOP w0.104: U1.BF15 v2(141.24,56.84) ; J2.G13 v1(161.7,165.86)
  16_SIG5 w0.076: 141.94,56.49 141.93,56.49 141.88,56.45 140.87,56.45 140.79,56.53 140.79,56.76 140.87,56.84 v2(141.24,56.84)
  16_SIG5 w0.089: v1(161.7,165.86) 161.84,166 162.09,166 162.19,165.9 162.19,153.99 158.57,150.36 158.57,143.32 158.43,143.18 157.27,143.18 156.97,142.88 156.97,142.11 157.27,141.82 158.43,141.82 158.57,141.68 158.57,141.14 158.43,141.01 156.53,141.01 156.24,140.71 156.24,139.94 156.53,139.64 158.43,139.64 158.57,139.51 158.57,138.97 158.43,138.83 156.53,138.83 156.24,138.54 156.24,137.77 156.53,137.47 158.3,137.47 158.95,136.81 158.95,134.8 158.57,134.42 158.38,134.42 156.81,135.99 156.32,135.99 155.81,135.48 155.81,135.06 157.41,133.45 157.41,133.26 157.03,132.88 156.84,132.88 155.21,134.51 154.68,134.51 154.04,133.87 154.04,133.37 155.21,132.2 155.21,132.01 154.83,131.63 154.64,131.63 154.04,132.23 153.62,132.23 153.12,131.73 153.12,127.04 150.6,124.52 150.6,122.23 151.41,121.42 151.41,119.58 151.28,119.45 150.59,119.45 150.29,119.15 150.29,118.38 150.59,118.08 151.28,118.08 151.41,117.95 151.41,115.22 151.28,115.09 150.36,115.09 150.06,114.79 150.06,114.02 150.36,113.72 151.46,113.72 151.87,113.32 151.87,110.68 150.13,108.94 150.13,107.94 149.47,107.28 149.47,105.72 148.73,104.98 148.73,103.76 147.42,102.46 147.42,101.28 144.68,98.54 144.68,94.22 146.28,92.62 146.28,71.24 143.75,68.71 143.75,57.8 142.44,56.49 141.94,56.49
FMC_HPC1_LA08_P: length 151.2
  TOP w0.104: U1.BE15 v2(140.24,56.84) ; J2.G12 v1(162.97,165.86)
  16_SIG5 w0.076: v2(140.24,56.84) 140.51,56.84 140.59,56.77 140.59,56.45 140.79,56.25 141.88,56.25 141.93,56.21 141.94,56.21
  16_SIG5 w0.089: 141.94,56.21 142.56,56.21 144.03,57.68 144.03,68.59 146.56,71.13 146.56,92.73 144.96,94.34 144.96,98.42 147.7,101.16 147.7,102.34 149.01,103.64 149.01,104.86 149.75,105.61 149.75,107.17 150.41,107.83 150.41,108.83 152.15,110.56 152.15,113.43 151.58,114 150.48,114 150.34,114.13 150.34,114.67 150.48,114.81 151.39,114.81 151.69,115.1 151.69,118.06 151.39,118.36 150.7,118.36 150.57,118.5 150.57,119.04 150.7,119.17 151.39,119.17 151.69,119.47 151.69,121.54 150.88,122.35 150.88,124.41 153.4,126.93 153.4,131.61 153.73,131.95 153.93,131.95 154.52,131.35 154.95,131.35 155.49,131.89 155.49,132.32 154.32,133.48 154.32,133.76 154.8,134.23 155.09,134.23 156.73,132.6 157.15,132.6 157.69,133.15 157.69,133.57 156.09,135.18 156.09,135.37 156.43,135.71 156.69,135.71 158.26,134.14 158.69,134.14 159.23,134.68 159.23,136.93 158.41,137.75 156.65,137.75 156.51,137.88 156.51,138.42 156.65,138.56 158.55,138.56 158.85,138.85 158.85,139.62 158.55,139.92 156.65,139.92 156.51,140.06 156.51,140.59 156.65,140.73 158.55,140.73 158.85,141.03 158.85,141.8 158.55,142.1 157.39,142.1 157.25,142.23 157.25,142.77 157.39,142.9 158.55,142.9 158.85,143.2 158.85,150.24 162.47,153.87 162.47,165.37 v1(162.97,165.86)
FMC_HPC1_LA09_N: length 152.9
  TOP w0.104: U1.BB14 136.74,56.34 v2(137.24,55.84) ; J2.D15 v1(159.16,162.05)
  16_SIG5 w0.076: v2(137.24,55.84) 136.91,55.84 136.84,55.92 136.84,56.2 136.91,56.27 137.5,56.27 137.84,56.61 137.84,62.01 138.07,62.24 139.53,62.24 139.84,62.55 139.84,71.01 140.07,71.24 141.52,71.24 141.56,71.2 141.58,71.2
  16_SIG5 w0.089: v1(159.16,162.05) 159.45,162.35 159.45,162.45 159.36,162.55 157.6,162.55 157.39,162.34 157.39,157.29 156.08,155.98 151.12,155.98 148.97,153.83 148.97,150.79 149.8,149.96 149.8,149.54 149.26,148.99 148.83,148.99 148.01,149.82 147.82,149.82 147.43,149.44 147.43,149.25 147.96,148.73 147.96,148.3 147.41,147.76 146.99,147.76 146.47,148.28 146.28,148.28 145.59,147.6 145.59,145.89 146.07,145.41 146.07,144.99 145.53,144.44 145.11,144.44 144.62,144.93 144.43,144.93 144.05,144.55 144.05,144.36 144.54,143.87 144.54,143.45 143.85,142.77 143.85,142.14 143.99,142.01 145.53,142.01 145.82,141.71 145.82,140.94 145.53,140.64 143.99,140.64 143.85,140.51 143.85,138.25 145.46,136.64 145.46,134.98 144.95,134.48 144.95,132.85 145.29,132.5 145.29,131.43 146.87,129.85 146.87,128.32 146.57,128.02 145.98,128.02 145.85,127.88 145.85,127.35 145.98,127.21 146.57,127.21 146.87,126.91 146.87,126.14 146.57,125.85 145.98,125.85 145.85,125.71 145.85,125.17 145.98,125.04 146.57,125.04 146.87,124.74 146.87,123.97 146.57,123.67 145.34,123.67 144.9,124.12 142.95,124.12 142.38,123.55 142.38,115.69 143.49,114.58 143.49,112.31 143.62,112.17 144.32,112.17 144.6,111.89 144.6,111.09 144.32,110.8 143.62,110.8 143.49,110.67 143.49,110.13 143.62,110 145.02,110 145.28,109.73 145.28,108.96 144.95,108.63 143.62,108.63 143.49,108.5 143.49,107.11 142.38,106 142.38,105.15 139.79,102.57 139.79,100.87 139.26,100.33 139.26,95.41 143.35,91.31 143.35,72.68 141.87,71.2 141.58,71.2
FMC_HPC1_LA09_P: length 154.1
  TOP w0.104: U1.BA14 135.74,56.34 v2(136.24,55.84) ; J2.D14 v1(160.43,162.05)
  16_SIG5 w0.076: 141.58,71.48 141.56,71.48 141.52,71.44 139.99,71.44 139.64,71.09 139.64,62.64 139.44,62.44 137.99,62.44 137.64,62.09 137.64,56.69 137.42,56.47 136.83,56.47 136.64,56.28 136.64,55.92 136.56,55.84 v2(136.24,55.84)
  16_SIG5 w0.089: v1(160.43,162.05) 159.96,162.05 159.73,162.28 159.73,162.57 159.47,162.83 157.49,162.83 157.11,162.45 157.11,157.41 155.97,156.26 151,156.26 148.69,153.95 148.69,150.67 149.52,149.84 149.52,149.65 149.14,149.27 148.95,149.27 148.12,150.1 147.7,150.1 147.16,149.56 147.16,149.14 147.68,148.61 147.68,148.42 147.3,148.04 147.11,148.04 146.58,148.56 146.16,148.56 145.31,147.72 145.31,145.77 145.79,145.29 145.79,145.1 145.41,144.72 145.22,144.72 144.74,145.21 144.32,145.21 143.77,144.66 143.77,144.24 144.26,143.76 144.26,143.57 143.57,142.88 143.57,142.03 143.87,141.73 145.41,141.73 145.54,141.6 145.54,141.06 145.41,140.92 143.87,140.92 143.57,140.62 143.57,138.13 145.18,136.53 145.18,135.1 144.67,134.59 144.67,132.73 145.02,132.39 145.02,131.31 146.59,129.74 146.59,128.43 146.46,128.3 145.87,128.3 145.57,128 145.57,127.23 145.87,126.93 146.46,126.93 146.59,126.8 146.59,126.26 146.46,126.12 145.87,126.12 145.57,125.83 145.57,125.06 145.87,124.76 146.46,124.76 146.59,124.62 146.59,124.09 146.46,123.95 145.46,123.95 145.01,124.4 142.84,124.4 142.1,123.66 142.1,115.58 143.21,114.47 143.21,112.19 143.51,111.89 144.2,111.89 144.32,111.77 144.32,111.2 144.2,111.08 143.51,111.08 143.21,110.79 143.21,110.02 143.51,109.72 144.9,109.72 145,109.62 145,109.08 144.83,108.91 143.51,108.91 143.21,108.61 143.21,107.23 142.1,106.12 142.1,105.26 139.51,102.68 139.51,100.98 138.98,100.45 138.98,95.29 143.07,91.2 143.07,72.8 141.76,71.48 141.58,71.48
FMC_HPC1_LA10_N: length 150.7
  TOP w0.104: J2.C15 v1(159.16,160.78) ; U1.BB12 v2(137.24,53.84)
  16_SIG5 w0.076: 142.55,58.99 142.55,58.97 142.59,58.93 142.59,58.28 141.75,57.44 139.99,57.44 139.64,57.09 139.64,55.68 139.4,55.44 136.87,55.44 136.65,55.22 136.65,54.56 136.97,54.24 137.16,54.24 137.24,54.17 v2(137.24,53.84)
  16_SIG5 w0.089: v1(159.16,160.78) 159.65,160.29 159.65,154.54 158.74,153.63 158.74,152.53 158.6,152.4 158.06,152.4 157.93,152.53 157.93,153.63 157.63,153.92 156.86,153.92 156.56,153.63 156.56,152.53 156.43,152.4 155.89,152.4 155.76,152.53 155.76,153.63 155.46,153.92 154.69,153.92 154.39,153.63 154.39,152.53 154.25,152.4 153.72,152.4 153.58,152.53 153.58,153.63 153.28,153.92 152.35,153.92 151.63,153.2 151.63,151.63 152.86,150.4 155.08,148.18 155.08,147.35 154.6,146.88 154.6,146.27 155.46,145.41 155.46,145.22 155.08,144.84 154.89,144.84 153.94,145.79 153.52,145.79 152.98,145.25 152.98,144.83 153.93,143.88 153.93,143.69 152.39,142.15 152.39,141.23 152.26,141.1 150.6,141.1 150.32,140.83 150.32,139.71 150.64,139.39 152.25,139.39 152.39,139.25 152.39,137.89 151.77,137.28 151.77,134.42 150.97,133.62 150.54,133.62 150.24,133.32 150.24,132.55 150.54,132.25 151.64,132.25 151.77,132.11 151.77,131.22 151.64,131.09 150.85,131.09 150.55,130.79 150.55,130.02 150.85,129.72 151.64,129.72 151.77,129.59 151.77,127.89 151.42,127.53 151.23,127.53 150.71,128.05 150.29,128.05 149.74,127.51 149.74,127.09 150.26,126.57 150.26,126.38 149.33,125.44 149.33,116.44 148.98,116.1 148.98,108.38 147.9,107.3 147.9,106.04 146.76,104.9 145.55,104.9 144.97,104.32 144.97,102.79 144.36,102.17 144.36,100.12 143.74,99.5 143.74,93.04 145.09,91.69 145.09,71.62 142.55,69.07 142.55,58.99
FMC_HPC1_LA10_P: length 151.5
  TOP w0.104: v2(137.24,54.84) 136.74,55.34 U1.BB13 ; J2.C14 v1(160.43,160.78)
  16_SIG5 w0.076: v2(137.24,54.84) 137.24,54.52 137.16,54.44 137.05,54.44 136.85,54.64 136.85,55.14 136.96,55.24 139.49,55.24 139.84,55.59 139.84,57.01 140.07,57.24 141.83,57.24 142.79,58.2 142.79,58.93 142.83,58.97 142.83,58.99
  16_SIG5 w0.089: 142.83,58.99 142.83,68.96 145.37,71.5 145.37,91.81 144.02,93.16 144.02,99.39 144.64,100 144.64,102.06 145.25,102.67 145.25,104.2 145.67,104.62 146.87,104.62 148.18,105.93 148.18,107.18 149.26,108.26 149.26,115.98 149.6,116.33 149.6,125.32 150.54,126.26 150.54,126.68 150.02,127.2 150.02,127.39 150.4,127.77 150.6,127.77 151.11,127.25 151.54,127.25 152.05,127.77 152.05,129.7 151.75,130 150.97,130 150.83,130.14 150.83,130.67 150.97,130.81 151.75,130.81 152.05,131.11 152.05,132.23 151.75,132.53 150.65,132.53 150.52,132.66 150.52,133.2 150.65,133.34 151.08,133.34 152.05,134.3 152.05,137.16 152.67,137.78 152.67,139.37 152.36,139.67 150.76,139.67 150.6,139.83 150.6,140.71 150.71,140.82 152.37,140.82 152.67,141.12 152.67,142.03 154.21,143.57 154.21,143.99 153.26,144.94 153.26,145.13 153.64,145.51 153.83,145.51 154.78,144.56 155.2,144.56 155.74,145.11 155.74,145.53 154.88,146.39 154.88,146.76 155.36,147.24 155.36,148.29 151.91,151.75 151.91,153.09 152.47,153.64 153.17,153.64 153.3,153.51 153.3,152.42 153.6,152.12 154.37,152.12 154.67,152.42 154.67,153.51 154.8,153.64 155.34,153.64 155.48,153.51 155.48,152.42 155.77,152.12 156.54,152.12 156.84,152.42 156.84,153.51 156.98,153.64 157.52,153.64 157.65,153.51 157.65,152.42 157.95,152.12 158.72,152.12 159.02,152.42 159.02,153.51 159.93,154.42 159.93,155.57 160.07,155.7 160.19,155.7 160.33,155.85 160.33,156.11 160.2,156.24 160.07,156.24 159.93,156.38 159.93,156.65 160.07,156.78 160.15,156.78 160.29,156.91 160.29,157.18 160.15,157.32 160.07,157.32 159.93,157.45 159.93,160.68 160.04,160.78 v1(160.43,160.78)
FMC_HPC1_LA11_N: length 154.5
  TOP w0.104: J2.H17 v1(156.62,167.13) ; U1.BA15 135.74,57.34 v2(136.24,56.84)
  16_SIG5 w0.076: 142.35,73.31 142.35,73.29 142.31,73.25 142.31,72.82 141.73,72.24 139.11,72.24 138.84,71.97 138.84,63.59 138.49,63.24 137.11,63.24 136.84,62.97 136.84,57.61 136.47,57.24 136.31,57.24 136.24,57.17 v2(136.24,56.84)
  16_SIG5 w0.089: 142.35,73.31 142.35,91.08 138.24,95.18 138.24,103.3 140.13,105.18 140.13,109.75 142.01,111.63 142.01,113.67 141.42,114.26 141.42,123.91 143.06,125.54 143.06,127.98 142.08,128.96 142.08,131.98 142.21,132.12 143.05,132.12 143.34,132.42 143.34,133.19 143.05,133.48 142.21,133.48 142.08,133.62 142.08,134.16 142.21,134.29 143.46,134.29 143.76,134.59 143.76,135.36 143.46,135.66 142.21,135.66 142.08,135.79 142.08,137.47 141.83,137.73 141.29,137.73 141.2,137.82 141.2,138.08 141.29,138.17 141.83,138.17 142.08,138.42 142.08,138.92 141.83,139.18 141.29,139.18 141.2,139.26 141.2,139.53 141.29,139.62 141.83,139.62 142.08,139.87 142.08,140.37 141.83,140.62 141.29,140.62 141.2,140.71 141.2,140.98 141.29,141.07 141.83,141.07 142.08,141.32 142.08,144.97 142.21,145.1 143.21,145.1 143.51,145.4 143.51,146.17 143.21,146.47 142.3,146.47 142.19,146.58 142.19,147.12 142.35,147.28 144.23,147.28 144.53,147.58 144.53,148.32 144.2,148.64 142.21,148.64 142.08,148.78 142.08,149.6 143.57,151.09 143.76,151.09 144.68,150.17 145.1,150.17 145.65,150.72 145.65,151.14 144.73,152.06 144.73,152.25 145.11,152.63 145.3,152.63 146.33,151.6 146.76,151.6 147.35,152.19 147.35,155.53 148.9,157.09 155.29,157.09 156.13,157.93 156.13,167.38 156.39,167.64 157.28,167.64 157.34,167.58 157.34,167.28 157.19,167.13 v1(156.62,167.13)
FMC_HPC1_LA11_P: length 154.7
  TOP w0.104: v2(136.24,57.84) 135.74,58.34 U1.BA16 ; J2.H16 v1(157.89,167.13)
  16_SIG5 w0.076: v2(136.24,57.84) 136.24,57.52 136.31,57.44 136.39,57.44 136.64,57.69 136.64,63.05 137.03,63.44 138.4,63.44 138.64,63.68 138.64,72.05 139.03,72.44 141.65,72.44 142.11,72.9 142.11,73.25 142.07,73.29 142.07,73.31
  16_SIG5 w0.089: v1(157.89,167.13) 157.77,167.13 157.62,167.28 157.62,167.69 157.39,167.92 156.28,167.92 155.85,167.49 155.85,158.04 155.17,157.37 148.78,157.37 147.07,155.65 147.07,152.3 146.64,151.88 146.45,151.88 145.42,152.91 144.99,152.91 144.45,152.37 144.45,151.94 145.37,151.02 145.37,150.83 144.99,150.45 144.8,150.45 143.88,151.37 143.46,151.37 141.8,149.72 141.8,148.66 142.1,148.37 144.09,148.37 144.25,148.21 144.25,147.69 144.11,147.56 142.24,147.56 141.91,147.23 141.91,146.46 142.19,146.19 143.1,146.19 143.23,146.06 143.23,145.52 143.1,145.38 142.1,145.38 141.8,145.09 141.8,141.44 141.71,141.35 141.17,141.35 140.92,141.09 140.92,140.6 141.17,140.34 141.71,140.34 141.8,140.25 141.8,139.99 141.71,139.9 141.17,139.9 140.92,139.65 140.92,139.15 141.17,138.9 141.71,138.9 141.8,138.81 141.8,138.54 141.71,138.45 141.17,138.45 140.92,138.2 140.92,137.7 141.17,137.45 141.71,137.45 141.8,137.36 141.8,135.68 142.1,135.38 143.34,135.38 143.48,135.25 143.48,134.71 143.34,134.57 142.1,134.57 141.8,134.27 141.8,133.5 142.1,133.21 142.93,133.21 143.06,133.07 143.06,132.53 142.93,132.4 142.1,132.4 141.8,132.1 141.8,128.84 142.78,127.86 142.78,125.66 141.15,124.03 141.15,114.14 141.74,113.55 141.74,111.75 139.85,109.87 139.85,105.3 137.96,103.41 137.96,95.07 142.07,90.96 142.07,73.31
FMC_HPC1_LA12_N: length 150.4
  TOP w0.104: J2.G16 v1(157.89,165.86) ; U1.BC13 v2(138.24,54.84)
  18_SIG6 w0.076: v2(138.24,54.84) 138.64,55.24 141.74,55.24 141.78,55.2 141.8,55.2
  18_SIG6 w0.089: 141.8,55.2 142.25,55.2 143.36,56.31 143.36,67.77 146.85,71.27 146.85,88.83 151.41,93.39 151.41,98 151.67,98.26 152.57,98.26 153.1,98.79 153.1,99.07 153.63,99.61 157.45,99.61 158.19,100.35 158.19,101.58 158.59,101.98 158.59,103.18 159.97,104.56 159.97,106.02 162.05,108.1 162.05,109.51 163.42,110.88 166.57,110.88 168.44,112.75 168.44,122.25 167.6,123.09 167.6,129.44 165.55,131.48 165.55,135.44 166.56,136.45 166.56,137.76 165.11,139.22 165.11,141.72 165.73,142.34 165.73,144.09 163.64,146.17 163.64,148 163.78,148.14 165.1,148.14 165.4,148.44 165.4,149.2 165.1,149.5 163.78,149.5 163.64,149.64 163.64,150.18 163.78,150.31 165.25,150.31 165.54,150.61 165.54,151.38 165.25,151.68 163.78,151.68 163.64,151.81 163.64,152.35 163.78,152.49 164.88,152.49 165.23,152.83 165.23,153.47 164.85,153.85 162.8,153.85 162.67,153.99 162.67,156.42 162.22,156.87 160.22,156.87 159.93,157.16 159.93,166.29 159.59,166.64 158.66,166.64 v1(157.89,165.86)
FMC_HPC1_LA12_P: length 150.5
  TOP w0.104: U1.BC14 v2(138.24,55.84) ; J2.G15 v1(159.16,165.86)
  18_SIG6 w0.076: v2(138.24,55.84) 138.16,55.77 138.16,55.52 138.24,55.44 141.74,55.44 141.78,55.48 141.8,55.48
  18_SIG6 w0.089: v1(159.16,165.86) 159.16,165.57 159,165.41 158.68,165.41 158.5,165.58 158.5,166.08 158.78,166.36 159.47,166.36 159.65,166.18 159.65,157.05 160.11,156.59 162.1,156.59 162.39,156.3 162.39,153.87 162.69,153.57 164.73,153.57 164.95,153.36 164.95,152.95 164.77,152.77 163.66,152.77 163.36,152.47 163.36,151.7 163.66,151.4 165.13,151.4 165.26,151.26 165.26,150.73 165.13,150.59 163.66,150.59 163.36,150.29 163.36,149.52 163.66,149.22 164.99,149.22 165.13,149.08 165.13,148.56 164.99,148.42 163.66,148.42 163.36,148.12 163.36,146.05 165.45,143.97 165.45,142.45 164.83,141.84 164.83,139.1 166.28,137.65 166.28,136.56 165.27,135.55 165.27,131.36 167.32,129.32 167.32,122.98 168.16,122.14 168.16,112.86 166.45,111.16 163.31,111.16 161.77,109.62 161.77,108.21 159.7,106.14 159.7,104.67 158.31,103.29 158.31,102.1 157.91,101.7 157.91,100.47 157.34,99.89 153.52,99.89 152.82,99.19 152.82,98.91 152.45,98.54 151.56,98.54 151.13,98.12 151.13,93.5 146.57,88.95 146.57,71.39 143.08,67.89 143.08,56.43 142.13,55.48 141.8,55.48
FMC_HPC1_LA13_N: length 145.2
  TOP w0.104: U1.AY7 v2(135.24,48.84) ; J2.D18 v1(155.35,162.05)
  18_SIG6 w0.076: v2(135.24,48.84) 135.24,49.03 135.34,49.14 135.57,49.14 135.84,49.41 135.84,51.01 136.07,51.24 137.56,51.24 137.84,51.52 137.84,56.01 138.07,56.24 141.63,56.24 141.67,56.2 141.7,56.2
  18_SIG6 w0.089: 141.7,56.2 141.9,56.2 142.24,56.55 142.24,60.74 142.04,60.94 142.04,67.8 145.86,71.62 145.86,89.17 150.48,93.79 150.48,97.21 149.3,98.4 149.3,99.3 150.26,100.25 152.76,100.25 153.07,100.57 153.87,100.57 154.41,101.11 154.41,101.74 154.67,102.01 156.01,102.01 158.48,104.48 158.48,105.85 159.2,106.57 159.2,107.32 158.46,108.06 158.46,109.31 158.86,109.7 159.26,109.7 160.69,111.13 160.69,112.26 162.15,113.72 162.15,114.81 163.73,116.39 164.89,116.39 166.64,118.14 166.64,126.48 163.83,129.29 163.83,130.4 162.37,131.86 162.37,132.81 163.62,134.06 163.62,140.98 161.92,142.68 161.92,146.56 161.52,146.96 161.23,146.96 161.06,147.13 161.06,147.78 161.92,148.65 161.92,153.39 157.39,157.92 157.39,162.5 157.06,162.82 156.12,162.82 v1(155.35,162.05)
