# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_C1_DQ35: length 60.9
  TOP w0.152: U1.C18 v2(97.24,59.84)
  05_SIG2 w0.173: v4(75.56,96.23) 75.96,95.83 75.96,93.66 76.19,93.43 76.52,93.43 76.76,93.2 76.76,92.86 76.99,92.63 77.32,92.63 77.56,92.4 77.56,90.98 ; 94.39,58.89 94.93,58.34 97.44,58.34 97.74,58.64 97.74,59.03 97.24,59.53 v2(97.24,59.84)
  05_SIG2 w0.262: 77.56,90.98 77.56,90.24 77.42,90.1 77.07,90.1 76.93,89.96 76.93,89.68 77.07,89.54 77.59,89.54 77.73,89.4 77.73,89.12 77.59,88.98 77.07,88.98 76.93,88.84 76.93,87.17 77.41,86.69 77.76,86.69 77.9,86.83 77.9,86.98 78.04,87.12 78.32,87.12 78.46,86.98 78.46,86.83 78.6,86.69 78.88,86.69 79.02,86.83 79.02,86.98 79.16,87.12 79.44,87.12 79.58,86.98 79.58,86.49 79.87,86.2 81.01,86.2 81.5,86.69 83.26,86.69 83.5,86.45 83.5,67.71 84.74,66.47 84.74,65.35 85,65.09 85.58,65.09 87.22,63.45 89.83,63.45 94.39,58.89
  BOTTOM w0.152: U62.H7 v4(75.56,96.23)
DDR4_C1_DQ36: length 63.7
  TOP w0.152: U1.D20 v2(98.24,61.84)
  05_SIG2 w0.173: v2(98.24,61.84) 98.74,62.34 98.74,65.66 97.74,66.66 97.74,67.05 97.44,67.34 97.03,67.34 96.74,67.64 96.74,68.05 96.44,68.34 96.03,68.34 95.74,68.64 95.74,69.05 95.44,69.34 94.39,69.34 ; 75.1,99.36 74.82,99.09 74.66,99.09 74.36,98.79 74.36,98.43 74.16,98.23 73.79,98.23 73.56,98 73.56,94.47 73.93,94.1 73.93,93.29 74.59,92.63 U62.H2 v4(75.56,92.23)
  05_SIG2 w0.262: 75.1,99.36 75.41,99.68 81.97,99.68 86.18,95.46 86.18,94.64 89.19,91.63 89.19,74.32 94.17,69.34 94.39,69.34
  BOTTOM w0.152: U62.H2 v4(75.56,92.23)
DDR4_C1_DQ37: length 63.3
  TOP w0.152: U1.D19 v2(98.24,60.84)
  05_SIG2 w0.173: 94.39,68.34 95.59,68.34 95.74,68.19 95.74,67.47 95.86,67.34 96.65,67.34 96.8,67.2 96.8,66.27 96.73,66.21 96.4,66.21 96.24,66.05 96.24,65.86 96.38,65.73 97.06,65.73 97.15,65.82 97.15,66.3 97.24,66.39 97.42,66.39 97.51,66.3 97.51,65.82 97.6,65.73 98.21,65.73 98.33,65.61 98.33,65.41 98.2,65.28 97.86,65.28 97.74,65.15 97.74,61.34 v2(98.24,60.84) ; v4(75.56,97.83) 75.16,98.23 75.16,98.8 75.39,99.03 81.61,99.03
  05_SIG2 w0.262: 94.39,68.34 94.25,68.34 91,71.59 90.69,71.59 90.57,71.71 90.57,72.02 90.44,72.14 90.19,72.14 90.07,72.02 90.07,71.71 89.95,71.59 89.72,71.59 89.6,71.71 89.6,72.74 89.47,72.87 89.22,72.87 89.11,72.76 89.11,71.71 88.98,71.59 88.73,71.59 88.55,71.77 88.55,91.36 85.52,94.39 85.52,95.21 81.7,99.03 81.61,99.03
  BOTTOM w0.152: U62.H8 v4(75.56,97.83)
DDR4_C1_DQ38: length 59.7
  TOP w0.152: U1.C20 v2(97.24,61.84)
  05_SIG2 w0.173: v4(74.76,93.83) 74.36,94.23 74.36,95.17 74.45,95.25 75.34,95.25 75.43,95.34 75.43,95.61 75.34,95.7 74.45,95.7 74.36,95.79 74.36,97.2 74.59,97.43 75.79,97.43 75.96,97.59 75.96,98 76.19,98.23 81.55,98.23 81.61,98.17 ; 94.39,67.34 95.44,67.34 95.74,67.05 95.74,65.98 96.74,64.98 96.74,62.34 v2(97.24,61.84)
  05_SIG2 w0.262: 81.61,98.17 84.86,94.92 84.86,94.14 87.91,91.1 87.91,71.09 88.09,70.91 90.77,70.91 94.34,67.34 94.39,67.34
  BOTTOM w0.152: U62.J3 v4(74.76,93.83)
DDR4_C1_DQ39: length 60.3
  TOP w0.152: U1.B20 v2(96.24,61.84)
  05_SIG2 w0.173: 94.39,66.56 94.86,66.56 95.26,66.16 95.26,65.52 95.74,65.04 95.74,62.63 96.24,62.13 v2(96.24,61.84) ; 81.61,97.26 81.44,97.43 76.99,97.43 76.76,97.2 76.76,96.83 76.56,96.63 75.16,96.63 v4(74.76,96.23)
  05_SIG2 w0.262: 81.61,97.26 84.17,94.7 84.17,93.82 84.31,93.68 84.4,93.68 84.54,93.54 84.54,93.14 84.41,93 84.22,93 84.1,92.88 84.1,92.31 84.22,92.19 84.48,92.19 85.03,92.74 85.23,92.74 85.42,92.54 85.42,92.34 84.77,91.7 84.77,91.5 84.97,91.3 85.17,91.3 85.82,91.95 86.02,91.95 86.21,91.75 86.21,91.55 85.4,90.74 85.4,90.55 85.6,90.35 85.8,90.35 86.61,91.16 86.81,91.16 87,90.96 87,90.76 86.3,90.06 86.3,89.88 86.46,89.72 86.64,89.72 86.86,89.94 87.03,89.94 87.26,89.71 87.26,70.44 87.45,70.25 90.51,70.25 94.2,66.56 94.39,66.56
  BOTTOM w0.152: U62.J7 v4(74.76,96.23)
DDR4_C1_DQ40: length 79.4
  TOP w0.152: U1.N23 v2(107.24,64.84)
  03_SIG1 w0.173: v4(81.16,93.83) U62.A3 80.76,92.02 80.56,91.83 72.99,91.83 72.76,91.6 72.76,91.2 72.54,90.98 ; v2(107.24,64.84) 107.24,64.62 107.74,64.12 107.74,63.64 107.44,63.34 106.03,63.34 105.74,63.64 105.74,64.05 105.44,64.34 105.03,64.34 104.74,64.64 104.74,67.05 104.44,67.34 104.03,67.34 103.74,67.64 103.74,68.05 103.44,68.34 103.03,68.34 102.74,68.64 102.74,69.05 102.44,69.34 102.03,69.34 101.74,69.64 101.74,71.05 101.44,71.34 101.03,71.34 100.74,71.64 100.74,72.05 100.44,72.34 100.03,72.34 99.74,72.64 99.74,73.05 99.44,73.34 99.03,73.34 98.74,73.64 98.74,74.05 98.44,74.34 98.03,74.34 97.74,74.64 97.74,75.05 97.44,75.34 97.03,75.34 96.74,75.64 96.74,76.05 96.44,76.34 96.03,76.34 95.74,76.64 95.74,77.05 95.44,77.34 94.39,77.34
  03_SIG1 w0.262: 72.54,90.98 71.77,90.21 71.29,90.21 71.07,90 69.38,90 69.16,89.78 69.16,89.45 69.3,89.31 70.42,89.31 70.56,89.17 70.56,88.84 70.4,88.68 69.28,88.68 69.16,88.56 69.16,88.29 69.4,88.06 70.37,88.06 70.56,87.86 70.56,86.94 70.46,86.84 69.95,86.84 69.86,86.94 69.86,87.26 69.7,87.42 69.33,87.42 69.16,87.25 69.16,86.31 69.75,85.72 82.52,85.72 82.75,85.49 85.65,85.49 93.79,77.34 94.39,77.34
  BOTTOM w0.152: U62.A3 v4(81.16,93.83)
DDR4_C1_DQ41: length 78.9
  TOP w0.152: U1.M23 v2(106.24,64.84)
  03_SIG1 w0.173: v2(106.24,64.84) 106.24,66.11 106.74,66.61 106.74,67.17 106.57,67.34 106.03,67.34 105.74,67.64 105.74,68.14 105.53,68.34 105.03,68.34 104.74,68.64 104.74,69.12 104.51,69.34 104.03,69.34 103.74,69.64 103.74,71.05 103.44,71.34 103.03,71.34 102.74,71.64 102.74,72.11 102.5,72.34 102.03,72.34 101.74,72.64 101.74,73.13 101.52,73.34 101.03,73.34 100.74,73.64 100.74,74.14 100.53,74.34 100.03,74.34 99.74,74.64 99.74,75.1 99.49,75.34 99.03,75.34 98.74,75.64 98.74,76.12 98.52,76.34 98.03,76.34 97.74,76.64 97.74,77.11 97.5,77.34 97.03,77.34 96.74,77.64 96.74,78.13 96.53,78.34 96.03,78.34 95.74,78.64 95.74,79.1 95.5,79.34 94.39,79.34 94.39,79.35 ; 81.61,97.34 81.52,97.43 80.76,97.43 v4(80.36,97.83)
  03_SIG1 w0.262: 94.39,79.35 86.58,87.15 86.58,88.69 86.36,88.91 86.21,88.91 85.95,88.65 85.95,88.31 85.69,88.06 85.13,88.06 84.77,87.69 83.52,87.69 83.16,88.06 81.97,88.06 80.79,89.24 80.01,89.24 79.37,88.6 79.23,88.6 79.04,88.79 79.04,89.16 78.86,89.35 78.59,89.35 78.4,89.16 78.4,88.79 78.21,88.6 77.95,88.6 77.76,88.79 77.76,89.16 77.57,89.35 77.3,89.35 77.12,89.16 77.12,88.79 76.93,88.6 76.66,88.6 76.47,88.79 76.47,89.16 76.29,89.35 76.02,89.35 75.83,89.16 75.83,88.79 75.64,88.6 75.26,88.6 74.97,88.89 74.97,89.77 75.17,89.97 81.96,89.97 82.11,89.81 82.11,89.66 81.78,89.32 81.78,89.14 81.95,88.96 82.23,88.96 82.61,89.35 83.18,89.35 83.49,89.04 83.49,88.65 83.72,88.42 84.35,88.42 84.56,88.62 84.56,88.85 83.62,89.78 83.62,90.04 83.25,90.41 83.25,91.45 83.62,91.82 83.62,96.12 82.54,97.2 81.75,97.2 81.61,97.34
  BOTTOM w0.152: U62.B8 v4(80.36,97.83)
DDR4_C1_DQ42: length 77.2
  TOP w0.152: U1.R21 v2(109.24,62.84)
  03_SIG1 w0.173: v2(109.24,62.84) 109.74,63.34 109.74,63.64 109.74,64.05 110.03,64.34 110.05,64.34 110.47,64.34 110.74,64.61 110.74,65.05 111.19,65.51 111.63,65.51 112.74,66.62 112.74,67.05 112.44,67.34 112.03,67.34 111.74,67.64 111.74,68.05 111.44,68.34 111.03,68.34 110.74,68.64 110.74,69.05 110.44,69.34 110.03,69.34 109.74,69.64 109.74,71.05 109.44,71.34 109.03,71.34 108.74,71.64 108.74,72.05 108.44,72.34 108.03,72.34 107.74,72.64 107.74,73.05 107.44,73.34 107.03,73.34 106.74,73.64 106.74,74.05 106.44,74.34 106.03,74.34 105.74,74.64 105.74,75.05 105.44,75.34 105.03,75.34 104.74,75.64 104.74,76.05 104.44,76.34 104.03,76.34 103.74,76.64 103.74,77.05 103.44,77.34 103.03,77.34 102.74,77.64 102.74,78.05 102.44,78.34 102.03,78.34 101.74,78.64 101.74,79.05 101.44,79.34 101.03,79.34 100.74,79.64 100.74,79.65 100.74,80.05 100.44,80.34 100.03,80.34 99.74,80.64 99.74,80.68 99.74,81.05 99.44,81.34 99.06,81.34 99.03,81.34 98.74,81.64 98.74,81.66 98.74,82.05 98.44,82.34 98.03,82.34 97.74,82.64 97.74,83.05 97.44,83.34 97.03,83.34 96.74,83.64 96.74,84.05 96.44,84.34 96.03,84.34 95.74,84.64 95.74,90.96 ; v4(79.56,93.83) U62.C3 78.58,93.43 78.36,93.65 78.36,94.21 76.76,95.81 76.76,96.39 76.52,96.63 76.18,96.63 75.96,96.86 75.96,98 76.19,98.23 76.51,98.23 76.52,98.23 76.76,98.46 76.76,98.48 76.76,98.48 76.76,99.11 77,99.36 77.18,99.36 77.19,99.36
  03_SIG1 w0.262: 95.74,90.96 95.74,91.32 92.33,94.73 92.33,95.26 88.49,99.1 88.49,100.03 86.73,101.79 78.84,101.79 77.8,100.75 77.8,99.98 77.19,99.36
  BOTTOM w0.152: U62.C3 v4(79.56,93.83)
DDR4_C1_DQ43: length 77.3
  TOP w0.152: U1.P21 v2(108.24,62.84)
  03_SIG1 w0.173: v4(79.56,96.23) 79.26,96.23 79.16,96.33 79.16,98 79.39,98.23 79.43,98.23 79.72,98.23 79.96,98.47 79.96,98.8 80.21,99.05 81.38,99.05 81.59,98.83 81.61,98.83 ; 94.39,81.94 94.98,81.34 95.56,81.34 95.74,81.16 95.74,80.64 96.03,80.34 96.57,80.34 96.74,80.17 96.74,79.64 97.03,79.34 97.5,79.34 97.74,79.1 97.74,78.61 98,78.34 98.55,78.34 98.74,78.15 98.74,77.64 99.03,77.34 99.53,77.34 99.74,77.13 99.74,76.64 100.03,76.34 100.44,76.34 100.74,76.05 100.74,75.64 101.03,75.34 101.44,75.34 101.74,75.05 101.74,74.64 102.03,74.34 102.44,74.34 102.74,74.05 102.74,73.64 103.03,73.34 103.44,73.34 103.74,73.05 103.74,72.64 104.03,72.34 104.44,72.34 104.74,72.05 104.74,71.64 105.03,71.34 105.44,71.34 105.74,71.05 105.74,69.64 106.03,69.34 106.44,69.34 106.74,69.05 106.74,68.64 107.03,68.34 107.44,68.34 107.74,68.05 107.74,67.64 108.03,67.34 108.44,67.34 108.74,67.05 108.74,62.77 108.59,62.62 108.46,62.62 v2(108.24,62.84)
  03_SIG1 w0.262: 94.39,81.94 92.81,83.52 92.16,83.52 92.02,83.66 92.02,83.94 92.16,84.07 92.67,84.07 92.81,84.21 92.81,84.74 92.62,84.93 91.83,84.93 91.64,85.11 91.64,85.38 91.83,85.57 92.62,85.57 92.81,85.76 92.81,86.02 92.62,86.21 90.56,86.21 90.39,86.38 90.39,86.65 90.59,86.85 91,86.85 91.19,87.04 91.19,87.46 91.38,87.64 91.65,87.64 91.83,87.46 91.83,87.04 92.02,86.85 92.62,86.85 92.81,87.04 92.81,87.7 92.18,88.33 91.02,88.33 89.9,87.22 89.63,87.22 89.44,87.4 89.44,87.67 90.37,88.6 90.37,88.86 90.18,89.05 89.91,89.05 88.99,88.13 88.72,88.13 88.54,88.31 88.54,88.58 89.86,89.9 89.86,90.2 89.64,90.41 89.34,90.41 89.12,90.19 88.91,90.19 88.16,90.93 88.16,91.1 88.71,91.65 88.71,91.95 88.54,92.13 88.29,92.13 87.77,91.6 87.42,91.6 84.93,94.09 84.93,96.64 83.65,97.93 83.06,98.51 82.43,98.51 82.11,98.83 81.61,98.83
  BOTTOM w0.152: U62.C7 v4(79.56,96.23)
DDR4_C1_DQ44: length 77.1
  TOP w0.152: U1.R22 v2(109.24,63.84)
  03_SIG1 w0.173: 81.47,100.24 81.08,99.85 79.3,99.85 78.36,98.91 78.36,98.46 78.12,98.23 77.79,98.23 77.56,98 77.56,96.87 77.79,96.63 78.13,96.63 78.36,96.4 78.36,95.6 78.82,95.13 78.94,95.13 79.53,95.72 79.65,95.72 79.9,95.47 79.9,95.34 79.32,94.76 79.32,94.63 79.96,94 79.96,92.63 v4(79.56,92.23) ; 94.39,83.99 95.03,83.34 95.44,83.34 95.74,83.05 95.74,82.64 96.03,82.34 96.44,82.34 96.74,82.05 96.74,81.64 97.03,81.34 97.44,81.34 97.74,81.05 97.74,80.64 98.03,80.34 98.44,80.34 98.74,80.05 98.74,79.64 99.03,79.34 99.44,79.34 99.74,79.05 99.74,78.64 100.03,78.34 100.44,78.34 100.74,78.05 100.74,77.54 100.93,77.34 101.44,77.34 101.74,77.05 101.74,76.54 101.93,76.34 102.44,76.34 102.74,76.05 102.74,75.54 102.93,75.34 103.44,75.34 103.74,75.05 103.74,74.54 103.93,74.34 104.44,74.34 104.74,74.05 104.74,73.54 104.93,73.34 105.44,73.34 105.74,73.05 105.74,72.54 105.93,72.34 106.44,72.34 106.74,72.05 106.74,71.54 106.93,71.34 107.44,71.34 107.74,71.05 107.74,69.64 108.03,69.34 108.44,69.34 108.74,69.05 108.74,68.64 109.03,68.34 109.44,68.34 109.74,68.05 109.74,67.64 110.03,67.34 110.44,67.34 110.74,67.05 110.74,66.12 109.74,65.12 109.74,64.63 109.24,64.13 v2(109.24,63.84)
  03_SIG1 w0.262: 94.39,83.99 94.11,84.27 94.11,87.26 94.51,87.66 94.51,90.2 93.92,90.79 93.72,90.79 93.46,90.53 93.27,90.53 91.45,92.34 91.45,92.72 91.09,93.09 90.71,93.09 90.41,93.38 90.41,93.75 90.97,94.31 90.97,94.51 90.65,94.83 90.45,94.83 89.06,93.43 87.4,93.43 86.22,94.62 86.22,96.34 86.98,97.1 86.98,98.29 86.2,99.07 84.33,99.07 83.57,99.84 83.1,99.84 82.7,100.24 81.47,100.24
  BOTTOM w0.152: U62.C2 v4(79.56,92.23)
DDR4_C1_DQ45: length 78.2
  TOP w0.152: U1.P22 v2(108.24,63.84)
  03_SIG1 w0.173: 94.39,80.34 95.56,80.34 95.74,80.16 95.74,79.53 95.93,79.34 96.53,79.34 96.74,79.14 96.74,78.56 96.95,78.34 97.52,78.34 97.74,78.13 97.74,77.51 97.91,77.34 98.55,77.34 98.74,77.16 98.74,76.56 98.95,76.34 99.53,76.34 99.74,76.14 99.74,75.57 99.96,75.34 100.55,75.34 100.74,75.16 100.74,74.57 100.96,74.34 101.52,74.34 101.74,74.13 101.74,73.55 101.95,73.34 102.58,73.34 102.74,73.18 102.74,72.55 102.95,72.34 103.5,72.34 103.74,72.1 103.74,71.57 103.96,71.34 104.58,71.34 104.74,71.19 104.74,69.54 104.94,69.34 105.53,69.34 105.74,69.14 105.74,68.53 105.92,68.34 106.44,68.34 106.74,68.05 106.74,67.64 107.03,67.34 107.54,67.34 107.74,67.14 107.74,66.69 107.35,66.31 106.87,66.31 106.63,66.07 106.63,65.41 106.75,65.29 106.98,65.29 107.13,65.44 107.13,65.61 107.33,65.81 107.81,65.81 107.93,65.93 107.93,66.26 108.02,66.35 108.26,66.35 108.38,66.23 108.38,65.45 108.26,65.33 107.97,65.33 107.74,65.1 107.74,64.64 108.24,64.14 v2(108.24,63.84) ; 81.61,98.1 81.48,98.1 81.35,98.23 80.19,98.23 79.79,97.83 v4(79.56,97.83)
  03_SIG1 w0.262: 81.61,98.1 81.84,98.1 82.08,97.85 82.81,97.85 83,97.66 84.29,96.37 84.29,91.56 83.9,91.16 83.9,90.78 84.07,90.61 84.28,90.61 84.73,91.07 84.87,91.07 85.18,90.76 85.18,90.55 84.67,90.05 84.67,89.69 85.09,89.27 85.66,89.27 86.02,89.63 86.02,90.17 86.16,90.31 86.16,90.78 84.99,91.96 84.99,92.31 85.22,92.55 85.51,92.55 87.4,90.66 87.4,90.52 86.67,89.79 86.67,89.51 86.9,89.28 87.21,89.28 87.92,90 88.18,90 88.43,89.74 88.43,89.45 87.23,88.24 87.23,87.42 87.45,87.2 87.72,87.2 88.05,87.53 88.32,87.53 88.51,87.34 88.51,87.07 88.17,86.74 88.17,86.48 88.36,86.29 88.63,86.29 88.96,86.62 89.23,86.62 89.42,86.43 89.42,86.16 89.08,85.83 89.08,85.57 89.27,85.38 89.54,85.38 89.87,85.71 90.14,85.71 90.32,85.52 90.32,85.26 89.99,84.92 89.99,84.66 90.18,84.47 90.45,84.47 90.78,84.8 91.04,84.8 91.23,84.61 91.23,84.35 90.9,84.02 90.9,83.75 91.99,82.66 92.26,82.66 92.36,82.75 92.62,82.75 92.81,82.56 92.81,82.3 92.72,82.2 92.72,81.93 92.9,81.75 93.17,81.75 93.27,81.84 93.53,81.84 93.72,81.65 93.72,81.39 93.62,81.29 93.62,81.03 94.31,80.34 94.39,80.34
  BOTTOM w0.152: U62.C8 v4(79.56,97.83)
DDR4_C1_DQ46: length 76
  TOP w0.152: U1.T23 v2(110.24,64.84)
  03_SIG1 w0.173: v4(78.76,93.83) 78.76,94.55 77.56,95.75 77.56,96.4 77.33,96.63 76.99,96.63 76.76,96.86 76.76,97.99 76.85,98.09 76.85,98.09 76.99,98.23 77.26,98.23 77.32,98.23 77.56,98.46 77.56,98.79 77.56,98.8 77.56,98.82 78.1,99.36 ; v2(110.24,64.84) 110.24,65.1 111.74,66.6 111.74,67.05 111.44,67.34 111.03,67.34 110.74,67.64 110.74,68.05 110.44,68.34 110.03,68.34 109.74,68.64 109.74,69.05 109.44,69.34 109.03,69.34 108.74,69.64 108.74,71.05 108.44,71.34 108.03,71.34 107.74,71.64 107.74,72.1 107.49,72.34 107.03,72.34 106.74,72.64 106.74,73.1 106.49,73.34 106.03,73.34 105.74,73.64 105.74,74.1 105.49,74.34 105.03,74.34 104.74,74.64 104.74,75.1 104.49,75.34 104.03,75.34 103.74,75.64 103.74,76.1 103.49,76.34 103.03,76.34 102.74,76.64 102.74,77.1 102.49,77.34 102.03,77.34 101.74,77.64 101.74,78.1 101.49,78.34 101.03,78.34 100.74,78.64 100.74,79.1 100.49,79.34 100.03,79.34 99.74,79.64 99.74,80.1 99.49,80.34 99.03,80.34 98.74,80.64 98.74,81.1 98.49,81.34 98.03,81.34 97.74,81.64 97.74,82.1 97.49,82.34 97.03,82.34 96.74,82.64 96.74,83.05 96.44,83.34 96.03,83.34 95.74,83.64 95.74,84.05 95.44,84.34 95.03,84.34 94.69,84.68 94.69,87.01 95.04,87.36 95.04,90.96
  03_SIG1 w0.262: 95.04,90.96 95.04,91.06 94.3,91.8 94.07,91.8 93.72,91.44 93.36,91.44 93.2,91.61 93.2,91.8 93.65,92.25 93.65,92.49 93.47,92.67 93.23,92.67 92.81,92.26 92.47,92.26 92.28,92.46 92.28,92.58 92.82,93.12 92.82,93.33 92.62,93.52 92.22,93.52 92.01,93.31 91.82,93.31 91.54,93.59 91.54,93.83 91.67,93.97 91.67,95.01 88.04,98.64 87.58,98.64 86.6,99.63 86.6,100.77 86.38,100.99 85.55,100.99 85.35,100.78 85.35,100.04 85.04,99.73 84.59,99.73 84.15,100.17 84.15,100.74 83.92,100.97 78.95,100.97 78.49,100.51 78.49,99.75 78.1,99.36
  BOTTOM w0.152: U62.D3 v4(78.76,93.83)
DDR4_C1_DQ47: length 76.7
  TOP w0.152: U1.R23 v2(109.24,64.84)
  03_SIG1 w0.173: 81.64,99.4 81.33,99.4 81.27,99.46 79.82,99.46 79.71,99.34 79.35,99.34 79.16,99.16 79.16,98.46 78.92,98.23 78.59,98.23 78.36,98 78.36,96.87 arc(78.36,96.87) 78.36,96.86 78.76,96.47 v4(78.76,96.23) ; 94.39,82.86 94.9,82.34 95.52,82.34 95.74,82.12 95.74,81.64 96.03,81.34 96.48,81.34 96.74,81.08 96.74,80.64 97.03,80.34 97.52,80.34 97.74,80.12 97.74,79.6 98,79.34 98.54,79.34 98.74,79.15 98.74,78.64 99.03,78.34 99.44,78.34 99.74,78.05 99.74,77.64 100.03,77.34 100.44,77.34 100.74,77.05 100.74,76.64 101.03,76.34 101.44,76.34 101.74,76.05 101.74,75.64 102.03,75.34 102.44,75.34 102.74,75.05 102.74,74.57 102.97,74.34 103.44,74.34 103.74,74.05 103.74,73.57 103.97,73.34 104.44,73.34 104.74,73.05 104.74,72.57 104.97,72.34 105.44,72.34 105.74,72.05 105.74,71.53 105.92,71.34 106.52,71.34 106.74,71.13 106.74,69.56 106.95,69.34 107.49,69.34 107.74,69.1 107.74,68.53 107.92,68.34 108.53,68.34 108.74,68.14 108.74,67.57 108.96,67.34 109.57,67.34 109.74,67.17 109.74,66.53 109.88,66.38 110.11,66.38 110.23,66.26 110.23,66.05 109.92,65.74 109.63,65.74 109.51,65.86 109.51,66.19 109.37,66.33 109.16,66.33 109.04,66.21 109.04,65.46 109.13,65.36 109.32,65.36 109.42,65.26 109.42,65.03 v2(109.24,64.84)
  03_SIG1 w0.262: 94.39,82.86 93.46,83.79 93.46,87.57 93.96,88.07 93.96,88.31 93.77,88.5 92.97,88.5 92.78,88.68 92.78,88.95 92.97,89.14 93.77,89.14 93.96,89.33 93.96,89.58 93.73,89.81 93.05,89.81 92.73,90.13 92.46,90.13 91.37,89.03 91.1,89.03 90.91,89.22 90.91,89.48 92.01,90.58 92.01,90.85 91.69,91.16 91.42,91.16 90.75,90.49 90.48,90.49 90.29,90.68 90.29,90.94 90.97,91.62 90.97,91.88 90.78,92.07 90.52,92.07 89.84,91.4 89.57,91.4 89.39,91.58 89.39,91.85 90.06,92.53 90.06,92.79 89.8,93.06 89.6,93.06 89.34,92.79 87.14,92.79 85.58,94.35 85.58,96.62 86.27,97.31 86.27,98.02 85.87,98.42 85.5,98.42 85.37,98.3 85.37,97.86 85.16,97.65 84.84,97.65 83.31,99.18 82.85,99.18 82.63,99.4 81.64,99.4
  BOTTOM w0.152: U62.D7 v4(78.76,96.23)
DDR4_C1_DQ48: length 56.1
  TOP w0.152: U1.K24 v2(104.24,66.84)
  07_SIG3 w0.173: v2(104.24,66.84) 103.91,66.84 103.74,67.02 103.74,68.05 103.44,68.34 102.03,68.34 101.74,68.64 101.74,69.05 101.44,69.34 101.03,69.34 101.03,69.34 100.03,69.34 99.74,69.64 99.74,69.97 99.74,69.97 99.74,70.05 99.44,70.34 99.03,70.34 98.74,70.64 98.74,71.05 98.44,71.34 97.03,71.34 96.74,71.64 96.74,72.05 96.44,72.34 96.03,72.34 95.74,72.64 95.74,73.05 95.44,73.34 94.77,73.34 94.39,73.72 ; v4(76.36,78.13) 76.36,78.37 75.96,78.77 75.96,80.02 76.2,80.26 76.2,80.35 76.12,80.43 75.64,80.43 75.52,80.55 75.52,80.82 75.58,80.88 76.45,80.88 76.63,81.06 76.63,81.13 76.49,81.27 75.59,81.27 75.5,81.36 75.5,81.53 75.62,81.65 76.61,81.65 76.76,81.8 76.76,83.1 76.99,83.33 77.35,83.33 77.56,83.53 77.56,84.72 77.42,84.86 77.42,85.14 77.55,85.27 78.03,85.27 78.15,85.15 78.15,84.99 78.23,84.91 78.49,84.91 78.58,85 78.58,85.16 78.67,85.25 78.94,85.25 79.03,85.16 79.03,85 79.11,84.92 79.34,84.92 79.43,85.01 79.43,85.17 79.52,85.26 79.72,85.26 79.8,85.17 79.8,85.01 79.89,84.93 80.1,84.93 80.18,85 80.18,85.16 80.26,85.24 80.52,85.24 80.61,85.15 80.61,85 80.7,84.9 80.89,84.9 81,85.01 81,85.17 81.08,85.25 81.53,85.25 81.61,85.17
  07_SIG3 w0.262: 81.61,85.17 81.66,85.12 81.66,84.55 81.93,84.28 83.34,84.28 83.58,84.52 83.58,84.91 83.81,85.14 84.35,85.14 84.51,84.99 84.51,84.61 83.95,84.05 83.95,83.82 84.18,83.59 84.31,83.59 84.94,84.22 85.86,84.22 85.98,84.35 86.87,84.35 87.44,83.78 87.44,80.66 91.29,76.81 91.3,76.81 94.12,73.99 94.39,73.72
  BOTTOM w0.152: U63.G2 v4(76.36,78.13)
DDR4_C1_DQ49: length 56.4
  TOP w0.152: v2(103.24,66.84) U1.J24
  07_SIG3 w0.173: v4(77.16,82.13) 77.56,82.53 81.5,82.53 81.61,82.64 ; v2(103.24,66.84) 102.74,67.34 102.03,67.34 101.74,67.64 101.74,68.05 101.44,68.34 101.03,68.34 101.03,68.34 100.03,68.34 99.74,68.64 99.74,68.88 99.74,69.05 99.44,69.34 99.03,69.34 98.74,69.64 98.74,70.05 98.44,70.34 97.03,70.34 96.74,70.64 96.74,71.05 96.44,71.34 96.03,71.34 95.74,71.64 95.74,72.05 95.44,72.34 94.82,72.34
  07_SIG3 w0.262: 94.82,72.34 88.05,79.12 87.92,79.12 87.78,78.98 87.78,78.17 87.66,78.04 87.39,78.04 87.22,78.2 87.22,79.76 86.75,80.23 86.75,81.14 86.52,81.37 85.98,81.37 85.75,81.6 85.75,81.93 85.98,82.16 86.52,82.16 86.75,82.39 86.75,83.37 86.58,83.54 86.1,83.54 85.5,82.93 83.67,82.93 83.51,82.76 83.51,82.45 83.66,82.3 84.39,82.3 84.65,82.03 84.65,80.86 85.06,80.44 85.67,80.44 86.67,79.45 86.67,78.38 86.54,78.25 86.27,78.25 86.11,78.42 86.11,78.94 85.97,79.08 84.68,79.08 84.43,79.33 84.43,80.37 84.15,80.64 84.15,81.35 83.82,81.67 82.8,81.67 82.35,82.13 82.35,83.47 82.2,83.62 81.86,83.62 81.7,83.45 81.7,82.73 81.61,82.64
  BOTTOM w0.152: U63.F7 v4(77.16,82.13)
DDR4_C1_DQ50: length 55.1
  TOP w0.152: U1.M21 v2(106.24,62.84)
  07_SIG3 w0.173: v2(106.24,62.84) U1.M21 106.74,67.02 106.43,67.34 106.07,67.34 105.74,67.67 105.74,67.98 105.37,68.34 105.08,68.34 104.74,68.69 104.74,69.05 104.44,69.34 104.03,69.34 103.74,69.64 103.74,70 103.39,70.34 102.1,70.34 101.74,70.7 101.74,71.05 101.44,71.34 100.03,71.34 99.74,71.64 99.74,72.05 99.44,72.34 99.03,72.34 98.74,72.64 98.74,73.05 98.44,73.34 98.03,73.34 97.74,73.64 97.74,74.05 97.44,74.34 96.03,74.34 95.74,74.64 95.74,75.05 95.44,75.34 94.61,75.34 94.39,75.56 ; v4(75.56,79.73) 75.16,80.13 75.16,83.1 75.39,83.33 75.72,83.33 75.96,83.57 75.96,85.02 76.21,85.27
  07_SIG3 w0.262: 94.39,75.56 88.78,81.17 88.78,84.42 86.35,86.86 81.29,86.86 80.81,86.39 77.33,86.39 76.21,85.27
  BOTTOM w0.152: U63.H3 v4(75.56,79.73)
DDR4_C1_DQ51: length 54.5
  TOP w0.152: U1.L21 v2(105.24,62.84)
  07_SIG3 w0.173: 76.86,85.27 76.76,85.16 76.76,83.57 76.52,83.33 76.19,83.33 75.96,83.1 75.96,82.27 75.82,82.13 v4(75.56,82.13) ; 94.39,74.64 94.68,74.34 95.44,74.34 95.74,74.05 95.74,73.64 96.03,73.34 96.56,73.34 96.74,73.17 96.74,72.64 97.03,72.34 98.44,72.34 98.74,72.05 98.74,71.64 99.03,71.34 99.44,71.34 99.44,71.34 99.74,71.05 99.74,71.04 99.74,70.64 100.03,70.34 101.44,70.34 101.74,70.05 101.74,69.64 102.03,69.34 103.44,69.34 103.74,69.05 103.74,68.64 104.03,68.34 104.44,68.34 104.74,68.05 104.74,66.62 105.24,66.12 105.54,66.12 105.85,66.43 106.12,66.43 106.3,66.24 106.3,65.6 106.15,65.44 105.63,65.44 105.56,65.38 105.56,65.15 105.74,64.98 105.74,63.02 105.56,62.84 v2(105.24,62.84)
  07_SIG3 w0.262: 94.39,74.64 88.11,80.92 88.11,84.15 87.24,85.01 86.68,85.01 86.46,85.23 86.46,85.79 86.24,86.02 86.02,86.02 85.89,85.89 85.89,85.71 85.67,85.49 84.94,85.49 84.71,85.72 84.71,86.04 84.58,86.17 83.67,86.17 83.52,86.02 83.52,85.73 83.5,85.73 83.28,85.52 82.44,85.52 82.24,85.72 82.24,86.06 82.11,86.19 81.63,86.19 81.49,86.05 81.49,85.84 81.35,85.7 77.3,85.7 76.86,85.27
  BOTTOM w0.152: U63.H7 v4(75.56,82.13)
DDR4_C1_DQ52: length 56.6
  TOP w0.152: U1.K21 v2(104.24,62.84)
  07_SIG3 w0.173: 75.03,76.89 75.16,77.02 75.16,77.73 v4(75.56,78.13) ; v2(104.24,62.84) 103.74,63.34 103.74,64.05 103.44,64.34 101.03,64.34 100.74,64.64 100.74,65.05 100.2,65.58 95.15,65.58 94.39,66.34
  07_SIG3 w0.262: 75.03,76.89 74.87,76.73 74.66,76.73 74.5,76.57 74.5,75.92 73.91,75.34 73.91,73.86 74.33,73.44 74.97,73.44 75.13,73.6 75.13,76.23 75.29,76.39 75.55,76.39 75.69,76.25 75.69,75.27 75.83,75.13 76.25,75.13 76.39,74.99 76.39,74.71 76.25,74.57 75.83,74.57 75.69,74.43 75.69,73.59 75.91,73.38 76.56,73.38 76.71,73.53 76.71,74.15 76.87,74.31 77.12,74.31 77.27,74.16 77.27,73.51 77.4,73.38 77.68,73.38 77.83,73.53 77.83,74.15 77.99,74.31 78.24,74.31 78.39,74.16 78.39,73.51 78.52,73.38 78.8,73.38 78.95,73.53 78.95,74.15 79.11,74.31 79.35,74.31 79.51,74.16 79.51,73.51 79.63,73.38 79.91,73.38 80.09,73.55 80.09,74.32 81.21,75.45 81.21,75.96 81.41,76.15 81.91,76.15 82.27,75.79 83.22,75.79 84.85,74.16 86.19,74.16 92.91,67.44 92.91,66.52 93.09,66.34 94.39,66.34
  BOTTOM w0.152: U63.H2 v4(75.56,78.13)
DDR4_C1_DQ53: length 57.3
  TOP w0.152: v2(103.24,62.84) U1.J21
  07_SIG3 w0.173: 76.96,71.07 77.06,71.17 ; v4(75.56,83.73) 75.32,83.73 74.92,83.33 74.92,83.33 74.59,83.33 74.36,83.1 74.36,82.77 74.12,82.53 73.79,82.53 73.56,82.3 73.56,81.97 73.59,81.94 73.59,76.92 73.56,76.89 ; 94.39,64.71 94.75,64.34 99.44,64.34 99.74,64.05 99.74,63.64 100.03,63.34 100.44,63.34 100.74,63.05 100.74,62.64 101.03,62.34 102.74,62.34 v2(103.24,62.84)
  07_SIG3 w0.262: 76.96,71.07 73.3,71.07 73.04,71.33 73.04,72.94 72.7,73.28 72.7,76.19 72.99,76.48 73.42,76.48 73.56,76.62 73.56,76.89 ; 94.39,64.71 94.06,65.03 91.74,65.03 91.59,65.17 91.59,66.83 89.64,68.78 89.62,68.78 89.04,69.36 88.86,69.36 88.37,68.87 88.17,68.87 88.04,68.99 88.04,69.26 88.41,69.62 88.41,69.91 86.4,71.91 85.04,71.91 84.37,72.58 84.11,72.58 83.99,72.46 83.99,72.23 83.88,72.12 83.64,72.12 83.51,72.24 83.51,73.65 82.87,74.3 81.61,74.3 81.1,73.79 81.1,73.08 79.32,71.3 77.19,71.3 77.06,71.17
  BOTTOM w0.152: U63.H8 v4(75.56,83.73)
DDR4_C1_DQ54: length 57.1
  TOP w0.152: U1.K22 v2(104.24,63.84)
  07_SIG3 w0.173: 94.39,67.01 95.51,65.89 100.64,65.89 101.19,65.34 103.44,65.34 103.74,65.05 103.74,64.69 104.24,64.19 v2(104.24,63.84) ; v4(74.76,79.73) 74.76,81.07 74.63,81.19 74.5,81.19 74.35,81.04 74.35,78.67 74.49,78.53 75.72,78.53 75.96,78.3 75.96,78.16 75.96,78.16 75.96,77.07 76.14,76.89
  07_SIG3 w0.262: 76.14,76.89 76.23,76.8 76.71,76.8 76.85,76.66 76.85,76.34 76.71,76.21 76.37,76.21 76.23,76.07 76.23,75.79 76.37,75.65 76.71,75.65 76.85,75.51 76.85,74.96 77,74.81 77.28,74.81 77.41,74.94 77.41,76.63 77.58,76.8 77.83,76.8 77.97,76.66 77.97,74.96 78.12,74.81 78.4,74.81 78.53,74.94 78.53,76.64 78.66,76.77 78.94,76.77 79.09,76.62 79.09,74.96 79.24,74.81 79.52,74.81 79.65,74.94 79.65,76.66 79.79,76.8 79.99,76.8 80.13,76.66 80.13,75.59 80.27,75.45 80.55,75.45 80.69,75.59 80.69,76.66 80.83,76.8 82.23,76.8 82.47,76.56 83.44,76.56 84.66,75.33 85.96,75.33 93.55,67.74 93.55,67.73 93.6,67.68 93.6,67.17 93.73,67.04 94.36,67.04 94.39,67.01
  BOTTOM w0.152: U63.J3 v4(74.76,79.73)
DDR4_C1_DQ55: length 57.1
  TOP w0.152: v2(103.24,63.84) U1.J22
  07_SIG3 w0.173: 94.39,65.61 94.72,65.28 99.51,65.28 99.74,65.05 99.74,64.64 100.03,64.34 100.44,64.34 100.74,64.05 100.74,63.64 101.03,63.34 102.74,63.34 v2(103.24,63.84) ; 74.03,76.89 73.96,76.95 73.96,81.34 v4(74.76,82.13)
  07_SIG3 w0.262: 94.39,65.61 94.31,65.68 92.38,65.68 92.25,65.8 92.25,67.18 86.39,73.04 85.04,73.04 82.94,75.13 81.66,75.13 80.57,74.05 80.57,73.33 80.11,72.87 79.46,72.87 79.32,72.73 79.32,72.01 79.18,71.87 78.93,71.87 78.76,72.04 78.76,72.76 78.62,72.9 78.34,72.9 78.2,72.76 78.2,71.86 78.06,71.72 77.78,71.72 77.65,71.86 77.65,72.76 77.51,72.9 77.23,72.9 77.09,72.76 77.09,71.86 76.95,71.72 76.67,71.72 76.53,71.86 76.53,72.76 76.39,72.9 76.11,72.9 75.97,72.76 75.97,71.86 75.83,71.72 75.55,71.72 75.41,71.86 75.41,72.21 75.27,72.35 74.99,72.35 74.85,72.21 74.85,71.86 74.71,71.72 74,71.72 73.73,71.98 73.73,73.29 73.44,73.58 73.44,75.7 74.03,76.29 74.03,76.89
  BOTTOM w0.152: U63.J7 v4(74.76,82.13)
DDR4_C1_DQ56: length 39.7
  TOP w0.152: v2(102.24,64.84) U1.H23
  03_SIG1 w0.173: 81.7,79.05 81.7,79.79 80.59,80.9 79.21,80.9 79.12,80.81 79.12,80.23 79.21,80.14 79.48,80.14 79.69,80.35 80.32,80.35 80.48,80.19 80.7,80.19 v4(81.16,79.73) ; 94.39,69.75 94.79,69.34 96.55,69.34 96.74,69.15 96.74,68.62 97.02,68.34 97.47,68.34 97.74,68.08 97.74,67.64 98.03,67.34 98.44,67.34 98.44,67.34 98.74,67.05 98.74,66.64 98.6,66.5 98.6,66.4 98.79,66.21 99.24,66.21 99.39,66.07 99.39,65.61 99.74,65.26 99.74,64.54 99.93,64.34 101.5,64.34 101.72,64.56 101.72,65.08 101.93,65.28 101.93,65.76 102.04,65.88 102.3,65.88 102.44,65.75 102.44,65.04 v2(102.24,64.84)
  03_SIG1 w0.262: 81.7,79.05 81.95,78.8 81.95,78.43 82.09,78.29 82.48,78.29 82.9,77.87 83.36,77.87 83.52,78.03 84.69,78.03 85.08,78.42 85.72,78.42 87,77.13 87.01,77.13 87.99,76.15 87.99,76.14 94.39,69.75
  BOTTOM w0.152: U63.A3 v4(81.16,79.73)
DDR4_C1_DQ57: length 40
  TOP w0.152: v2(102.24,63.84) U1.H22
  03_SIG1 w0.173: 81.61,84.13 80.45,84.13 80.36,84.04 v4(80.36,83.73) ; v2(102.24,63.84) 102.24,63.44 102.34,63.33 102.64,63.33 102.74,63.44 102.74,67.05 102.44,67.34 102.03,67.34 101.74,67.64 101.74,68.05 101.44,68.34 101.03,68.34 100.74,68.64 100.74,69.05 100.44,69.34 100.03,69.34 99.74,69.64 99.74,71.05 99.44,71.34 99.03,71.34 98.74,71.64 98.74,72.05 98.44,72.34 98.03,72.34 97.74,72.64 97.74,73.05 97.44,73.34 97.03,73.34 96.74,73.64 96.74,74.05 96.44,74.34 95.91,74.34 95.74,74.51 95.74,75.05 95.44,75.34 94.39,75.34
  03_SIG1 w0.262: 81.61,84.13 81.87,84.13 82.01,83.99 82.01,83.78 81.88,83.64 81.77,83.64 81.65,83.51 81.65,83.27 81.78,83.14 82.42,83.14 82.61,82.95 83.25,82.95 83.42,83.12 83.42,83.33 83.62,83.53 84.67,83.53 84.81,83.39 84.81,83.21 85.05,82.97 85.59,82.97 85.72,83.11 86,83.11 86.13,82.98 86.13,82.74 86.36,82.51 86.67,82.51 93.84,75.34 94.39,75.34
  BOTTOM w0.152: U63.B8 v4(80.36,83.73)
DDR4_C1_DQ58: length 35.2
  TOP w0.152: v2(99.24,64.84) U1.E23
  03_SIG1 w0.173: v4(79.56,79.73) 79.66,79.83 79.82,79.83 79.95,79.7 79.95,79.57 80.19,79.33 80.61,79.33 80.76,79.19 80.76,78.77 80.99,78.53 81.44,78.53 81.56,78.41 81.56,77.85 81.61,77.8 ; 94.39,68.84 94.88,68.34 96.52,68.34 96.74,68.12 96.74,67.53 96.92,67.34 97.5,67.34 97.74,67.1 97.74,66.59 97.54,66.39 97.54,66.24 98.08,65.69 98.32,65.69 98.53,65.9 98.89,65.9 99.01,65.79 99.01,65.58 99.43,65.16 99.43,65.04 v2(99.24,64.84)
  03_SIG1 w0.262: 94.39,68.84 87.39,75.84 87.19,75.84 86.71,75.36 86.52,75.36 86.19,75.68 86.19,75.86 86.66,76.32 86.66,76.56 86.15,77.07 85.92,77.07 85.5,76.64 85.21,76.64 84.48,77.37 83.85,77.37 83.64,77.16 83.64,76.92 83.86,76.69 84.24,76.69 84.5,76.43 84.5,76.22 84.3,76.02 83.63,76.02 83.18,76.47 82.61,76.47 82.34,76.75 82.34,77.49 82.19,77.64 81.78,77.64 81.61,77.8
  BOTTOM w0.152: U63.C3 v4(79.56,79.73)
DDR4_C1_DQ59: length 36
  TOP w0.152: v2(99.24,63.84) U1.E22
  03_SIG1 w0.173: 94.39,67.93 94.97,67.34 96.44,67.34 96.74,67.05 96.74,66.58 97.95,65.37 98.42,65.37 98.74,65.05 98.74,64.61 99.24,64.11 v2(99.24,63.84) ; 80.95,76.89 80.76,77.08 80.76,78.3 80.52,78.53 80.19,78.53 79.96,78.77 79.96,79.1 79.72,79.33 78.59,79.33 78.36,79.57 78.36,80.26 78.27,80.35 78.02,80.35 77.93,80.44 77.93,80.62 78.02,80.71 78.28,80.71 78.38,80.8 78.38,80.98 78.29,81.06 78.02,81.06 77.93,81.15 77.93,81.33 78.02,81.42 78.27,81.42 78.36,81.51 78.36,82.3 78.59,82.53 U63.C7 v4(79.56,82.13)
  03_SIG1 w0.262: 80.95,76.89 81.03,76.8 81.36,76.8 82.35,75.82 82.89,75.82 83.34,75.37 84.31,75.37 84.53,75.16 84.79,75.16 85,75.37 85.56,75.37 86.21,74.71 87.6,74.71 94.39,67.93
  BOTTOM w0.152: U63.C7 v4(79.56,82.13)
DDR4_C1_DQ60: length 35.6
  TOP w0.152: v2(100.24,62.84) U1.F21
  03_SIG1 w0.173: 94.39,67.02 95.54,65.86 96.93,65.86 97.74,65.05 97.74,64.64 98.03,64.34 98.44,64.34 98.74,64.05 98.74,63.64 99.03,63.34 100.61,63.34 100.7,63.25 100.7,62.89 100.66,62.84 v2(100.24,62.84) ; 79.16,76.89 79.16,78.11 79.24,78.2 79.49,78.2 v4(79.56,78.13)
  03_SIG1 w0.262: 94.39,67.02 87.34,74.07 86.74,74.07 86.6,73.93 86.6,73.76 86.46,73.62 86.18,73.62 86.04,73.76 86.04,73.92 85.81,74.16 85.58,74.16 85.58,74.16 85.11,74.16 85.11,74.16 84.61,74.16 84.05,74.72 83.04,74.72 82.59,75.17 81.79,75.17 81.43,74.81 81.11,74.81 80.92,75 80.92,75.18 81.45,75.72 81.45,75.99 81.26,76.17 81,76.17 80.46,75.64 80.2,75.64 80.01,75.83 80.01,76.09 80.37,76.45 80.37,76.72 80.18,76.91 79.91,76.91 79.56,76.55 79.29,76.55 79.16,76.68 79.16,76.89
  BOTTOM w0.152: U63.C2 v4(79.56,78.13)
DDR4_C1_DQ61: length 37.2
  TOP w0.152: v2(99.24,62.84) U1.E21
  03_SIG1 w0.173: v4(79.56,83.73) U63.C8 78.59,83.33 78.36,83.1 78.36,82.77 78.12,82.53 77.79,82.53 77.56,82.3 77.56,79.57 77.79,79.33 78.12,79.33 78.36,79.1 78.36,76.89 ; v2(99.24,62.84) 98.96,62.84 98.46,63.34 98.03,63.34 97.74,63.64 97.74,64.05 97.44,64.34 97.03,64.34 96.74,64.64 96.74,65.05 96.41,65.38 95.12,65.38 94.39,66.11
  03_SIG1 w0.262: 78.36,76.89 78.36,76.79 80.87,74.27 82.51,74.27 82.72,74.07 83.47,74.07 84.49,73.04 85.76,73.04 85.84,72.96 87.54,72.96 94.39,66.11
  BOTTOM w0.152: U63.C8 v4(79.56,83.73)
DDR4_C1_DQ62: length 36.5
  TOP w0.152: v2(100.24,66.84) U1.F24
  03_SIG1 w0.173: 81.61,80.49 80.76,81.33 78.92,81.33 78.76,81.17 v4(78.76,79.73) ; 94.39,70.66 94.71,70.34 95.55,70.34 95.74,70.53 95.74,71.12 95.96,71.34 96.48,71.34 96.74,71.09 96.74,69.64 97.03,69.34 97.49,69.34 97.74,69.09 97.74,68.57 97.97,68.34 98.44,68.34 98.74,68.05 98.74,67.64 99.03,67.34 99.44,67.34 99.74,67.05 99.74,65.69 100.08,65.35 100.32,65.35 100.49,65.52 100.49,66.01 100.24,66.26 v2(100.24,66.84)
  03_SIG1 w0.262: 94.39,70.66 85.9,79.15 84.68,79.15 84.34,78.8 83.01,78.8 82.34,79.48 82.34,79.76 81.61,80.49
  BOTTOM w0.152: U63.D3 v4(78.76,79.73)
DDR4_C1_DQ63: length 38.2
  TOP w0.152: v2(100.24,64.84) U1.F23
  03_SIG1 w0.173: 81.61,81.14 81.59,81.14 81.04,81.69 79.2,81.69 v4(78.76,82.13) ; v2(100.24,64.84) 100.43,64.65 100.67,64.65 100.75,64.74 100.75,65.17 100.86,65.28 101.19,65.28 101.3,65.38 101.3,65.58 101.22,65.66 100.88,65.66 100.79,65.75 100.79,65.94 100.89,66.04 101.22,66.04 101.3,66.12 101.3,66.32 101.19,66.42 100.88,66.42 100.74,66.56 100.74,67.05 100.44,67.34 99.92,67.34 99.74,67.52 99.74,68.05 99.44,68.34 98.93,68.34 98.74,68.54 98.74,69.05 98.44,69.34 97.95,69.34 97.74,69.56 97.74,71.05 97.44,71.34 97.1,71.34 97.1,71.34 96.95,71.34 96.74,71.55 96.74,72.05 96.44,72.34 96.03,72.34 95.74,72.05 95.74,71.58 95.5,71.34 94.62,71.34 94.39,71.57
  03_SIG1 w0.262: 81.61,81.14 81.88,81.14 82.53,80.48 83.22,80.48 83.53,80.18 83.53,79.76 83.71,79.57 84.16,79.57 84.34,79.75 84.34,80.16 84.67,80.48 85.47,80.48 86.08,79.88 86.08,79.88 94.39,71.57
  BOTTOM w0.152: U63.D7 v4(78.76,82.13)
DDR4_C1_DQ64: length 55
  TOP w0.152: U1.A24 v2(95.24,66.84)
  16_SIG5 w0.089: v4(76.36,49.94) 75.96,49.54 74.06,49.54 73.72,49.88 73.72,51.72 73.43,52.01 73.43,53.65 73.56,53.77 73.56,57.07 ; 81.61,71.15 81.59,71.17
  16_SIG5 w0.14: 73.56,57.07 73.56,61.99 74.24,62.68 81.52,62.68 81.68,62.84 81.68,71.08 81.61,71.15 ; 81.59,71.17 81.42,71.35 80.83,71.35 80.55,71.64 80.55,73.8 81.02,74.27 82.93,74.27 83.41,73.8 83.41,73.36 84.88,71.89 86.48,71.89 91.41,66.95 94.67,66.95 94.78,66.84 v2(95.24,66.84)
  BOTTOM w0.152: U64.G2 v4(76.36,49.94)
DDR4_C1_DQ65: length 54.2
  TOP w0.152: U1.A23 v2(95.24,64.84)
  16_SIG5 w0.089: 76.76,57.07 U64.F7 v4(77.16,53.94)
  16_SIG5 w0.14: 76.76,57.07 76.76,57.46 76.48,57.74 75.9,57.74 75.63,58 75.63,58.52 75.9,58.78 76.63,58.78 76.76,58.91 76.76,59.95 76.96,60.16 77.29,60.16 77.55,59.9 77.55,58.27 77.8,58.02 78.06,58.02 78.35,58.31 78.35,59.91 78.6,60.16 78.95,60.16 79.17,59.94 79.17,59.24 79.41,58.99 79.72,58.99 79.97,59.24 79.97,59.91 80.22,60.16 83.51,60.16 83.92,59.75 84.55,59.75 84.67,59.88 84.67,60.98 85.05,61.35 85.63,61.35 85.97,61.02 85.97,59.04 86.24,58.77 86.55,58.77 86.73,58.95 86.73,61.49 86.9,61.66 87.18,61.66 87.34,61.5 87.34,58.9 87.47,58.77 87.86,58.77 88,58.91 88,61.45 88.19,61.63 88.48,61.63 88.61,61.5 88.61,60.12 88.84,59.9 89.01,59.9 89.24,60.13 89.24,61.54 89.42,61.73 89.74,61.73 89.87,61.59 89.87,61.26 90.1,61.03 90.28,61.03 90.79,61.54 90.79,61.8 90.13,62.45 90.13,62.68 90.69,63.24 90.92,63.24 91.55,62.61 91.92,62.61 92.14,62.84 92.14,63.26 91.65,63.75 91.65,64.21 91.99,64.55 92.35,64.55 92.96,63.93 93.19,63.93 93.85,64.59 94.39,64.59 94.64,64.84 v2(95.24,64.84)
  BOTTOM w0.152: U64.F7 v4(77.16,53.94)
DDR4_C1_DQ66: length 55.8
  TOP w0.152: U1.C24 v2(97.24,66.84)
  16_SIG5 w0.089: 94.39,57.89 94.84,58.34 95.44,58.34 95.74,58.64 95.74,59.05 96.03,59.34 96.44,59.34 96.74,59.64 96.74,60.05 97.03,60.34 97.44,60.34 97.74,60.64 97.74,61.05 98.03,61.34 98.44,61.34 98.74,61.64 98.74,62.05 99.03,62.34 99.44,62.34 99.74,62.64 99.74,63.05 100.03,63.34 100.44,63.34 100.74,63.64 100.74,67.05 100.44,67.34 98,67.34 97.5,66.84 v2(97.24,66.84) ; v4(75.56,51.54) 75.56,51.3 75.96,50.9 75.96,50.57 76.19,50.34 76.52,50.34 76.76,50.1 76.76,48.72 76.79,48.69
  16_SIG5 w0.14: 94.39,57.89 92.95,56.45 92.95,48.57 87.01,42.63 86.37,42.63 86.37,42.64 83.38,42.64 83.01,43.01 81.95,43.01 81.54,43.42 77.4,43.42 76.79,44.03 76.79,48.69
  BOTTOM w0.152: U64.H3 v4(75.56,51.54)
DDR4_C1_DQ67: length 55.5
  TOP w0.152: U1.C23 v2(97.24,64.84)
  16_SIG5 w0.089: v4(75.56,53.94) 75.96,54.34 75.96,56.88 75.77,57.07 ; v2(97.24,64.84) 97.14,64.84 96.64,64.34 96.03,64.34 95.74,64.64 95.74,65.3 95.54,65.49 94.69,65.49 94.56,65.36 94.39,65.36
  16_SIG5 w0.14: 94.39,65.36 90.45,65.36 90.23,65.14 90.23,63.92 88.78,62.47 88.3,62.47 88.04,62.73 88.04,63.21 87.78,63.47 87.26,63.47 87,63.21 87,62.73 86.73,62.47 86.16,62.47 86.04,62.59 86.04,66.67 86.7,67.33 87.44,67.33 88.04,67.93 88.04,68.12 86.57,69.59 86.32,69.59 86.11,69.38 86.11,68.03 85.61,67.53 84.54,67.53 84.37,67.36 84.37,62.12 83.6,61.35 82.64,61.35 82.33,61.04 79.3,61.04 79.19,61.16 79.19,61.16 78.9,61.44 78.73,61.61 78.14,61.61 77.87,61.35 77.87,61.02 77.61,60.76 77.09,60.76 76.83,61.02 76.83,61.35 76.57,61.61 75.26,61.61 74.91,61.26 74.91,60.51 75.17,60.25 75.54,60.25 75.8,59.98 75.8,59.46 75.54,59.2 75.17,59.2 74.91,58.94 74.91,57.93 75.77,57.07
  BOTTOM w0.152: U64.H7 v4(75.56,53.94)
DDR4_C1_DQ68: length 54.9
  TOP w0.152: U1.B23 v2(96.24,64.84)
  16_SIG5 w0.089: 94.39,66.13 97.14,66.13 97.27,66 97.27,65.62 97.07,65.43 96.41,65.43 96.24,65.25 v2(96.24,64.84) ; 74.33,57.07 74.33,57.03 74.36,57.01 74.36,50.57 74.59,50.34 U64.H2 v4(75.56,49.94)
  16_SIG5 w0.14: 74.33,57.07 74.33,61.68 74.76,62.12 81.94,62.12 82.55,62.72 83.24,62.72 83.52,63 83.52,68.38 83.75,68.61 84.5,68.61 84.73,68.84 84.73,69.36 84.52,69.58 82.73,69.58 82.5,69.81 82.5,70.35 82.74,70.59 83.23,70.59 83.44,70.81 83.44,71.51 83.61,71.68 83.99,71.68 84.19,71.48 84.19,70.44 84.32,70.31 84.57,70.31 85.07,70.81 86.47,70.81 91.14,66.13 94.39,66.13
  BOTTOM w0.152: U64.H2 v4(75.56,49.94)
DDR4_C1_DQ69: length 54.5
  TOP w0.152: U1.B22 v2(96.24,63.84)
  16_SIG5 w0.089: 77.56,57.07 77.56,53.78 77.32,53.54 75.39,53.54 75.16,53.77 75.16,55.14 v4(75.56,55.54) ; v2(96.24,63.84) 95.94,63.84 95.44,64.34 94.96,64.34 94.44,63.82 94.39,63.82
  16_SIG5 w0.14: 77.56,57.07 77.56,57.2 77.76,57.4 79,57.4 79.17,57.57 79.17,58.07 79.46,58.36 80.28,58.36 80.43,58.51 80.43,59.02 80.65,59.24 81.51,59.24 81.65,59.11 81.65,58.71 81.82,58.53 82.2,58.53 82.58,58.91 84.05,58.91 84.35,58.62 84.35,56.97 84.71,56.61 85.73,56.61 86.16,56.17 86.16,53.12 86.26,53.02 86.93,53.02 87.11,53.2 87.11,56.92 86.85,57.18 86.17,57.18 85.97,57.38 85.97,57.47 85.94,57.5 85.94,57.72 86.15,57.93 87.7,57.93 87.93,57.7 87.93,53.14 88.06,53.01 88.47,53.01 88.63,53.17 88.63,58.21 94.24,63.82 94.39,63.82
  BOTTOM w0.152: U64.H8 v4(75.56,55.54)
DDR4_C1_DQ70: length 55
  TOP w0.152: U1.B21 v2(96.24,62.84)
  16_SIG5 w0.089: v4(74.76,51.54) 74.83,51.61 74.83,52.28 75.28,52.73 77.92,52.73 78.71,53.52 81.46,53.52 81.61,53.38 ; 94.39,60.61 94.53,60.75 94.53,60.91 94.97,61.34 95.14,61.34 95.14,61.34 95.44,61.34 95.74,61.64 95.74,61.94 95.74,61.94 95.74,62.34 v2(96.24,62.84)
  16_SIG5 w0.14: 81.61,53.38 81.8,53.19 82.34,53.19 83.37,52.16 83.37,51.02 83.38,51.01 83.38,50.26 82.88,49.76 82.88,49.21 83.38,48.72 83.38,47.76 83.16,47.54 78.77,47.54 78.46,47.23 78.46,46.83 78.69,46.6 80.64,46.6 80.81,46.42 80.81,45.5 80.95,45.37 81.68,45.37 81.93,45.62 81.93,46.3 82.19,46.56 83.11,46.56 83.35,46.32 83.35,45.97 83.96,45.37 87.18,45.37 91.01,49.19 91.01,57.23 94.39,60.61
  BOTTOM w0.152: U64.J3 v4(74.76,51.54)
DDR4_C1_DQ71: length 55.3
  TOP w0.152: U1.A21 v2(95.24,62.84)
  16_SIG5 w0.089: 81.61,54.34 78.59,54.34 78.36,54.1 78.36,53.78 77.81,53.23 74.91,53.23 74.76,53.38 v4(74.76,53.94)
  16_SIG5 w0.14: 81.61,54.34 82.3,54.34 84.14,52.49 84.14,51.34 84.15,51.33 84.15,47.79 84.15,47.78 84.15,46.54 84.52,46.18 84.93,46.18 85.13,46.37 85.13,46.8 85.32,46.99 85.76,46.99 85.97,46.78 85.97,46.38 86.18,46.18 86.78,46.18 87.1,46.5 87.1,51.21 87.32,51.43 87.66,51.43 87.86,51.23 87.86,47.84 88.02,47.69 88.4,47.69 88.59,47.87 88.59,51.22 88.74,51.37 89.18,51.37 89.38,51.16 89.38,49.53 89.61,49.3 89.99,49.3 90.2,49.52 90.2,57.56 95.24,62.6 v2(95.24,62.84)
  BOTTOM w0.152: U64.J7 v4(74.76,53.94)
DDR4_C1_DQ72: length 33.8
  TOP w0.152: U1.D7 v2(98.24,48.84)
  05_SIG2 w0.173: v2(98.24,48.84) 97.74,48.34 97.03,48.34 96.74,48.64 96.74,49.05 96.44,49.34 96.03,49.34 95.74,49.05 95.74,48.64 95.44,48.34 94.61,48.34 94.39,48.11 ; v4(81.16,51.54) 81.56,51.54 81.61,51.59
  05_SIG2 w0.262: 94.39,48.11 94.14,47.87 94.14,46.63 94.02,46.51 87.6,46.51 86.18,47.93 86.18,49.08 85.88,49.38 85.5,49.38 85.06,49.81 85.06,50.12 84.92,50.26 84.64,50.26 84.53,50.15 84.53,49.46 84.41,49.34 84.11,49.34 83.97,49.48 83.97,51.61 83.82,51.77 83.57,51.77 83.39,51.59 83.39,49.45 83.27,49.34 82.94,49.34 82.8,49.48 82.8,50 82.66,50.14 82.38,50.14 82.24,50 82.24,49.48 82.1,49.34 81.79,49.34 81.66,49.47 81.66,50.6 81.8,50.73 81.99,50.73 82.46,51.21 82.46,51.37 82.02,51.82 81.84,51.82 81.61,51.59
  BOTTOM w0.152: U64.A3 v4(81.16,51.54)
DDR4_C1_DQ73: length 34.4
  TOP w0.152: U1.C7 v2(97.24,48.84)
  05_SIG2 w0.173: 81.61,55.14 80.76,55.14 v4(80.36,55.54) ; v2(97.24,48.84) 97.24,49.17 96.74,49.67 96.74,51.05 96.44,51.34 94.86,51.34 94.73,51.47 94.39,51.47
  05_SIG2 w0.262: 94.39,51.47 93.95,51.47 93.62,51.14 92.06,51.14 91.78,51.42 90.37,51.42 90.18,51.61 90.18,53.97 90.04,54.11 89.76,54.11 89.62,53.97 89.62,51.61 89.48,51.47 89.2,51.47 89.06,51.61 89.06,53.97 88.93,54.11 88.65,54.11 88.51,53.97 88.51,51.61 88.37,51.47 88.05,51.47 87.93,51.6 87.93,55.08 87.6,55.4 82.45,55.4 82.18,55.14 81.61,55.14
  BOTTOM w0.152: U64.B8 v4(80.36,55.54)
DDR4_C1_DQ74: length 34.3
  TOP w0.152: U1.B8 v2(96.24,49.84)
  05_SIG2 w0.173: 94.39,49.03 94.7,49.34 95.47,49.34 95.97,49.84 v2(96.24,49.84) ; v4(79.56,51.54) 79.56,53.37 79.69,53.51 79.87,53.51 79.96,53.42 79.96,52.06 80.05,51.97 80.27,51.97 80.36,52.06 80.36,53.42 80.45,53.51 80.71,53.51 80.8,53.42 80.8,52.09 80.88,52 81.11,52 81.2,52.09 81.2,53.42 81.3,53.52 81.48,53.52 81.61,53.39 81.61,52.62 81.76,52.48
  05_SIG2 w0.262: 94.39,49.03 94.33,48.97 93.73,48.97 93.47,48.71 93.47,47.4 93.24,47.17 92.65,47.17 92.32,47.5 91.95,47.5 91.62,47.17 91.27,47.17 91.13,47.31 91.13,47.54 90.99,47.68 90.71,47.68 90.57,47.54 90.57,47.31 90.43,47.17 90.15,47.17 90.01,47.31 90.01,47.59 89.87,47.73 89.59,47.73 89.45,47.6 89.45,47.31 89.31,47.17 89.04,47.17 88.9,47.31 88.9,47.61 88.76,47.75 88.48,47.75 88.34,47.61 88.34,47.31 88.2,47.17 87.9,47.17 86.82,48.26 86.82,49.86 85.72,50.95 85.24,50.95 84.8,51.4 84.8,51.88 84.2,52.48 81.76,52.48
  BOTTOM w0.152: U64.C3 v4(79.56,51.54)
DDR4_C1_DQ75: length 35
  TOP w0.152: U1.B7 v2(96.24,48.84)
  05_SIG2 w0.173: 94.39,45.81 94.46,45.81 95,46.35 95.59,46.35 95.74,46.49 95.74,47.96 96.24,48.46 v2(96.24,48.84) ; v4(79.56,53.94) 79.16,53.54 79.16,51.37 79.39,51.14 79.77,51.14 79.96,50.95 79.96,48.84 79.81,48.69
  05_SIG2 w0.262: 79.81,48.69 79.75,48.63 76.46,48.63 76.3,48.47 76.3,48.19 76.51,47.99 81.13,47.99 81.83,48.69 84.44,48.69 87.32,45.81 94.39,45.81
  BOTTOM w0.152: U64.C7 v4(79.56,53.94)
DDR4_C1_DQ76: length 37.1
  TOP w0.152: U1.C10 v2(97.24,51.84)
  05_SIG2 w0.173: v2(97.24,51.84) 96.74,52.34 96.74,53.05 96.44,53.34 96.03,53.34 95.74,53.64 95.74,54.05 95.44,54.34 94.98,54.34 94.39,54.94 94.39,55.09 ; v4(79.56,49.94) U64.C2 78.55,50.34 78.36,50.53 78.36,51.84 78.1,52.1 77.71,52.1 77.58,52.23 77.58,52.47 77.69,52.58 77.91,52.58 78.05,52.73 78.05,52.93 77.93,53.04 77.25,53.04 77.14,53.16 77.14,53.38 77.25,53.49 77.45,53.49 77.56,53.6 77.56,56.5 78.13,57.07
  05_SIG2 w0.262: 94.39,55.09 88.7,60.78 86.18,60.78 85.58,60.18 85.11,60.18 84.69,60.6 83.58,60.6 83.17,60.18 82.62,60.18 82.37,60.43 81.48,60.43 78.13,57.07
  BOTTOM w0.152: U64.C2 v4(79.56,49.94)
DDR4_C1_DQ77: length 37.2
  TOP w0.152: U1.B10 v2(96.24,51.84)
  05_SIG2 w0.173: 81.61,55.94 80.17,55.94 79.77,55.54 v4(79.56,55.54) ; v2(96.24,51.84) 95.86,51.84 95.4,52.3 94.39,52.3
  05_SIG2 w0.262: 94.39,52.3 93.99,52.7 93.75,52.7 93.66,52.6 93.66,52.12 93.44,51.91 93.26,51.91 93.07,52.09 93.07,53.59 92.93,53.73 92.65,53.73 92.51,53.59 92.51,52.14 92.39,52.02 92.11,52.02 91.96,52.17 91.96,54.7 91.82,54.84 91.54,54.84 91.4,54.7 91.4,52.23 91.25,52.08 91.02,52.08 90.86,52.24 90.86,54.62 90.69,54.79 89.77,54.79 89.63,54.93 89.63,55.27 89.77,55.41 90.71,55.41 90.85,55.55 90.85,55.82 90.71,55.96 89.77,55.96 89.63,56.1 89.63,56.46 89.49,56.6 89.21,56.6 89.07,56.46 89.07,54.93 88.93,54.79 88.73,54.79 88.59,54.93 88.59,56.31 88.36,56.54 82.58,56.54 81.97,55.94 81.61,55.94
  BOTTOM w0.152: U64.C8 v4(79.56,55.54)
DDR4_C1_DQ78: length 36.4
  TOP w0.152: U1.B11 v2(96.24,52.84)
  05_SIG2 w0.173: v2(96.24,52.84) 96.24,52.45 96.11,52.33 95.9,52.33 95.71,52.52 95.71,53.05 95.42,53.34 95.08,53.34 94.39,54.03 94.39,54.15 ; 79.7,57.55 79.53,57.38 79.06,57.38 78.97,57.29 78.97,56.93 78.8,56.76 78.47,56.76 78.36,56.66 78.36,53.42 78.45,53.32 78.61,53.32 78.78,53.16 78.78,52.92 78.68,52.82 78.52,52.82 78.41,52.71 78.41,52.34 78.52,52.22 78.69,52.22 78.76,52.15 v4(78.76,51.54)
  05_SIG2 w0.262: 79.7,57.55 79.7,57.85 79.9,58.05 80.1,58.05 80.43,57.72 80.64,57.72 80.84,57.92 80.84,58.1 80.49,58.44 80.49,58.77 80.72,59 81.46,59 81.57,59.11 81.57,59.63 81.71,59.77 81.99,59.77 82.13,59.63 82.13,59.09 82.31,58.92 83.38,58.92 83.56,59.09 83.56,59.63 83.79,59.86 84.45,59.86 84.67,59.64 84.67,59.14 84.9,58.92 85.67,58.92 85.87,59.12 85.87,59.54 86.02,59.69 86.34,59.69 86.49,59.54 86.49,59.14 86.63,59 86.91,59 87.05,59.14 87.05,59.99 87.18,60.11 88.42,60.11 94.39,54.15
  BOTTOM w0.152: U64.D3 v4(78.76,51.54)
DDR4_C1_DQ79: length 36.2
  TOP w0.152: U1.A11 v2(95.24,52.84)
  05_SIG2 w0.173: 94.39,53.22 94.39,53.14 94.68,52.84 v2(95.24,52.84) ; 81.41,57.07 81.41,57 81.41,57 81.41,56.85 81.33,56.77 81.02,56.77 80.93,56.86 80.93,57.09 80.84,57.18 80.55,57.18 80.46,57.09 80.46,56.86 80.37,56.77 79.36,56.77 79.16,56.57 79.16,54.06 79.03,53.94 v4(78.76,53.94)
  05_SIG2 w0.262: 81.41,57.07 81.41,57.61 81.29,57.72 81.29,58.39 81.42,58.51 81.77,58.51 81.88,58.41 81.88,57.22 82.01,57.09 82.24,57.09 82.35,57.21 82.35,57.64 82.5,57.78 83.32,57.78 83.51,57.59 83.51,57.33 83.64,57.2 84.01,57.2 84.14,57.33 84.14,58.19 84.29,58.34 84.61,58.34 84.74,58.21 84.74,57.96 84.91,57.78 85.84,57.78 86.01,57.61 86.01,57.33 86.15,57.19 86.43,57.19 86.57,57.33 86.57,58.19 86.72,58.34 87,58.34 87.13,58.22 87.13,57.33 87.27,57.19 87.55,57.19 87.73,57.37 87.73,59.33 87.86,59.46 88.15,59.46 88.52,59.09 88.52,58.89 88.24,58.62 88.24,58.39 88.44,58.2 88.62,58.2 88.91,58.5 89.11,58.5 89.31,58.3 89.31,58.1 88.86,57.65 88.86,57.45 89.05,57.26 89.25,57.26 89.7,57.71 89.9,57.71 94.39,53.22
  BOTTOM w0.152: U64.D7 v4(78.76,53.94)
DDR4_C1_DQS0_C: length 41
  TOP w0.145: v2(98.24,51.84) U1.D10
  14_SIG4 w0.107: 94.39,50.64 94.4,50.64 94.43,50.66 94.57,50.66 94.99,50.24 96.52,50.24 96.84,50.56 96.84,52.05 97.03,52.24 98.13,52.24 98.24,52.13 v2(98.24,51.84)
  14_SIG4 w0.108: v4(77.16,37.44) 76.81,37.79 76.81,38.19 77.27,38.66 77.57,38.66 77.68,38.55 77.68,38.48 77.78,38.37 78,38.37 78.11,38.48 78.11,38.55 78.22,38.66 81.09,38.66 82.14,39.71 82.18,39.71 82.2,39.73
  14_SIG4 w0.14: 82.2,39.73 82.73,40.26 83.07,40.26 83.59,39.74 84.08,39.74 84.5,40.16 84.5,40.65 83.37,41.78 83.37,42 83.6,42.22 83.82,42.22 84.95,41.1 85.44,41.1 85.86,41.51 85.86,42.01 85.28,42.58 85.28,42.8 85.51,43.03 85.73,43.03 86.31,42.45 86.8,42.45 87.22,42.87 87.22,43.37 86.64,43.94 86.64,44.16 86.87,44.39 87.09,44.39 87.66,43.81 88.16,43.81 88.58,44.23 88.58,44.72 88,45.3 88,45.52 93.12,50.64 94.39,50.64
  BOTTOM w0.145: v4(77.16,37.44) U60.F3
DDR4_C1_DQS0_T: length 41.1
  TOP w0.145: v2(98.24,52.84) U1.D11
  14_SIG4 w0.107: v2(98.24,52.84) 98.24,52.55 98.13,52.44 96.95,52.44 96.64,52.13 96.64,50.65 96.43,50.44 95.07,50.44 94.64,50.88 94.45,50.88 94.39,50.94
  14_SIG4 w0.108: v4(76.36,37.44) 76.56,37.64 76.56,38.29 77.17,38.91 80.98,38.91 81.96,39.89 81.96,39.93 81.98,39.94
  14_SIG4 w0.14: 81.98,39.94 82.6,40.56 83.2,40.56 83.72,40.04 83.96,40.04 84.2,40.28 84.2,40.52 83.07,41.65 83.07,42.12 83.47,42.53 83.95,42.53 85.08,41.4 85.32,41.4 85.56,41.64 85.56,41.88 84.98,42.46 84.98,42.93 85.38,43.33 85.86,43.33 86.43,42.76 86.67,42.76 86.91,43 86.91,43.24 86.34,43.82 86.34,44.29 86.74,44.69 87.21,44.69 87.79,44.12 88.03,44.12 88.27,44.36 88.27,44.6 87.7,45.17 87.7,45.65 92.99,50.94 94.39,50.94
  BOTTOM w0.145: v4(76.36,37.44) U60.G3
DDR4_C1_DQS1_C: length 53.7
  TOP w0.145: v2(108.24,57.84) 108.74,58.34 U1.P16
  07_SIG3 w0.127: v2(108.24,57.84) 108.06,58.02 108.06,58.29 108.19,58.42 108.54,58.42 108.63,58.33 108.63,54.68 108.4,54.45 107.99,54.45 107.63,54.09 107.63,53.68 107.4,53.45 106.99,53.45 106.63,53.09 106.63,52.68 106.4,52.45 105.99,52.45 105.63,52.09 105.63,51.68 105.4,51.45 104.99,51.45 104.63,51.09 104.63,50.68 104.4,50.45 101.96,50.45 101.63,50.12 101.63,49.67 101.32,49.35 ; 98.7,45.6 98.55,45.45 97.99,45.45 97.63,45.09 97.63,44.59 97.49,44.45 96.97,44.45 96.63,44.11 96.63,42.84 96.19,42.4 96.12,42.4 96.1,42.38
  07_SIG3 w0.178: 82.2,39.52 81.46,39.52 81.31,39.37 80.92,39.37 80.8,39.5 80.8,39.7 80.94,39.84 v4(81.16,39.84)
  07_SIG3 w0.208: 96.1,42.38 95.53,41.81 95.17,41.81 94.83,41.46 94.83,41.11 94.66,40.94 94,40.94 93.64,40.58 93.64,40.04 93.45,39.85 93.05,39.85 92.87,40.04 92.87,40.67 92.48,41.05 91.97,41.05 91.63,40.71 91.63,40.04 91.45,39.85 91.19,39.85 91.01,40.04 91.01,40.79 90.65,41.15 90.13,41.15 89.77,40.79 89.77,40.04 89.59,39.85 89.33,39.85 89.15,40.04 89.15,40.65 88.81,41 88.26,41 87.91,40.65 87.91,40.04 87.73,39.85 87.47,39.85 87.29,40.04 87.29,40.74 86.93,41.1 86.42,41.1 86.05,40.74 86.05,40.04 85.87,39.85 85.32,39.85 84.99,39.52 84.4,39.52 84.22,39.71 84.22,39.92 83.86,40.28 83.35,40.28 82.99,39.92 82.99,39.71 82.8,39.52 82.2,39.52
  07_SIG3 w0.237: 98.7,45.6 98.7,47.17 98.91,47.38 99.71,47.38 99.77,47.32 100.49,47.32 100.77,47.61 100.77,49.13 101,49.35 101.32,49.35
  BOTTOM w0.145: v4(81.16,39.84) U60.A7
DDR4_C1_DQS1_T: length 53.7
  TOP w0.145: U1.P17 108.74,59.34 v2(108.24,58.84)
  07_SIG3 w0.127: 99.04,45.3 98.7,45.3 98.64,45.24 98.07,45.24 97.84,45.01 97.84,44.5 97.57,44.24 97.05,44.24 96.84,44.03 96.84,42.76 96.34,42.25 96.34,42.19 96.32,42.16 ; v2(108.24,58.84) 108.41,58.67 108.63,58.67 108.84,58.46 108.84,54.6 108.49,54.24 108.08,54.24 107.84,54 107.84,53.59 107.49,53.24 107.08,53.24 106.84,53 106.84,52.59 106.49,52.24 106.08,52.24 105.84,52 105.84,51.59 105.49,51.24 105.08,51.24 104.84,51 104.84,50.59 104.49,50.24 102.05,50.24 101.84,50.03 101.84,49.5 101.71,49.37
  07_SIG3 w0.178: v4(80.36,39.84) 80.36,39.43 80.72,39.07 81.43,39.07 81.58,39.22 82.2,39.22
  07_SIG3 w0.208: 82.2,39.22 82.93,39.22 83.29,39.58 83.29,39.8 83.48,39.98 83.73,39.98 83.92,39.8 83.92,39.58 84.28,39.22 85.12,39.22 85.45,39.55 86,39.55 86.36,39.91 86.36,40.61 86.54,40.79 86.8,40.79 86.98,40.61 86.98,39.91 87.35,39.55 87.86,39.55 88.22,39.91 88.22,40.53 88.39,40.69 88.68,40.69 88.84,40.53 88.84,39.91 89.2,39.55 89.72,39.55 90.08,39.91 90.08,40.66 90.26,40.84 90.52,40.84 90.7,40.66 90.7,39.91 91.06,39.55 91.58,39.55 91.94,39.91 91.94,40.59 92.1,40.75 92.36,40.75 92.56,40.54 92.56,39.91 92.92,39.55 93.57,39.55 93.94,39.92 93.94,40.45 94.13,40.63 94.79,40.63 96.32,42.16
  07_SIG3 w0.237: 99.04,45.3 99.49,45.3 99.78,45.59 99.78,46.08 100.02,46.33 100.43,46.33 100.71,46.61 100.71,47.06 101.02,47.37 101.46,47.37 101.71,47.63 101.71,49.37
  BOTTOM w0.145: v4(80.36,39.84) U60.B7
