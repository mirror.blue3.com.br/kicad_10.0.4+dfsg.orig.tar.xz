# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RLD3_C3_72B_DK3_N: length 111.1
  TOP w0.145: U142.L7 v2(71.32,117.17) ; v2(101.24,75.84) 101.74,75.34
  18_SIG6 w0.107: v2(71.32,117.17) 71.36,117.13 71.75,117.13 71.88,117.25 71.88,117.53 72.12,117.77 72.59,117.77 72.93,117.44 72.93,116.68 72.95,116.66 72.95,116.64 ; v2(101.24,75.84) 101.64,75.44 101.64,74.58 101.98,74.24 104.42,74.24 104.64,74.03 104.64,66.47 104.09,65.93 103.4,65.93 102.64,65.17 102.64,64.64 102.44,64.44 94.91,64.44 94.59,64.13 94.44,64.13 94.41,64.16 94.39,64.16
  18_SIG6 w0.108: 72.95,116.64 72.95,116.34 72.37,115.76 70.85,115.76 70.33,116.28 69.69,116.28 69.14,115.74 69.14,115.7 69.13,115.68
  18_SIG6 w0.14: 69.13,115.68 68.88,115.43 68.88,115.22 65.22,111.55 65.22,101.74 65.68,101.27 65.68,96.83 67.83,94.68 81.34,94.68 81.91,94.11 81.91,75.16 80.59,73.84 80.59,72.15 85.12,67.62 86.26,67.62 86.75,68.11 89.42,68.11 93.37,64.16 94.12,64.16 94.39,64.16
RLD3_C3_72B_DK3_P: length 110.9
  TOP w0.145: U142.K7 v2(72.32,117.17) ; v2(102.24,75.84) 102.74,75.34
  18_SIG6 w0.107: 94.39,63.86 94.4,63.86 94.47,63.93 94.68,63.93 94.99,64.24 102.53,64.24 102.84,64.55 102.84,65.09 103.48,65.73 104.18,65.73 104.84,66.39 104.84,74.11 104.51,74.44 102.06,74.44 101.84,74.67 101.84,75.44 v2(102.24,75.84) ; v2(72.32,117.17) 72.19,117.17 72.08,117.27 72.08,117.44 72.21,117.57 72.51,117.57 72.72,117.36 72.72,116.68 72.7,116.66 72.7,116.64
  18_SIG6 w0.108: 72.7,116.64 72.7,116.44 72.27,116.01 70.95,116.01 70.43,116.53 69.59,116.53 68.97,115.91 68.93,115.91 68.91,115.89
  18_SIG6 w0.14: 94.39,63.86 94.12,63.86 94.12,63.85 93.25,63.85 89.29,67.81 86.87,67.81 86.39,67.32 85,67.32 80.29,72.03 80.29,73.97 81.61,75.29 81.61,93.98 81.21,94.38 67.71,94.38 65.38,96.71 65.38,101.14 64.91,101.61 64.91,111.68 68.58,115.35 68.58,115.56 68.91,115.89
RLD3_C3_72B_DM0: length 143.6
  TOP w0.152: U141.B7 v2(93.23,122.32) ; U1.F39 v2(100.24,81.84)
  20_SIG7 w0.089: 102.11,112.83 101.02,112.83 100.73,112.54 100.73,110.05 100.5,109.82 100.02,109.82 99.73,110.12 99.73,112.61 99.52,112.82 98.98,112.82 98.73,112.57 98.73,111.12 98.43,110.82 98.33,110.82 97.99,110.82 97.73,111.08 97.73,111.12 97.73,112.12 97.73,113.12 97.73,114.48 97.73,114.53 97.43,114.82 97.02,114.82 96.73,114.53 96.73,114.14 96.73,114.14 96.73,111.12 96.43,110.82 96.02,110.82 95.73,111.12 95.73,115.53 95.43,115.82 95.41,115.82 93.73,117.51 93.73,118.53 93.43,118.82 93.02,118.82 92.73,118.53 92.73,117.97 92.58,117.82 91.94,117.82 91.73,118.03 91.73,118.53 91.43,118.82 91.02,118.82 90.73,118.53 90.73,118.01 90.54,117.82 90.03,117.82 90.02,117.82 89.73,118.11 89.73,121.53 90.02,121.82 90.43,121.82 90.73,121.53 90.73,121.11 90.73,121.11 90.73,121.1 91.04,120.78 91.43,120.78 91.68,120.53 91.68,120.16 92.02,119.82 93.41,119.82 93.74,120.15 93.74,121.63 94.28,122.17 94.28,123.57 94.16,123.7 93.88,123.7 93.73,123.55 93.73,122.83 v2(93.23,122.32) ; v2(100.24,81.84) 100,81.84 99.5,81.34 98.97,81.34 98.74,81.58 98.74,81.64 98.74,82.25 98.83,82.34 99.53,82.34 99.74,82.55 99.74,83.07 99.46,83.34 98.94,83.34 98.74,83.55 98.74,84.05 98.74,85.09 98.99,85.34 100.58,85.34 100.74,85.5 100.74,86.24 100.63,86.34 99.59,86.34 99.59,86.34 98.84,86.34 98.74,86.45 98.74,87.18 98.9,87.34 100.66,87.34 100.74,87.42 100.74,88.24 100.63,88.34 98.87,88.34 98.74,88.48 98.74,89.05
  20_SIG7 w0.14: 98.74,89.05 98.74,89.81 98.95,90.02 99.19,90.02 99.52,89.69 99.77,89.69 100.01,89.93 100.01,90.17 99.68,90.51 99.68,90.75 101.19,92.26 101.19,94.06 100.83,94.43 100.83,98.26 100.49,98.6 99.14,98.6 98.88,98.85 98.88,99.57 99.22,99.9 101.5,99.9 101.81,99.6 101.81,98.71 102.12,98.4 102.59,98.4 103.23,99.04 103.23,99.63 103.51,99.9 108.67,99.9 108.99,100.23 108.99,100.43 108.76,100.66 108.22,100.66 108.08,100.8 108.08,101.26 107.94,101.4 107.66,101.4 107.52,101.26 107.52,100.8 107.38,100.66 107.1,100.66 106.96,100.8 106.96,101.2 106.82,101.34 106.54,101.34 106.4,101.2 106.4,100.8 106.26,100.66 99.85,100.66 99.69,100.81 99.69,101.04 99.87,101.22 104.52,101.22 104.8,101.5 104.8,102.16 104.99,102.35 106.43,102.35 106.74,102.65 106.74,103.12 106.38,103.48 105.34,103.48 105.15,103.66 105.15,105.11 107.32,107.27 107.32,107.98 107.18,108.12 106.18,108.12 106.05,108.26 106.05,108.54 106.18,108.68 107.18,108.68 107.32,108.82 107.32,109.1 107.18,109.24 106.18,109.24 106.05,109.38 106.05,109.66 106.18,109.8 107.18,109.8 107.32,109.94 107.32,110.36 107.32,110.36 107.32,110.56 107.09,110.8 106.76,110.8 106.17,110.2 105.84,110.2 105.61,110.43 105.61,110.76 106.42,111.57 106.42,111.79 106.15,112.06 105.96,112.06 104.69,110.8 104.49,110.8 104.3,110.99 104.3,111.19 105.37,112.26 105.37,112.46 105,112.83 102.11,112.83
RLD3_C3_72B_DM1: length 143.3
  TOP w0.152: U141.M7 v2(93.23,111.32) ; U1.A35 v2(95.24,77.84)
  18_SIG6 w0.089: 86.82,122 87,121.82 87.43,121.82 87.73,121.52 87.73,121.12 88.04,120.81 88.43,120.81 88.43,120.8 88.44,120.8 88.72,120.53 88.72,120.12 89.02,119.82 91.53,119.82 91.72,119.63 91.72,119.1 91.44,118.82 90.01,118.82 89.73,118.53 89.73,118.1 90,117.82 91.44,117.82 91.74,117.53 91.74,117.11 91.45,116.83 89.61,116.83 89.52,116.74 89.52,116.39 89.86,116.05 91.52,116.05 91.72,115.85 91.72,115.09 91.45,114.82 91.01,114.82 90.73,114.54 90.73,114.1 91.01,113.82 91.56,113.82 91.72,113.65 91.72,113.01 91.53,112.82 91.01,112.82 90.73,112.54 90.73,112.13 91,111.86 91.48,111.86 91.73,111.62 91.73,111.01 91.55,110.83 91,110.83 90.73,110.55 90.73,110.12 91.03,109.82 92.72,109.82 92.96,109.58 92.96,108.97 92.82,108.82 91.5,108.82 91.39,108.71 91.39,108.46 ; v2(95.24,77.84) U1.A35 96.44,77.34 96.74,77.05 96.74,76.64 96.44,76.34 94.98,76.34 94.63,76.7 94.63,79.94 95.03,80.34 95.44,80.34 95.74,80.64 95.74,82.05 95.44,82.34 94.89,82.34 94.57,82.66 94.57,83.15 94.77,83.34 95.44,83.34 95.74,83.64 95.74,84.05 95.44,84.34 94.68,84.34 94.52,84.5 94.52,85.22 94.65,85.34 95.44,85.34 95.74,85.64 95.74,86.05 95.44,86.34 95.03,86.34 94.65,86.72 94.65,87.67 95.03,88.05 95.74,88.05 96.03,88.34 96.44,88.34 96.74,88.05 96.74,82.64 97.03,82.34 97.44,82.34 97.74,82.64 97.74,89.05 98.03,89.34 98.44,89.34 98.74,89.05 98.74,84.64 99.03,84.34 99.44,84.34 99.74,84.64 99.74,89.17 99.17,89.74 98.65,89.74 98.16,90.23 98.16,90.96 ; v2(93.23,111.32) 93.23,110.9 93.13,110.81 92.86,110.81 92.73,110.94 92.73,112.53 93.02,112.82 93.43,112.82 93.73,113.12 93.73,113.54 93.43,113.84 92.89,113.84 92.74,113.99 92.74,114.68 92.88,114.82 94.13,114.82 94.29,114.99 94.29,115.67 93.95,116.02 92.5,116.02 92.34,116.17 92.34,116.59 92.54,116.79 94.14,116.79 94.32,116.97 94.32,117.72 94.22,117.82 92.92,117.82 92.73,118.01 92.73,118.69 92.86,118.82 94.14,118.82 94.27,118.95 94.27,119.7 94.15,119.82 92.95,119.82 92.72,120.05 92.72,120.51 92.41,120.82 90.01,120.82 89.73,121.1 89.73,122.53 89.43,122.83 88.97,122.83 88.73,122.59 88.73,122.11 88.44,121.82 88.05,121.82 87.74,122.12 87.74,123.12 87.53,123.33 86.9,123.33 86.82,123.25
  18_SIG6 w0.14: 86.82,123.25 86.68,123.11 86.68,122.13 86.82,122 ; 91.39,108.46 91.39,108.25 91.58,108.07 93.11,108.07 93.53,107.65 93.53,107.18 93.33,106.98 93.33,106.34 93.55,106.12 95,106.12 96.24,104.88 96.24,104.59 96.5,104.33 98.18,104.33 98.45,104.05 98.45,103.67 98.06,103.28 96.5,103.28 96.24,103.02 96.24,101.27 96.91,100.61 96.91,98.89 98.16,97.64 98.16,93.72 98.42,93.46 99.26,93.46 99.52,93.2 99.52,92.67 99.26,92.41 98.42,92.41 98.16,92.15 98.16,90.96
RLD3_C3_72B_DM2: length 120.3
  TOP w0.152: U1.N24 v2(107.24,66.84) ; U142.B7 v2(81.32,117.17)
  14_SIG4 w0.089: 96.37,90.96 95.77,90.36 95.77,85.57 95.53,85.33 94.97,85.33 94.67,85.03 94.67,84.84 94.39,84.56 ; 94.39,75.36 105.55,75.36 105.78,75.59 105.78,77.1 105.99,77.32 106.46,77.32 106.71,77.57 106.71,78.12 106.89,78.3 107.58,78.3 107.73,78.15 107.73,77.53 107.99,77.26 108.5,77.26 108.75,77.02 108.75,75.59 108.97,75.36 109.31,75.36 109.72,74.95 109.72,74.52 109.92,74.32 110.44,74.32 110.72,74.04 110.72,73.52 110.9,73.34 112.42,73.34 112.72,73.04 112.72,72.58 112.96,72.34 116.58,72.34 116.74,72.18 116.74,66.43 116.66,66.35 116.45,66.35 116.33,66.23 116.33,65.98 116.45,65.85 116.66,65.85 116.74,65.78 116.74,60.45 116.62,60.33 112.98,60.33 112.73,60.59 112.73,69.16 112.54,69.34 111.95,69.34 111.74,69.55 111.74,70.18 111.59,70.33 110.01,70.33 109.73,70.05 109.73,69.58 109.47,69.32 109.01,69.32 108.74,69.05 108.74,67.64 108.44,67.34 108.03,67.34 107.53,66.84 v2(107.24,66.84) ; 86.44,109.36 86.44,109.35 ; 83.59,117.63 83.56,117.67 81.45,117.67 81.32,117.54 v2(81.32,117.17)
  14_SIG4 w0.14: 86.44,109.35 86.95,108.84 86.95,108.84 87,108.79 88.57,108.79 89.59,107.77 89.59,107.22 90.95,105.86 92.64,105.86 93.06,105.44 93.06,102.61 93.68,101.99 93.68,98.73 94.26,98.15 94.38,98.15 96.37,96.16 96.37,90.96 ; 94.39,84.56 93.09,83.26 93.09,75.78 93.51,75.36 94.39,75.36 ; 86.44,109.36 86.44,115.91 85.53,116.81 85.18,116.81 84.67,117.32 83.9,117.32 83.59,117.63
RLD3_C3_72B_DM3: length 111.5
  TOP w0.152: U1.B25 96.74,67.34 v2(96.24,67.84) ; U142.M7 v2(70.32,117.17)
  20_SIG7 w0.089: 68.91,116.54 69.04,116.66 69.82,116.66 v2(70.32,117.17) ; v2(96.24,67.84) 95.74,67.34 94.39,67.34
  20_SIG7 w0.14: 68.91,116.54 68.86,116.48 68.86,115.62 68.73,115.49 68.73,114.64 68.54,114.45 68.17,114.45 68.02,114.6 68.02,115.46 67.79,115.69 67.55,115.69 67.31,115.46 67.31,114.63 67.22,114.54 65.65,114.54 64.97,113.86 64.97,111.73 65.11,111.59 65.9,111.59 66.04,111.45 66.04,111.17 65.9,111.03 65.11,111.03 64.97,110.89 64.97,110.61 65.11,110.47 65.9,110.47 66.04,110.33 66.04,110.06 65.9,109.92 65.11,109.92 64.97,109.78 64.97,109.5 65.11,109.36 65.9,109.36 66.04,109.22 66.04,108.94 65.9,108.8 65.11,108.8 64.97,108.66 64.97,108.38 65.11,108.24 65.9,108.24 66.04,108.1 66.04,107.82 65.9,107.68 65.11,107.68 64.97,107.54 64.97,107.26 65.11,107.12 65.9,107.12 66.04,106.98 66.04,106.7 65.9,106.56 65.11,106.56 64.97,106.42 64.97,106.14 65.11,106 65.9,106 66.04,105.86 66.04,105.59 65.9,105.45 65.11,105.45 64.91,105.25 64.91,102.59 65.15,102.35 65.35,102.35 65.69,102.69 65.89,102.69 66.08,102.49 66.08,102.29 65.74,101.95 65.74,101.75 66.47,101.03 81.82,101.03 82.81,100.03 82.81,91.85 83.35,91.31 83.35,90.64 83.12,90.41 82.71,90.41 81.75,89.44 80.96,89.44 80.83,89.31 80.83,87.01 81.04,86.79 81.27,86.79 81.41,86.93 81.41,88.7 81.55,88.84 81.83,88.84 81.97,88.7 81.97,86.93 82.11,86.79 83.11,86.79 83.52,86.39 83.52,75.28 84.14,74.66 84.14,71.3 84.58,70.85 85.77,70.85 86,70.62 86,69.62 86.42,69.21 86.79,69.21 86.93,69.35 86.93,70.83 87.07,70.97 87.35,70.97 87.49,70.83 87.49,69.35 87.63,69.21 87.91,69.21 88.05,69.35 88.05,70.83 88.19,70.97 88.47,70.97 88.61,70.83 88.61,69.35 88.75,69.21 90.08,69.21 91.95,67.34 94.39,67.34
RLD3_C3_72B_DQ0: length 144.2
  TOP w0.152: U1.H39 v2(102.24,81.84) ; U141.D11 v2(98.23,120.32)
  20_SIG7 w0.089: 102.11,117.09 101.83,116.81 97.05,116.81 97.04,116.82 97.02,116.82 96.73,117.12 96.73,117.53 96.43,117.82 96.39,117.82 96.02,117.82 96.01,117.84 96,117.84 95.73,118.11 95.73,118.53 95.43,118.82 94.92,118.82 94.76,118.98 94.76,119.55 95.02,119.81 95.53,119.81 95.73,120.02 95.73,120.6 95.96,120.82 97.43,120.82 97.43,120.82 97.73,121.12 97.73,121.53 98.02,121.82 98.43,121.82 98.73,122.12 98.73,122.31 98.73,122.31 98.73,122.53 99.02,122.82 99.44,122.82 99.73,122.53 99.73,122.12 99.44,121.82 99.02,121.82 98.73,121.53 98.73,120.44 98.61,120.32 v2(98.23,120.32) ; v2(102.24,81.84) 102.24,82.13 101.74,82.63 101.74,83.05 102.03,83.34 103.44,83.34 103.74,83.64 103.74,84.05 104.03,84.34 104.44,84.34 104.74,84.64 104.74,86.07 105.01,86.34 106.44,86.34 106.74,86.64 106.74,89.7 106.55,89.89 106.07,89.89 105.8,89.63 105.8,87.7 105.44,87.34 104.91,87.34 104.74,87.52 104.74,89.05 104.56,89.22
  20_SIG7 w0.14: 104.56,89.22 104.19,89.59 104.19,94.77 104.91,95.49 105.43,95.49 105.66,95.26 105.66,91.26 105.9,91.02 106.22,91.02 106.45,91.24 106.45,95.26 106.67,95.49 107,95.49 107.23,95.26 107.23,90.01 107.44,89.79 107.78,89.79 108.01,90.03 108.01,95.26 108.24,95.49 112.22,95.49 114.1,97.36 114.1,98.35 113.31,99.14 113.31,99.69 113.45,99.84 116.85,99.84 117.23,100.21 117.23,101.73 117.04,101.92 117.04,107.65 116.33,108.36 116.33,110.35 115.21,111.47 115.21,112.25 115.82,112.86 115.82,113.93 115.66,114.1 114.63,114.1 114.35,114.38 114.35,119.81 113.97,120.19 111.99,120.19 111.81,120.37 111.81,120.78 112.04,121.01 112.39,121.01 112.62,121.24 112.62,121.57 112.39,121.8 112.04,121.8 111.81,122.03 111.81,122.35 112.04,122.58 112.39,122.58 112.62,122.81 112.62,123.14 112.39,123.37 112.04,123.37 111.81,123.6 111.81,123.92 112.04,124.15 112.39,124.15 112.62,124.38 112.62,124.71 112.39,124.94 112.04,124.94 111.81,125.17 111.81,125.62 112.04,125.85 113.54,125.85 113.77,126.08 113.77,127.86 110.69,130.94 107.39,130.94 106.9,130.45 106.9,126.25 106.28,125.63 106.28,120.04 104.7,118.46 104.7,117.8 104.2,117.3 102.31,117.3 102.11,117.09
RLD3_C3_72B_DQ1: length 143.6
  TOP w0.152: U1.H40 v2(102.24,82.84) ; U141.E10 v2(97.23,119.32)
  20_SIG7 w0.089: 110.92,89.36 110.74,89.17 110.74,87.64 110.44,87.34 109.92,87.34 109.74,87.16 109.74,86.64 109.44,86.34 109.03,86.34 108.74,86.05 108.74,85.64 108.44,85.34 108.03,85.34 107.74,85.05 107.74,84.64 107.74,84.55 107.53,84.34 107.03,84.34 106.74,84.05 106.74,83.64 106.44,83.34 106.03,83.34 105.74,83.05 105.74,82.55 105.53,82.34 105.44,82.34 105.03,82.34 105.03,82.34 104.74,82.05 104.74,81.64 104.44,81.34 103.03,81.34 102.74,81.64 102.74,82.34 v2(102.24,82.84) ; v2(97.23,119.32) 97.73,119.82 98.43,119.82 98.44,119.82 102.07,119.82 102.11,119.86
  20_SIG7 w0.14: 102.11,119.86 102.98,120.73 102.98,123.47 103.87,124.36 103.87,124.67 104.01,124.81 104.64,124.81 104.78,124.95 104.78,125.37 104.64,125.51 104.37,125.51 104.03,125.85 104.03,127 104.22,127.19 105.24,127.19 105.33,127.28 105.33,128.36 105.19,128.5 104.57,128.5 104.43,128.64 104.43,129.06 104.57,129.2 105.19,129.2 105.33,129.34 105.33,129.76 104.88,130.21 103.32,130.21 102.94,130.58 102.94,131.18 102.82,131.3 102.48,131.3 101.79,131.99 101.79,133.44 102,133.65 102.49,133.65 102.63,133.52 102.63,132.8 102.77,132.66 103.19,132.66 103.33,132.8 103.33,133.52 103.47,133.65 103.82,133.65 103.96,133.52 103.96,130.91 104.1,130.77 104.51,130.77 104.65,130.91 104.65,131.3 104.79,131.43 105.26,131.43 105.4,131.57 105.4,131.99 105.26,132.13 104.79,132.13 104.65,132.27 104.65,133.52 104.79,133.65 110.19,133.65 117.35,126.49 117.86,126.49 118.82,125.53 118.82,125.17 118.37,124.72 118.37,123.85 118.08,123.56 118.08,122.9 118.62,122.36 118.62,119.75 117.96,119.08 117.96,118.82 118.19,118.59 119.32,118.59 119.57,118.34 119.57,118.08 119.29,117.81 118.19,117.81 117.96,117.58 117.96,117.25 118.19,117.02 119.49,117.02 119.75,116.76 119.75,116.5 119.49,116.24 118.19,116.24 117.96,116.01 117.96,115.68 118.19,115.45 119.23,115.45 119.46,115.22 119.46,114.9 119.23,114.67 118.19,114.67 117.91,114.38 117.91,114.01 118.15,113.77 118.16,113.77 118.42,113.51 118.42,113.2 118.1,112.87 117.85,112.87 117.55,112.58 117.55,111.62 118.26,110.91 119.93,110.91 120.12,110.73 120.12,110.34 119.91,110.13 118.79,110.13 118.65,110 118.65,109.55 118.84,109.36 119.8,109.36 120,109.16 120,108.81 119.76,108.58 118.85,108.58 118.65,108.38 118.65,108.02 118.87,107.81 120.33,107.81 120.56,107.58 120.56,107.23 120.34,107.02 119,107.02 118.74,106.76 118.74,106.5 119,106.24 120.34,106.24 120.53,106.05 120.53,105.61 120.37,105.45 119.46,105.45 119.25,105.25 119.25,104.88 119.47,104.67 120.72,104.67 120.97,104.41 120.97,104.08 120.77,103.88 119.48,103.88 119.21,103.61 119.21,102.83 119.5,102.54 119.82,102.54 120.23,102.14 120.23,101.57 119.78,101.12 119.78,100.13 120.58,99.33 120.58,98.73 120.44,98.59 119.77,98.59 119.63,98.45 119.63,98.04 119.77,97.9 120.44,97.9 120.58,97.76 120.58,97.33 121.21,96.7 121.21,96.4 120.97,96.16 120.63,96.16 119.21,97.57 116.61,97.57 116.13,97.1 116.13,94.26 111.84,89.97 111.53,89.97 110.92,89.36
RLD3_C3_72B_DQ2: length 140.5
  TOP w0.152: U1.G40 v2(101.24,82.84) ; U141.C8 v2(95.23,121.32)
  20_SIG7 w0.089: 102.11,115.98 101.98,115.98 101.83,115.82 100.96,115.82 100.46,116.33 100.05,116.33 99.87,116.16 99.87,115.99 99.7,115.82 99.36,115.82 99.18,115.99 99.18,116.16 99.01,116.33 96.51,116.33 95.73,117.12 95.73,117.53 95.43,117.82 94.83,117.82 94.43,118.22 94.43,118.82 94.38,118.87 94.24,119.01 94.24,119.56 94.57,119.89 94.57,121.15 94.74,121.32 v2(95.23,121.32) ; v2(101.24,82.84) 101.24,83.11 101.74,83.61 101.74,83.64 101.74,84.05 102.03,84.34 103.44,84.34 103.74,84.64 103.74,89.05
  20_SIG7 w0.14: 103.74,89.05 103.74,89.25 103.5,89.49 103.5,95.11 103.94,95.55 103.94,96.6 104.21,96.86 104.73,96.86 105.47,96.13 111.8,96.13 112.59,96.92 112.59,100.18 112.89,100.48 116.43,100.48 116.58,100.63 116.58,101.01 116.39,101.19 114.37,101.19 114.22,101.34 114.22,102 114.55,102.33 116.19,102.33 116.39,102.53 116.39,103.11 116.13,103.37 115.59,103.37 115.35,103.61 115.35,104.04 115.5,104.19 116.21,104.19 116.39,104.37 116.39,104.87 116.21,105.05 115.86,105.05 115.6,105.31 115.6,105.61 115.86,105.87 116.14,105.87 116.37,106.1 116.37,106.47 116.11,106.73 115.74,106.73 115.25,107.22 115.25,107.73 115.61,108.09 115.61,110.11 114.61,111.12 113.56,111.12 113.26,111.42 113.26,112.05 113.45,112.24 113.69,112.24 113.92,112.47 113.92,113.51 113.66,113.77 112.13,113.77 111.9,113.99 111.9,115.23 112.07,115.4 112.47,115.4 112.67,115.2 112.67,114.68 112.86,114.5 113.28,114.5 113.44,114.66 113.44,115.14 113.82,115.52 113.82,116.02 113.68,116.15 111.23,116.15 111.03,115.94 111.03,114.05 110.8,113.82 109.63,113.82 109.44,114 109.44,114.57 109.65,114.78 110.09,114.78 110.24,114.94 110.24,115.89 109.99,116.15 109.49,116.15 109.34,116.3 109.34,116.72 109.51,116.89 113.66,116.89 113.82,117.05 113.82,117.52 113.63,117.71 110.76,117.71 110.57,117.9 110.57,118.27 110.79,118.48 113.63,118.48 113.82,118.67 113.82,119.28 113.56,119.53 111.43,119.53 111.12,119.84 111.12,126.47 111.26,126.61 112.8,126.61 112.93,126.75 112.93,127.16 112.78,127.31 111.26,127.31 111.12,127.45 111.12,127.87 111.26,128.01 112.16,128.01 112.3,128.15 112.3,128.57 112.16,128.71 111.26,128.71 111.12,128.85 111.12,129.57 110.39,130.3 107.82,130.3 107.42,129.9 107.42,126.04 106.8,125.42 106.8,119.81 105.41,118.41 105.41,116.67 104.72,115.98 102.11,115.98
RLD3_C3_72B_DQ3: length 140
  TOP w0.152: U1.F40 v2(100.24,82.84) ; U141.C10 v2(97.23,121.32)
  20_SIG7 w0.089: v2(97.23,121.32) 97.23,121.65 97.05,121.82 94.48,121.82 94.16,121.5 94.16,120.08 93.79,119.71 93.79,118.96 93.82,118.93 94.08,118.67 94.08,117.78 94.73,117.13 94.73,117.12 95.02,116.82 95.04,116.82 96.04,115.82 98.43,115.82 98.73,115.53 98.73,115.52 98.73,115.52 98.73,114.06 98.97,113.82 101.72,113.82 102.11,113.44 ; 101.63,89.26 101.74,89.16 101.74,85.64 101.44,85.34 101.03,85.34 100.74,85.05 100.74,84.64 100.44,84.34 100.03,84.34 99.74,84.05 99.74,83.64 100.03,83.34 100.05,83.34 100.24,83.15 v2(100.24,82.84)
  20_SIG7 w0.14: 102.11,113.44 102.18,113.36 103.21,113.36 104.13,114.27 104.83,114.27 106.83,116.27 106.83,117.42 108.63,119.22 108.63,128.96 108.86,129.19 109.58,129.19 109.8,128.97 109.8,119.38 108,117.57 108,115.16 107.71,114.87 106.58,114.87 105.4,113.69 105.4,113.24 105.96,112.69 107.06,112.69 108,111.76 108,111.31 108.23,111.08 109.2,111.08 109.41,111.29 109.41,112.27 109.59,112.46 110.08,112.46 110.3,112.23 110.3,111.34 110.56,111.08 110.92,111.08 111.11,111.27 111.11,112.1 111.3,112.3 111.78,112.3 111.98,112.1 111.98,110.55 111.72,110.3 108.23,110.3 108,110.07 108,109.74 108.23,109.51 110.08,109.51 110.31,109.28 110.31,108.96 110.08,108.73 108.23,108.73 108,108.5 108,106.07 107.38,105.45 106.41,105.45 105.86,104.9 105.86,104.55 106.12,104.29 106.56,104.29 106.92,104.65 108.13,104.65 108.36,104.88 108.36,105.78 108.63,106.04 108.94,106.04 109.15,105.84 109.15,104.88 109.38,104.65 110.3,104.65 110.56,104.39 110.56,103.64 110.3,103.38 107.84,103.38 107.58,103.12 107.58,102.71 107.84,102.45 109.06,102.45 109.42,102.08 109.42,101.3 109.72,101 110.84,101 111.06,100.78 111.06,100.47 110.79,100.19 109.91,100.19 109.42,99.7 109.42,98.79 109.84,98.37 110.92,98.37 111.16,98.13 111.16,97.63 110.95,97.41 108.29,97.41 108.03,97.67 108.03,98.3 107.7,98.63 106.78,98.63 106.55,98.4 106.55,97.85 106.28,97.59 105.84,97.59 105.56,97.87 105.56,98.4 105.33,98.63 103.73,98.63 102.8,97.7 101.71,97.7 101.48,97.46 101.48,97.18 101.71,96.95 102.38,96.95 102.61,96.72 102.61,96.39 102.38,96.16 101.71,96.16 101.48,95.93 101.48,94.84 102.14,94.18 102.14,92.13 101.19,91.17 101.19,89.71 101.63,89.26
RLD3_C3_72B_DQ4: length 144.4
  TOP w0.152: U1.H38 v2(102.24,80.84) ; U141.C12 v2(99.23,121.32)
  20_SIG7 w0.089: 100.73,122.12 100.44,121.82 99.95,121.82 99.45,121.32 v2(99.23,121.32) ; 111.93,89.24 111.74,89.05 111.74,87.53 111.55,87.34 111.03,87.34 110.74,87.05 110.74,86.64 110.44,86.34 110.03,86.34 109.74,86.05 109.74,85.64 109.44,85.34 109.03,85.34 108.74,85.05 108.74,84.64 108.44,84.34 108.03,84.34 107.74,84.05 107.74,83.64 107.44,83.34 107.03,83.34 106.74,83.05 106.74,82.64 106.73,82.63 106.73,82.58 106.5,82.34 106.44,82.34 106.03,82.34 106.03,82.34 105.74,82.05 105.74,78.74 105.74,78.64 105.44,78.34 105.03,78.34 104.74,78.64 104.74,80.05 104.44,80.34 104.43,80.34 103.44,80.34 103.44,80.34 103.03,80.34 102.77,80.6 102.48,80.6 v2(102.24,80.84)
  20_SIG7 w0.14: 111.93,89.24 112.34,89.66 112.46,89.66 116.24,93.43 119.13,93.43 121.9,96.2 121.9,99.27 122.33,99.7 122.33,100.05 122.06,100.31 120.68,100.31 120.48,100.51 120.48,100.81 120.85,101.17 121.95,101.17 122.15,101.37 122.15,102.07 121.85,102.37 120.95,102.37 120.67,102.66 120.67,103.03 120.85,103.22 122.34,103.22 122.6,103.48 122.6,103.75 122.33,104.03 121.94,104.03 121.49,104.48 121.49,104.65 121.17,104.97 121.17,106.42 121.46,106.71 121.46,107.58 120.77,108.28 120.77,111.27 121.16,111.66 121.16,112.7 121.01,112.85 120.82,112.85 120.56,112.58 120.02,112.58 118.97,111.53 118.64,111.53 118.33,111.84 118.33,112.2 119.12,112.99 119.12,113.69 119.47,114.04 120.23,114.04 120.57,113.69 120.88,113.69 121.03,113.84 121.03,115.62 120.4,116.25 120.4,116.67 120.94,117.22 120.94,118.68 120.68,118.94 119.79,118.94 119.41,119.31 119.41,119.68 119.67,119.95 121.42,119.95 121.61,120.14 121.61,120.5 121.35,120.77 120.73,120.77 120.47,121.03 120.47,121.27 120.74,121.53 121.42,121.53 121.61,121.73 121.61,123.03 120.81,123.83 120.35,123.83 120.09,123.57 120.09,122.41 119.9,122.22 119.55,122.22 119.34,122.43 119.34,123.12 119.01,123.44 119.01,124.57 119.36,124.92 119.64,124.92 119.82,125.1 119.82,125.55 119.03,126.34 118.77,126.34 118.06,127.05 118.06,127.81 116.87,129 115.83,129 110.59,134.24 100.65,134.24 100.3,133.89 100.3,133.47 100.44,133.33 101.03,133.33 101.17,133.19 101.17,132.77 101.03,132.63 100.44,132.63 100.3,132.49 100.3,132.07 100.44,131.93 101.03,131.93 101.17,131.79 101.17,131.37 101.03,131.23 100.44,131.23 100.3,131.09 100.3,130.57 100.59,130.28 101.27,130.28 101.8,129.74 101.8,128.28 102.32,127.77 103.19,127.77 103.32,127.64 103.32,127.36 103.16,127.2 101.9,127.2 101.79,127.08 101.79,126.71 101.93,126.57 103.36,126.57 103.49,126.44 103.49,126.02 103.34,125.87 101.93,125.87 101.79,125.73 101.79,125.5 101.98,125.31 103.32,125.31 103.43,125.19 103.43,124.96 103.26,124.78 102.34,124.78 102.18,124.63 102.18,123.74 102.41,123.51 102.41,121 102.25,120.84 101.92,120.84 101.79,120.97 101.79,123.37 101.58,123.58 101.33,123.58 101.19,123.44 101.19,122.58 100.73,122.12
RLD3_C3_72B_DQ5: length 144.1
  TOP w0.152: U1.G38 v2(101.24,80.84) ; U141.B9 v2(96.23,122.32)
  20_SIG7 w0.089: v2(101.24,80.84) 100.74,81.34 100.03,81.34 99.74,81.05 99.74,79.05 99.74,78.64 100.03,78.34 100.44,78.34 100.74,78.05 100.74,77.64 101.03,77.34 101.44,77.34 101.74,77.05 101.74,76.64 102.03,76.34 103.44,76.34 103.74,76.05 103.74,75.64 104.03,75.34 104.44,75.34 104.74,75.05 104.74,74.64 105.03,74.34 107.44,74.34 107.51,74.41 107.53,74.41 107.74,74.62 107.74,74.64 107.74,75.05 108.03,75.34 108.46,75.34 108.74,75.62 108.74,75.64 108.74,76.05 109.03,76.34 109.46,76.34 109.74,76.62 109.74,82.05 110.03,82.34 110.03,82.34 110.43,82.34 110.72,82.64 110.74,82.64 110.74,83.05 111.03,83.34 111.44,83.34 111.45,83.34 111.48,83.34 111.74,83.59 111.74,84.05 112.03,84.34 112.44,84.34 112.74,84.64 112.74,85.05 113.03,85.34 113.44,85.34 113.74,85.64 113.74,86.05 114.03,86.34 114.44,86.34 114.74,86.64 114.74,87.05 115.03,87.34 115.44,87.34 115.74,87.64 115.74,89.05 115.98,89.3 ; 94.64,123.47 94.64,122.97 94.78,122.82 95.43,122.82 95.93,122.32 v2(96.23,122.32)
  20_SIG7 w0.14: 115.98,89.3 117.59,90.9 120.5,90.9 125.2,95.6 125.2,108.08 124.46,108.81 124.46,109.81 124.26,110.02 124.26,124.13 122.77,125.62 122.77,128.17 118.33,132.61 117.28,132.61 111.43,138.46 110.19,138.46 109.81,138.84 108.84,138.84 108.7,138.98 108.7,139.36 108.56,139.5 108.14,139.5 108,139.36 108,138.98 107.86,138.84 107.44,138.84 107.3,138.98 107.3,139.36 107.16,139.5 106.74,139.5 106.6,139.36 106.6,138.98 106.46,138.84 106.04,138.84 105.9,138.98 105.9,139.36 105.77,139.5 105.35,139.5 105.21,139.36 105.21,138.98 105.07,138.84 104.65,138.84 104.51,138.98 104.51,139.36 104.37,139.5 103.95,139.5 103.81,139.36 103.81,138.98 103.67,138.84 103.25,138.84 103.11,138.98 103.11,139.36 102.97,139.5 102.55,139.5 102.41,139.36 102.41,138.98 102.27,138.84 101.72,138.84 101.58,138.7 101.58,138.29 101.41,138.12 101.02,138.12 100.88,138.26 100.88,138.7 100.74,138.84 100.32,138.84 100.18,138.7 100.18,138.13 100.04,137.99 99.62,137.99 99.48,138.13 99.48,138.7 99.34,138.84 95.64,138.84 94.53,137.73 94.53,132.91 91.64,130.03 91.64,128.41 92.5,127.55 93.73,127.55 96.1,125.18 96.1,124.47 95.9,124.27 94.95,124.27 94.64,123.96 94.64,123.47
RLD3_C3_72B_DQ6: length 143.3
  TOP w0.152: U1.K37 v2(104.24,79.84) ; U141.B11 v2(98.23,122.32)
  20_SIG7 w0.089: v2(98.23,122.32) 98.23,122.52 98.73,123.02 98.73,123.92 98.86,124.05 99.52,124.05 99.73,123.84 99.73,123.04 99.95,122.82 100.44,122.82 100.73,123.12 100.73,123.6 100.61,123.72 ; 113.15,89.44 112.74,89.02 112.74,87.64 112.44,87.34 112.03,87.34 111.74,87.05 111.74,86.6 111.48,86.34 111.03,86.34 110.74,86.05 110.74,85.64 110.44,85.34 109.96,85.34 109.74,85.12 109.74,84.64 109.44,84.34 108.98,84.34 108.74,84.1 108.74,83.64 108.44,83.34 108.01,83.34 107.74,83.07 107.74,82.64 107.44,82.34 107.03,82.34 106.74,82.05 106.74,77.52 106.56,77.34 105.03,77.34 104.74,77.64 104.74,78.05 104.44,78.34 104.03,78.34 103.74,78.64 103.74,79.63 103.95,79.84 v2(104.24,79.84)
  20_SIG7 w0.14: 113.15,89.44 116.44,92.72 119.42,92.72 123.27,96.57 123.27,100.25 123.04,100.48 122.75,100.48 122.61,100.62 122.61,101.01 122.86,101.26 123.04,101.26 123.27,101.49 123.27,101.98 122.83,102.41 122.83,102.71 123.32,103.19 123.32,104.24 122.99,104.57 122.33,104.57 121.81,105.08 121.81,106.15 122.17,106.51 122.17,111.52 121.7,111.99 121.7,118.75 122.25,119.3 122.25,123.31 120.51,125.06 120.51,125.88 120.28,126.1 120.19,126.1 119.48,126.82 119.48,127.05 119.79,127.36 119.99,127.36 120.28,127.07 120.45,127.07 120.62,127.24 120.62,127.58 119.94,128.27 119.66,128.27 119.11,127.72 118.84,127.72 118.61,127.95 118.61,128.33 118.98,128.7 118.98,129.03 118.75,129.25 118.42,129.25 118.08,128.91 117.73,128.91 117.5,129.14 117.5,129.44 117.87,129.81 117.87,130.14 117.39,130.61 115.19,130.61 111.02,134.77 100.31,134.77 98.16,136.92 96.42,136.92 96.24,136.74 96.24,135.28 96.38,135.14 96.71,135.14 96.93,135.37 96.93,136.09 97.08,136.24 97.83,136.24 98.14,135.93 98.14,135.74 97.48,135.07 97.48,134.88 97.77,134.58 97.97,134.58 98.63,135.24 98.83,135.24 99.48,134.6 99.48,134.08 99.34,133.94 97.25,133.94 97.11,133.8 97.11,133.39 97.25,133.25 99.34,133.25 99.48,133.11 99.48,132.69 99.34,132.55 97.25,132.55 97.11,132.41 97.11,131.99 97.25,131.85 99.34,131.85 99.48,131.71 99.48,131.29 99.34,131.15 97.25,131.15 97.11,131.01 97.11,130.59 97.25,130.45 99.23,130.45 99.36,130.31 99.36,128.34 99.98,127.72 100.78,127.72 101.17,127.33 101.17,125.19 100.47,124.49 100.47,123.87 100.61,123.72
RLD3_C3_72B_DQ7: length 143.8
  TOP w0.152: v2(103.24,79.84) U1.J37 ; U141.A8 v2(95.23,123.32)
  20_SIG7 w0.089: v2(103.24,79.84) 102.94,79.84 102.44,80.34 102.03,80.34 101.74,80.05 101.74,78.64 102.03,78.34 103.44,78.34 103.74,78.05 103.74,77.64 104.03,77.34 104.44,77.34 104.74,77.05 104.74,76.64 105.03,76.34 107.44,76.34 107.74,76.64 107.74,76.69 107.74,82.05 108.03,82.34 108.44,82.34 108.74,82.64 108.74,83.06 109.02,83.34 109.44,83.34 109.74,83.64 109.74,84.05 110.03,84.34 110.44,84.34 110.74,84.64 110.74,85.05 111.03,85.34 111.44,85.34 111.74,85.64 111.74,86.05 112.03,86.34 112.51,86.34 112.74,86.57 112.74,87.05 113.03,87.34 113.44,87.34 113.74,87.64 113.74,89.07 114.05,89.38 ; v2(95.23,123.32) 95.46,123.32 95.96,122.82 97.56,122.82 97.73,122.99 97.73,123.67
  20_SIG7 w0.14: 114.05,89.38 116.64,91.98 119.68,91.98 123.91,96.22 123.91,104.45 123.31,105.06 123.31,106.99 123.12,107.18 122.75,107.55 122.75,111.88 122.34,112.29 122.34,113.89 122.57,114.12 122.76,114.12 122.99,114.35 122.99,114.68 122.76,114.91 122.57,114.91 122.34,115.14 122.34,115.79 122.57,116.02 122.6,116.02 122.83,116.25 122.83,116.58 122.6,116.81 122.57,116.81 122.34,117.04 122.34,118.23 122.96,118.85 122.96,123.53 121.2,125.29 121.2,127.8 117.74,131.26 115.54,131.26 111.5,135.31 111.09,135.31 110.95,135.45 110.95,135.98 110.81,136.12 110.39,136.12 110.25,135.98 110.25,135.45 110.11,135.31 109.69,135.31 109.55,135.45 109.55,135.98 109.41,136.12 108.99,136.12 108.85,135.98 108.85,135.45 108.71,135.31 108.29,135.31 108.15,135.45 108.15,135.98 108.01,136.12 107.59,136.12 107.45,135.98 107.45,135.45 107.31,135.31 106.89,135.31 106.75,135.45 106.75,135.98 106.62,136.12 106.2,136.12 106.06,135.98 106.06,135.45 105.92,135.31 105.5,135.31 105.36,135.45 105.36,135.98 105.22,136.12 104.8,136.12 104.66,135.98 104.66,135.45 104.52,135.31 104.1,135.31 103.96,135.45 103.96,135.98 103.82,136.12 103.4,136.12 103.26,135.98 103.26,135.45 103.12,135.31 102.7,135.31 102.56,135.45 102.56,135.98 102.42,136.12 102,136.12 101.87,135.98 101.87,135.45 101.73,135.31 100.56,135.31 98.34,137.52 95.96,137.52 95.66,137.22 95.66,135.01 96.4,134.27 96.4,129.87 96.74,129.53 96.74,128.48 97.5,127.72 97.95,127.72 98.09,127.59 98.09,125.18 98.23,125.04 98.65,125.04 98.79,125.18 98.79,127.59 98.93,127.72 99.13,127.72 99.66,127.19 100.38,127.19 100.57,126.99 100.57,126.71 100.43,126.57 99.88,126.57 99.74,126.43 99.74,126.02 99.88,125.88 100.43,125.88 100.57,125.74 100.57,125.4 99.68,124.5 98.16,124.5 97.73,124.08 97.73,123.67
RLD3_C3_72B_DQ8: length 143.3
  TOP w0.152: U1.F38 v2(100.24,80.84) ; U141.A10 v2(97.23,123.32)
  20_SIG7 w0.089: 114.92,89.32 114.74,89.13 114.74,87.64 114.44,87.34 114.03,87.34 113.74,87.05 113.74,86.58 113.5,86.34 113.03,86.34 112.74,86.05 112.74,85.64 112.44,85.34 112.03,85.34 111.74,85.05 111.74,84.64 111.74,84.6 111.48,84.34 111.03,84.34 110.74,84.05 110.74,83.64 110.72,83.62 110.44,83.34 110.01,83.34 109.74,83.07 109.74,82.6 109.48,82.34 109.01,82.34 108.76,82.09 108.76,82.07 108.74,82.05 108.74,76.64 108.74,76.59 108.49,76.34 108.03,76.34 107.74,76.05 107.74,75.64 107.44,75.34 105.03,75.34 104.74,75.64 104.74,76.05 104.44,76.34 104.03,76.34 103.74,76.64 103.74,77.05 103.44,77.34 102.03,77.34 101.74,77.64 101.74,78.05 101.44,78.34 101.03,78.34 100.74,78.64 100.74,79.05 100.74,80.34 v2(100.24,80.84)
  20_SIG7 w0.14: v2(97.23,123.32) 97.23,124.82 94.23,127.81 94.23,130.18 95.1,131.05 95.1,137.44 95.93,138.27 98.49,138.27 100,136.75 102.08,136.75 102.22,136.89 102.22,137.77 102.36,137.91 102.78,137.91 102.92,137.77 102.92,136.89 103.06,136.75 103.48,136.75 103.62,136.89 103.62,137.77 103.76,137.91 104.17,137.91 104.31,137.77 104.31,136.89 104.45,136.75 104.87,136.75 105.01,136.89 105.01,137.77 105.15,137.91 105.57,137.91 105.71,137.77 105.71,136.89 105.85,136.75 106.27,136.75 106.41,136.89 106.41,137.77 106.55,137.91 106.97,137.91 107.11,137.77 107.11,136.89 107.25,136.75 107.67,136.75 107.81,136.89 107.81,137.77 107.95,137.91 108.37,137.91 108.51,137.77 108.51,136.89 108.65,136.75 109.06,136.75 109.2,136.89 109.2,137.77 109.34,137.91 109.76,137.91 109.9,137.77 109.9,136.89 110.04,136.75 110.95,136.75 111.79,135.91 111.99,135.91 112.5,136.42 112.7,136.42 113,136.13 113,135.93 112.49,135.42 112.49,135.22 112.78,134.92 112.98,134.92 113.49,135.44 113.69,135.44 113.98,135.14 113.98,134.94 113.47,134.43 113.47,134.23 113.77,133.94 113.97,133.94 114.48,134.45 114.68,134.45 114.97,134.15 114.97,133.95 114.46,133.44 114.46,133.25 114.76,132.95 114.96,132.95 115.47,133.46 115.66,133.46 115.96,133.16 115.96,132.97 115.45,132.45 115.45,132.26 115.8,131.91 118.04,131.91 122.02,127.92 122.02,125.4 123.66,123.77 123.66,111.43 123.39,111.16 123.39,107.82 123.72,107.49 124.01,107.49 124.56,106.95 124.56,95.89 119.98,91.32 116.92,91.32 114.92,89.32
RLD3_C3_72B_DQ9: length 147.7
  TOP w0.152: v2(103.24,77.84) U1.J35 ; U141.J10 v2(97.23,114.32)
  18_SIG6 w0.089: 87.67,124.6 87.67,124.49 87.94,124.22 89.52,124.22 89.91,123.83 90.45,123.83 90.73,123.54 90.73,123.12 91.02,122.83 92.49,122.83 92.73,122.58 92.73,122.09 92.99,121.82 93.44,121.82 94.45,120.81 95.43,120.81 95.72,120.51 95.72,116.57 96.73,115.57 96.73,114.82 v2(97.23,114.32) ; v2(103.24,77.84) U1.J35 106.44,77.34 106.74,77.64 106.74,78.06 107.02,78.34 107.44,78.34 107.74,78.64 107.74,79.06 108.02,79.34 108.44,79.34 108.74,79.64 108.74,79.66 108.74,80.05 109.03,80.34 109.07,80.34 109.07,80.34 109.44,80.34 109.74,80.64 109.74,81.05 110.03,81.34 110.03,81.34 110.41,81.34 110.44,81.34 110.74,81.64 110.74,81.67 110.74,81.67 110.74,82 110.74,82.05 111.03,82.34 111.08,82.34 111.08,82.34 112.47,82.34 112.74,82.61 112.74,83.04 112.74,83.05 113.03,83.34 113.04,83.34 113.47,83.34 113.74,83.61 113.74,90.11 114.13,90.51 114.13,90.96
  18_SIG6 w0.14: 114.13,90.96 114.13,101.88 114.76,102.51 115.02,102.51 115.67,103.16 115.67,106.7 115.4,106.97 115.4,110.25 116.5,111.34 116.5,112.01 115.72,112.79 115.72,123.02 106.76,131.98 106.76,132.95 103.1,136.61 101.67,136.61 100.96,137.31 100.96,137.87 98.21,140.62 96.13,140.62 93.77,142.99 77.13,142.99 75.64,141.5 75.64,136.84 80.77,131.7 81.89,131.7 83.08,130.51 83.08,128.27 84.32,127.03 85.54,127.03 87.67,124.9 87.67,124.6
RLD3_C3_72B_DQ10: length 148.1
  TOP w0.152: v2(102.24,77.84) U1.H35 ; U141.K11 v2(98.23,113.32)
  18_SIG6 w0.089: v2(98.23,113.32) 98.23,113.5 97.73,114 97.73,115.66 96.72,116.67 96.72,120.53 96.42,120.83 95.97,120.83 95.75,121.05 95.75,121.51 95.44,121.82 94.54,121.82 93.54,122.82 93,122.82 92.73,123.1 92.73,123.63 92.38,123.98 90.82,123.98 90.68,124.12 90.24,124.12 89.75,124.6 ; 113.05,90.96 113.05,89.88 112.74,89.57 112.74,83.63 112.45,83.34 111,83.34 110.74,83.08 110.74,82.64 110.44,82.34 110.34,82.34 110.34,82.34 110.03,82.34 109.74,82.05 109.74,81.64 109.44,81.34 109.37,81.34 109.37,81.34 109.09,81.34 109.09,81.34 109.03,81.34 108.74,81.05 108.74,80.64 108.44,80.34 108.03,80.34 107.74,80.05 107.74,80.02 107.74,80.02 107.74,79.64 107.44,79.34 107.03,79.34 106.74,79.05 106.74,78.7 106.74,78.7 106.74,78.64 106.44,78.34 102.95,78.34 102.45,77.84 v2(102.24,77.84)
  18_SIG6 w0.14: 89.75,124.6 86.77,127.58 85.6,127.58 84.79,128.4 84.79,130.07 81.94,132.92 80.29,132.92 79.02,134.19 79.02,136.32 79.16,136.46 80.28,136.46 80.42,136.6 80.42,136.88 80.28,137.02 79.16,137.02 79.02,137.16 79.02,137.44 79.16,137.58 80.28,137.58 80.42,137.72 80.42,138 80.28,138.14 79.16,138.14 79.02,138.28 79.02,141.55 79.93,142.47 93.55,142.47 95.92,140.1 96.98,140.1 101.59,135.49 102.51,135.49 114.31,123.69 114.31,113.13 115.08,112.37 115.08,110.92 114.76,110.61 114.76,105 114.12,104.36 114.12,102.67 113.79,102.34 113.05,102.34 112.82,102.11 112.82,101.32 112.96,101.18 113.37,101.18 113.51,101.04 113.51,100.63 113.37,100.49 112.96,100.49 112.82,100.35 112.82,99.93 112.96,99.79 113.37,99.79 113.51,99.65 113.51,99.23 113.37,99.09 112.96,99.09 112.82,98.95 112.82,97.63 113.05,97.4 113.05,90.96
RLD3_C3_72B_DQ11: length 146.6
  TOP w0.152: v2(103.24,78.84) U1.J36 ; U141.K13 v2(100.23,113.32)
  18_SIG6 w0.089: v2(103.24,78.84) 103.48,78.84 103.98,79.34 106.46,79.34 106.74,79.62 106.74,80.15 106.93,80.34 107.56,80.34 107.74,80.52 107.74,81.13 107.95,81.34 108.53,81.34 108.74,81.55 108.74,82.12 108.96,82.34 109.49,82.34 109.74,82.59 109.74,83.09 109.99,83.34 110.49,83.34 110.74,83.59 110.74,84.09 110.99,84.34 111.57,84.34 111.74,84.51 111.74,89.71 112.06,90.03 112.06,90.96 ; v2(100.23,113.32) 99.73,113.82 99.01,113.82 98.73,114.1 98.73,115.79 98.56,115.96 98.08,115.96 97.73,116.31 97.73,121.55 97.44,121.84 97.03,121.84 96.74,122.12 96.74,122.63 96.54,122.83 94.48,122.83 92.81,124.5 92.81,124.6
  18_SIG6 w0.14: 92.81,124.6 92.81,125.19 92.45,125.55 90.02,125.55 87.93,127.63 87.93,130.68 87.53,131.09 84.76,131.09 83.16,132.69 83.16,137.34 82.58,137.92 82.58,138.94 82.44,139.08 80.12,139.08 79.98,139.22 79.98,139.5 80.12,139.64 82.44,139.64 82.58,139.78 82.58,140.06 82.44,140.2 80.12,140.2 79.98,140.34 79.98,140.62 80.12,140.76 82.44,140.76 82.58,140.9 82.58,141.3 83.22,141.95 93.33,141.95 95.7,139.58 96.76,139.58 101.37,134.97 102.29,134.97 113.73,123.54 113.73,108.82 113.37,108.46 113.37,107.22 112.74,106.59 112.74,106.36 112.97,106.13 113.52,106.13 113.75,105.9 113.75,105.57 113.53,105.35 112.97,105.35 112.74,105.12 112.74,103.68 111.33,102.27 111.33,101.15 111.47,101.01 112.13,101.01 112.27,100.87 112.27,100.45 112.13,100.31 111.47,100.31 111.33,100.17 111.33,98.45 112.06,97.72 112.06,90.96
RLD3_C3_72B_DQ12: length 145.6
  TOP w0.152: U141.L8 v2(95.23,112.32) ; v2(102.24,79.84) U1.H37
  18_SIG6 w0.089: 109.29,90.96 109.29,90.85 108.81,90.37 108.81,90.17 108.96,90.02 109.3,90.02 109.45,89.87 109.45,89.65 109.3,89.5 108.9,89.5 108.74,89.34 108.74,84.54 108.54,84.34 107.98,84.34 107.74,84.1 107.74,83.59 107.49,83.34 106.98,83.34 106.74,83.1 106.74,82.64 106.44,82.34 103.99,82.34 103.74,82.09 103.74,81.55 103.53,81.34 102.97,81.34 102.74,81.11 102.74,80.56 102.52,80.34 101.91,80.34 101.74,80.17 101.74,79.77 101.83,79.68 102.07,79.68 v2(102.24,79.84) ; 98.07,124.6 98.4,124.6 99.05,123.96 100.33,123.96 101.17,123.12 101.17,122.02 100.73,121.57 100.73,116.56 100.69,116.52 100.69,116.12 100.99,115.82 101.48,115.82 102.11,115.19 102.11,112.5 101.43,111.82 101.01,111.82 100.73,111.54 100.73,111.09 100.46,110.82 99.95,110.82 99.71,111.06 99.71,111.52 99.42,111.82 98.24,111.82 95.73,111.82 v2(95.23,112.32)
  18_SIG6 w0.14: 109.29,90.96 109.29,96.55 107.94,97.9 107.94,98.16 107.51,98.6 107.04,98.6 106.44,99.19 106.44,101.97 107.14,102.67 107.93,102.67 108.24,102.98 108.64,102.98 109.48,103.81 109.48,107.75 111.8,110.07 111.8,119.32 111.8,123.26 103.78,131.27 102.86,131.27 96.12,138.02 93.45,138.02 93.31,138.16 93.31,138.77 93.17,138.91 92.89,138.91 92.75,138.77 92.75,138.16 92.61,138.02 92.33,138.02 92.2,138.16 92.2,138.77 92.06,138.91 91.78,138.91 91.64,138.77 91.64,138.16 91.5,138.02 90.93,138.02 90.4,137.49 90.4,137.25 90.26,137.11 88.84,137.11 88.7,136.97 88.7,136.69 88.84,136.55 90.26,136.55 90.4,136.41 90.4,136.13 90.26,135.99 88.84,135.99 88.7,135.85 88.7,135.57 88.84,135.43 90.26,135.43 90.4,135.29 90.4,135.01 90.26,134.87 88.84,134.87 88.7,134.73 88.7,134.45 88.84,134.31 90.26,134.31 90.4,134.17 90.4,133.89 90.26,133.75 88.84,133.75 88.7,133.61 88.7,133.34 88.84,133.2 90.26,133.2 90.4,133.06 90.4,132.08 90.79,131.69 93.46,131.69 93.65,131.5 93.65,131.27 93.32,130.94 91.8,130.94 91.67,130.81 91.67,128.32 92.46,127.53 94.59,127.53 97.52,124.6 98.07,124.6
RLD3_C3_72B_DQ13: length 147.4
  TOP w0.152: U141.L10 v2(97.23,112.32) ; v2(102.24,76.84) U1.H34
  18_SIG6 w0.089: v2(102.24,76.84) 102.24,77.08 101.74,77.58 101.74,78.05 102.03,78.34 102.44,78.34 102.74,78.64 102.74,79.07 103.01,79.34 103.44,79.34 103.74,79.64 103.74,80.09 103.99,80.34 106.48,80.34 106.74,80.6 106.74,81.11 106.97,81.34 107.49,81.34 107.74,81.59 107.74,82.14 107.94,82.34 108.46,82.34 108.74,82.62 108.74,83.11 108.97,83.34 109.5,83.34 109.74,83.58 109.74,84.11 109.97,84.34 110.5,84.34 110.74,84.58 110.74,89.46 110.81,89.53 110.81,90.96 ; v2(97.23,112.32) 97.73,112.82 100.44,112.82 100.73,113.12 100.73,114.55 100.45,114.83 100.04,114.83 99.72,115.14 99.72,115.54 98.73,116.54 98.73,122.6 98.51,122.82 97.02,122.82 96.73,123.11 96.73,123.54 96.44,123.82 95.51,123.82 94.95,124.38 93.81,124.38 93.59,124.6
  18_SIG6 w0.14: 93.59,124.6 93.33,124.86 93.33,125.41 92.66,126.07 90.56,126.07 88.57,128.07 88.57,131.67 87.48,132.77 85.65,132.77 84.58,133.83 84.58,136.83 83.21,138.2 83.21,139.78 83.54,140.11 84.5,140.11 84.64,140.25 84.64,140.88 84.78,141.02 85.06,141.02 85.2,140.88 85.2,140.25 85.34,140.11 85.62,140.11 85.76,140.25 85.76,140.88 85.9,141.02 86.18,141.02 86.32,140.88 86.32,140.25 86.46,140.11 86.74,140.11 86.88,140.25 86.88,140.88 87.02,141.02 87.29,141.02 87.43,140.88 87.43,140.25 87.57,140.11 87.85,140.11 87.99,140.25 87.99,140.88 88.13,141.02 88.41,141.02 88.55,140.88 88.55,140.25 88.69,140.11 88.97,140.11 89.11,140.25 89.11,140.88 89.25,141.02 89.53,141.02 89.67,140.88 89.67,140.25 89.81,140.11 90.09,140.11 90.23,140.25 90.23,140.88 90.37,141.02 90.65,141.02 90.79,140.88 90.79,140.25 90.93,140.11 91.21,140.11 91.35,140.25 91.35,140.88 91.49,141.02 91.77,141.02 91.9,140.88 91.9,140.25 92.04,140.11 92.32,140.11 92.46,140.25 92.46,140.88 92.6,141.02 92.88,141.02 93.02,140.88 93.02,140.25 93.16,140.11 93.93,140.11 94.98,139.06 96.55,139.06 101.31,134.3 102.23,134.3 113.09,123.44 113.09,118.79 113.09,109.43 112.08,108.42 112.08,103.75 110.81,102.49 110.81,90.96
RLD3_C3_72B_DQ14: length 146.6
  TOP w0.152: v2(101.24,77.84) U1.G35 ; U141.L12 v2(99.23,112.32)
  18_SIG6 w0.089: 96.76,124.6 97.35,124.02 98.26,124.02 98.74,123.53 98.74,123.12 99.05,122.82 100.57,122.82 100.79,122.6 100.79,122.16 100.45,121.82 99.94,121.82 99.73,121.61 99.73,116.46 100.28,115.91 100.39,115.91 100.73,115.57 100.73,115.09 100.99,114.83 101.44,114.83 101.73,114.54 101.73,113.14 101.41,112.82 101,112.82 100.74,112.56 100.74,112.13 100.44,111.83 99.91,111.83 99.41,112.32 v2(99.23,112.32) ; v2(101.24,77.84) 101.24,78.14 101.74,78.64 101.74,79.05 102.03,79.34 102.5,79.34 102.74,79.58 102.74,80.09 102.99,80.34 103.49,80.34 103.74,80.59 103.74,81.12 103.96,81.34 106.46,81.34 106.74,81.62 106.74,82.08 107,82.34 107.47,82.34 107.74,82.61 107.74,83.06 108.02,83.34 108.45,83.34 108.74,83.63 108.74,84.11 108.97,84.34 109.46,84.34 109.74,84.62 109.74,89.06 110.12,89.45 110.12,90.96
  18_SIG6 w0.14: 110.12,90.96 110.12,97.47 108.98,98.62 108.51,98.62 108.09,99.04 108.09,101.92 108.5,102.33 109,102.33 110.81,104.14 111.19,104.14 111.42,104.37 111.42,104.7 111.19,104.93 110.81,104.93 110.58,105.16 110.58,105.48 110.81,105.71 111.19,105.71 111.42,105.94 111.42,106.27 111.19,106.49 110.81,106.49 110.36,106.94 110.36,107.73 112.07,109.43 112.44,109.81 112.44,119.05 112.44,123.35 102.01,133.78 101.09,133.78 96.33,138.54 94.61,138.54 93.57,139.57 85.01,139.57 84.86,139.42 84.86,138.96 85.12,138.71 89.88,138.71 90.02,138.57 90.02,138.01 89.88,137.87 85.2,137.87 85.06,137.73 85.06,137.16 85.27,136.96 87.86,136.96 88.09,136.73 88.09,132.97 89.13,131.93 89.13,128.45 90.8,126.78 94.58,126.78 96.76,124.6
RLD3_C3_72B_DQ15: length 144.9
  TOP w0.152: U141.M9 v2(96.23,111.32) ; v2(100.24,77.84) U1.F35
  18_SIG6 w0.089: 107.95,90.96 107.95,90.67 106.74,89.45 106.74,84.6 106.48,84.34 103.93,84.34 103.74,84.15 103.74,83.59 103.49,83.34 102.99,83.34 102.74,83.09 102.74,82.58 102.5,82.34 102,82.34 101.74,82.08 101.74,81.6 101.48,81.34 100.97,81.34 100.74,81.11 100.74,80.57 100.51,80.34 99.99,80.34 99.74,80.09 99.74,78.58 100.24,78.08 v2(100.24,77.84) ; v2(96.23,111.32) 95.73,110.82 95.73,110.11 96.09,109.75 96.6,109.75 96.73,109.88 96.73,110.58 96.98,110.84 97.45,110.84 97.73,110.56 97.73,110.1 97.99,109.83 99.44,109.83 99.69,109.58 99.69,108.94 99.8,108.82 100.5,108.82 100.75,109.07 100.75,109.53 101.03,109.81 101.45,109.81 102.11,110.46 102.11,110.49
  18_SIG6 w0.14: 107.95,90.96 107.95,95.05 106.01,97 104.16,97 103.34,97.82 103.34,99.77 103.08,100.03 102.81,100.03 102.55,100.29 102.55,100.82 102.81,101.08 103.08,101.08 103.34,101.34 103.34,102.17 103.74,102.57 104.45,102.57 105.38,103.49 105.68,103.49 108.1,105.9 108.1,108.46 110.52,110.88 110.52,121.87 107.87,124.51 107.16,124.51 106.12,125.55 106.12,126.03 104.96,127.19 100.35,127.19 99.39,128.16 99.39,130.14 99.52,130.28 101.49,130.28 101.63,130.42 101.63,130.67 101.46,130.84 99.52,130.84 99.39,130.98 99.39,131.25 99.52,131.39 100.34,131.39 100.48,131.53 100.48,131.81 100.34,131.95 99.52,131.95 99.39,132.09 99.39,133.23 95.71,136.91 95.25,136.91 94.89,136.55 94.89,134.31 95.03,134.17 96.51,134.17 96.65,134.03 96.65,133.75 96.51,133.61 95.03,133.61 94.89,133.47 94.89,133.19 95.03,133.05 96.51,133.05 96.65,132.91 96.65,132.63 96.51,132.49 95.03,132.49 94.89,132.35 94.89,132.07 95.03,131.93 96.51,131.93 96.65,131.79 96.65,131.51 96.51,131.37 95.03,131.37 94.89,131.23 94.89,130.73 95.22,130.4 96.42,130.4 96.83,129.99 96.83,128.07 98.66,126.25 100.26,126.25 102,124.5 102,124.14 102.2,123.94 102.2,117.89 102.41,117.68 103.3,117.68 103.93,117.05 103.93,114.25 104.55,113.63 104.55,113.16 104.16,112.76 103.5,112.76 103.38,112.64 103.38,111.76 102.11,110.49
RLD3_C3_72B_DQ16: length 145
  TOP w0.152: v2(100.24,78.84) U1.F36 ; U141.M11 v2(98.23,111.32)
  18_SIG6 w0.089: 102.11,111.52 101.42,110.83 101,110.83 100.71,110.54 100.71,110.12 100.43,109.84 100.03,109.84 100.03,109.84 99.74,110.13 99.74,110.55 99.46,110.83 98.72,110.83 v2(98.23,111.32) ; 108.62,90.96 108.62,90.82 107.74,89.94 107.74,84.54 107.54,84.34 106.98,84.34 106.74,84.1 106.74,83.62 106.46,83.34 103.99,83.34 103.74,83.09 103.74,82.62 103.46,82.34 103.02,82.34 102.74,82.06 102.74,81.59 102.49,81.34 101.94,81.34 101.74,81.14 101.74,80.59 101.49,80.34 100.98,80.34 100.74,80.1 100.74,79.52 100.56,79.34 100.13,79.34 100.01,79.22 100.01,79.07 v2(100.24,78.84) ; 99.46,124.57 99.43,124.6
  18_SIG6 w0.14: 102.11,111.52 102.53,111.93 102.53,115.42 101.75,116.19 101.75,116.38 101.86,116.49 102.51,116.49 102.67,116.65 102.67,116.86 102.52,117.01 101.9,117.01 101.75,117.16 101.75,123.32 100.51,124.57 99.46,124.57 ; 99.43,124.6 96.09,127.94 94.92,127.94 94.18,128.68 94.18,132.1 94.04,132.24 91.07,132.24 90.93,132.38 90.93,132.65 91.07,132.79 94.04,132.79 94.18,132.93 94.18,133.21 94.04,133.35 91.07,133.35 90.93,133.49 90.93,133.77 91.07,133.91 94.04,133.91 94.18,134.05 94.18,134.26 93.9,134.54 92.89,134.54 92.75,134.68 92.75,135.94 92.88,136.07 93.27,136.07 93.47,136.27 93.47,136.63 93.22,136.88 92.33,136.88 92.19,136.74 92.19,134.68 92.05,134.54 91.77,134.54 91.41,134.9 91.41,137.29 91.63,137.5 95.9,137.5 102.64,130.75 103.56,130.75 111.16,123.15 111.16,110.55 108.8,108.19 108.8,105.46 108.03,104.69 108.03,103.81 107.53,103.31 106.83,103.31 105.87,102.35 105.22,102.35 104.9,102.02 104.9,101.33 104.74,101.18 104.13,101.18 103.89,100.94 103.89,100.2 104.08,100.01 104.61,100.01 104.82,99.8 104.82,99.14 105.09,98.87 105.09,98.55 104.75,98.21 104.75,97.88 104.98,97.65 105.31,97.65 105.65,97.99 105.97,97.99 107.17,96.79 107.4,96.79 107.67,97.07 107.86,97.07 108.21,96.72 108.21,96.49 107.96,96.25 107.96,96 108.62,95.34 108.62,90.96
RLD3_C3_72B_DQ17: length 144
  TOP w0.152: v2(101.24,78.84) U1.G36 ; U141.N8 v2(95.23,110.32)
  18_SIG6 w0.089: v2(95.23,110.32) 95.23,110.14 95.78,109.59 95.78,108.84 95.91,108.71 96.44,108.71 96.65,108.92 96.65,109.27 96.75,109.37 96.91,109.37 97.06,109.52 97.06,109.68 97.21,109.83 97.43,109.83 97.58,109.68 97.58,109.52 97.73,109.37 99.21,109.37 99.31,109.27 99.31,109.02 99.14,108.84 98.96,108.84 98.8,108.69 98.8,108.69 98.65,108.53 98.44,108.53 98.29,108.69 98.29,108.69 98.14,108.84 97.43,108.84 97.33,108.74 97.33,108.46 ; v2(101.24,78.84) 101.24,79.24 101.14,79.34 101.01,79.34 100.74,79.07 100.74,77.57 100.97,77.34 101.44,77.34 101.74,77.05 101.74,76.64 101.44,76.34 101.03,76.34 100.74,76.05 100.74,75.64 100.44,75.34 100.03,75.34 99.74,75.64 99.74,76.05 100.03,76.34 100.44,76.34 100.74,76.64 100.74,77.05 100.44,77.34 100.03,77.34 99.74,77.64 99.74,78.08 99.48,78.34 99.03,78.34 98.74,78.64 98.74,80.05 99.03,80.34 99.44,80.34 99.74,80.64 99.74,81.05 100.03,81.34 100.44,81.34 100.74,81.64 100.74,82.05 101.03,82.34 101.44,82.34 101.74,82.64 101.74,83.05 102.03,83.34 102.44,83.34 102.74,83.64 102.74,84.05 103.03,84.34 103.44,84.34 103.74,84.64 103.74,86.14 103.94,86.34 104.54,86.34 104.74,86.15 104.74,85.64 105.03,85.34 105.44,85.34 105.74,85.64 105.74,87.2 105.59,87.34 104.92,87.34 104.74,87.52 104.74,88.05 105.03,88.34 105.63,88.34 105.74,88.45 105.74,89.07 107.29,90.62 107.29,90.96
  18_SIG6 w0.14: 97.33,108.46 97.58,108.21 97.86,108.21 98.09,107.98 98.09,107.54 98.32,107.31 98.65,107.31 98.88,107.54 98.88,107.98 99.11,108.21 99.96,108.21 100.19,107.98 100.19,107.9 100.42,107.67 100.75,107.67 100.98,107.9 100.98,107.98 101.21,108.21 102.16,108.21 102.62,108.66 102.62,108.99 102.21,109.4 102.21,109.72 102.44,109.95 102.76,109.95 103.17,109.54 103.5,109.54 103.73,109.77 103.73,110.1 103.32,110.51 103.32,110.83 103.55,111.06 103.87,111.06 104.28,110.65 104.61,110.65 104.85,110.9 104.85,111.31 104.35,111.82 104.35,112.05 105.2,112.89 105.2,113.89 104.58,114.51 104.58,118.5 104.94,118.87 104.94,119.36 104.31,119.99 103.7,119.99 103.36,119.65 103.36,118.98 103.22,118.84 102.9,118.84 102.72,119.02 102.72,120.71 103.02,121.02 103.88,121.02 104.14,121.28 104.14,121.87 103.73,122.28 103.1,122.28 102.84,122.53 102.84,123.34 103.36,123.87 103.36,124.58 103.1,124.84 102.83,124.84 102.57,125.1 102.57,125.63 102.79,125.86 103.57,125.86 103.71,125.72 103.71,125.26 103.85,125.12 104.27,125.12 104.41,125.26 104.41,125.72 104.55,125.86 104.98,125.86 106.91,123.93 107.7,123.93 108.56,123.06 108.56,122.86 108.05,122.35 108.05,122.15 108.34,121.86 108.54,121.86 109.05,122.37 109.25,122.37 109.87,121.75 109.87,120.86 109.73,120.72 108.97,120.72 108.83,120.58 108.83,120.16 108.97,120.02 109.73,120.02 109.87,119.88 109.87,119.46 109.73,119.32 108.97,119.32 108.83,119.18 108.83,118.76 108.97,118.62 109.73,118.62 109.87,118.48 109.87,117.99 109.63,117.75 109.2,117.75 108.97,117.52 108.97,117.19 109.2,116.96 109.64,116.96 109.87,116.73 109.87,116.37 109.45,115.95 109.45,115.62 109.87,115.2 109.87,114.8 109.45,114.38 109.45,114.05 109.87,113.63 109.87,113.23 109.45,112.81 109.45,112.48 109.87,112.06 109.87,111.21 109.24,110.58 108.91,110.58 108.63,110.87 108.3,110.87 108.07,110.64 108.07,110.31 108.36,110.02 108.36,109.7 107.23,108.57 107.23,108.06 107,107.83 106.45,107.83 106.22,107.6 106.22,107.28 106.45,107.05 107,107.05 107.23,106.82 107.23,105.98 105.42,104.17 105.07,104.17 104.2,103.3 103.15,103.3 103,103.14 103,102.63 102.8,102.44 102.36,102.44 102.1,102.69 102.1,103.57 101.69,103.98 101.36,103.98 101.18,103.79 101.18,102.55 101.89,101.84 101.89,101.17 101.74,101.02 101.37,101.02 101.11,100.76 101.11,100.23 101.37,99.97 101.63,99.97 101.89,99.71 101.89,98.36 103.03,97.22 103.03,96.46 103.2,96.29 105.76,96.29 107.29,94.76 107.29,90.96
