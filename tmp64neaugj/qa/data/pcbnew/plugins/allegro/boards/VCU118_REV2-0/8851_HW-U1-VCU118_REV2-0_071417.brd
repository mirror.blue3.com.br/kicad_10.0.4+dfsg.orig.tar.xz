# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_M0: length 274.2
  TOP w0.152: SW16.4 28.65,122.17 v1(28.58,122.1) ; U1.U10 v2(111.24,51.84) ; R1083.1 120.18,30.68 120.18,27.75 120.1,27.67 v1(120.1,27.46)
  14_SIG4 w0.089: v1(7.02,131.43) 7.02,129.44 7.8,128.66 7.8,124.47 7.98,124.29 7.98,100.84 11.05,97.76 11.05,95.14 13.46,92.74 27.15,92.74 28.76,91.13 48.5,91.13 57.45,82.17 57.45,77.17 61.28,73.34 61.28,66 61.64,65.64 61.64,41.59 66.08,37.15 66.08,35.27 67,34.35 67,33.8 69.44,31.36 69.44,30.4 69.9,29.95 70.86,29.95 71.75,29.06 76.65,29.06 78.33,27.38 82.35,27.38 82.95,26.77 85.06,26.77 85.65,26.18 87.73,26.18 88.62,27.07 93.09,27.07 95.01,29 95.01,29.8 98.02,32.81 98.02,33.56 106.74,42.28 106.74,44 106.74,44 106.74,44.05 107.03,44.34 107.56,44.34 107.73,44.51 107.73,45.07 108.01,45.35 108.03,45.35 108.03,45.34 108.44,45.34 108.74,45.64 108.74,46.1 108.98,46.34 109.59,46.34 109.74,46.49 109.74,47.05 110.04,47.34 110.44,47.34 110.74,47.64 110.74,49.13 110.95,49.34 111.44,49.34 111.73,49.64 111.73,49.68 111.74,49.69 111.74,51.34 v2(111.24,51.84)
  16_SIG5 w0.089: v1(28.58,122.1) 28.58,121.9 27.23,120.56 17.86,120.56 17.23,121.19 17.23,121.2 16.73,121.7 15.98,121.7 15.7,121.98 15.7,127.32 15.11,127.91 15.11,128.73 14.86,128.97 14.53,128.97 14.31,129.19 14.31,129.54 14.08,129.77 13.71,129.77 13.5,129.98 13.5,130.39 13.34,130.56 9.35,130.56 8.48,131.43 v1(7.02,131.43)
  18_SIG6 w0.089: v1(120.1,27.46) 120.1,29 119.45,29.65 116.6,29.65 115.33,30.92 115.33,33.26 115,33.59 115,36.93 110.74,41.19 110.74,51.34 v2(111.24,51.84)
  BOTTOM w0.152: R133.1 v1(7.02,131.43)
FPGA_M0_R: length 4.3
  TOP w0.152: U111.M11 v5(12.3,131.77)
  BOTTOM w0.113: v5(12.3,131.77) 11.89,131.36 9.51,131.36 9.45,131.43
  BOTTOM w0.152: 9.45,131.43 R133.2
FPGA_M1: length 280.6
  TOP w0.152: v1(120.73,29.81) 120.73,30.04 121.09,30.41 121.75,30.41 122.04,30.69 R1084.1 ; v1(29.97,122.07) 29.92,122.12 SW16.3 ; v2(114.24,52.84) U1.Y11
  03_SIG1 w0.173: v1(6.91,132.57) 7.77,131.71 7.77,126.87 8.71,125.94 11.63,125.94 13.01,124.56 13.01,120.93 14.86,119.08 20.63,119.08 22.57,121.03 29.41,121.03 29.97,121.59 v1(29.97,122.07)
  14_SIG4 w0.089: v1(6.91,132.57) 6.41,132.07 6.41,128.28 7.1,127.58 7.1,126.9 6.33,126.12 6.33,101.78 10.55,97.56 10.55,94.93 13.25,92.23 26.94,92.23 28.55,90.62 45.83,90.62 51.93,84.52 54.25,84.52 56.9,81.87 56.9,76.67 60.57,73 60.57,67.72 60.23,67.38 60.23,66.34 61.17,65.4 61.17,41.35 65.58,36.94 65.58,35.06 66.5,34.14 66.5,33.64 68.97,31.17 68.97,30.21 69.71,29.48 70.66,29.48 71.55,28.59 76.46,28.59 78.14,26.91 82.15,26.91 82.76,26.3 84.87,26.3 85.46,25.71 87.93,25.71 88.82,26.6 93.98,26.6 95.88,28.51 95.88,29.13 99.26,32.51 99.26,33.43 107.74,41.9 107.74,44.19 107.89,44.34 109.44,44.34 109.74,44.64 109.74,46.03 109.74,46.03 109.74,46.05 110.04,46.34 110.44,46.34 110.73,46.64 110.73,47 110.74,47 110.74,47.05 111.03,47.34 111.55,47.34 111.74,47.53 111.74,49.2 111.88,49.34 112.46,49.34 112.74,49.62 112.74,52 112.74,52 112.74,52.05 113.03,52.34 113.73,52.34 113.94,52.55 113.95,52.55 v2(114.24,52.84)
  18_SIG6 w0.089: v1(120.73,29.81) 120.73,29.88 120.79,29.94 120.79,30.13 116.11,34.81 116.11,37.39 112.74,40.76 112.74,51.11 112.97,51.34 113.56,51.34 113.74,51.52 113.74,52.34 v2(114.24,52.84)
  BOTTOM w0.152: R135.1 v1(6.91,132.57)
FPGA_M1_R: length 4.5
  TOP w0.152: U111.M10 v5(12.3,132.57)
  BOTTOM w0.113: 9.08,132.95 9.1,132.97 11.9,132.97 v5(12.3,132.57)
  BOTTOM w0.152: 9.08,132.95 8.71,132.57 R135.2
FPGA_M2: length 285.7
  TOP w0.152: v2(113.24,52.84) U1.W11 ; SW16.2 31.19,122.43 v1(30.86,122.1) ; v1(123.13,29.65) 123.13,30.96 R1085.1
  03_SIG1 w0.173: v1(30.86,122.1) 30.31,122.65 29.49,122.65 29.21,122.37 29.21,121.82 28.97,121.58 22.34,121.58 20.4,119.63 15.8,119.63 14.81,120.62 14.17,120.62 13.56,121.23 13.56,124.82 13.26,125.12 13.23,125.12 11.86,126.49 8.94,126.49 8.56,126.87 8.56,128.23 9.25,128.91 9.25,130.58 8.43,131.39 8.43,133.48 v1(7.04,134.88)
  14_SIG4 w0.089: v1(7.04,134.88) 7.79,134.12 7.79,129.38 8.31,128.86 8.31,124.77 9.95,123.13 9.95,116.48 8.94,115.47 8.94,100.81 11.56,98.2 11.56,95.35 13.67,93.24 27.36,93.24 28.97,91.63 49.51,91.63 58.88,82.27 58.88,76.46 61.79,73.55 61.79,68.03 62.43,67.39 62.43,66.44 62.32,66.33 62.32,47.29 62.11,47.08 62.11,41.84 66.59,37.36 66.59,35.48 67.51,34.56 67.51,33.96 71.94,29.53 76.85,29.53 78.53,27.85 82.54,27.85 83.15,27.24 85.26,27.24 85.84,26.65 87.54,26.65 88.43,27.54 91.46,27.54 96.64,32.73 96.64,33.27 105.74,42.37 105.74,44.14 105.94,44.34 106.5,44.34 106.73,44.58 106.73,45.11 106.96,45.34 107.44,45.34 107.74,45.64 107.74,46.05 108.03,46.34 108.24,46.34 108.24,46.34 108.44,46.34 108.73,46.64 108.73,47.01 108.74,47.02 108.74,47.05 109.03,47.34 109.52,47.34 109.73,47.56 109.73,49.08 110,49.34 110.46,49.34 110.74,49.62 110.74,52.05 111.03,52.34 112.48,52.34 112.98,52.84 v2(113.24,52.84)
  18_SIG6 w0.089: v1(123.13,29.65) 122.76,29.28 120.49,29.28 119.5,30.27 118.45,30.27 117.12,31.6 117.12,32.94 115.55,34.51 115.55,37.16 111.74,40.97 111.74,51.15 111.93,51.34 112.45,51.34 112.74,51.63 112.74,52.34 v2(113.24,52.84)
  BOTTOM w0.152: R83.1 v1(7.04,134.88)
FPGA_M2_R: length 1.7
  TOP w0.152: U111.R8 v5(9.9,134.97)
  BOTTOM w0.152: R83.2 9.81,134.88 v5(9.9,134.97)
FPGA_PROG_B: length 395.1
  TOP w0.381: v1(94.01,136.04) 91.85,136.04 SW4.1 ; U1.AH11 v2(123.24,52.84) ; U111.N14 v5(11.5,129.37) ; SW4.2 101.02,136.42 101.32,136.73 101.32,137.37 v1(101.55,137.6)
  07_SIG3 w0.254: v2(123.24,52.84) 122.73,52.33 112.96,52.33 112.7,52.07 112.7,51.62 112.47,51.39 112.06,51.39 111.75,51.07 111.75,50.61 111.48,50.33 111,50.33 110.73,50.06 110.73,49.57 110.52,49.36 109.96,49.36 109.72,49.11 109.72,48.64 109.39,48.31 109.04,48.31 108.77,48.04 108.77,47.62 108.46,47.31 108.04,47.31 107.77,47.04 107.77,46.69 107.39,46.31 107.04,46.31 106.77,46.04 106.77,45.6 106.48,45.31 106.04,45.31 105.77,45.04 105.77,44.69 105.45,44.37 104.02,44.37 103.71,44.06 103.71,42.24
  07_SIG3 w0.381: v1(62.85,44.62) 62.85,42.56 67.67,37.74 67.67,33.05 69.09,31.62 76.66,31.62 77.82,32.79 87.37,32.79 87.59,32.56 90.07,32.56 93.42,35.92 95.53,35.92 97.95,38.34 99.86,38.34 103.71,42.19 103.71,42.24 ; v1(67.18,138.03) 67.18,141.02 64.72,143.48 62.68,143.48 59.98,146.17 59.24,146.17 58.63,146.79 58.63,148.96 57.04,150.56 57.04,151.22 53.85,154.4 53.85,155.73 50.92,158.66 48.44,158.66 43.98,163.12 26.9,163.12 18.62,171.39 4.18,171.39 v1(2.29,169.49)
  16_SIG5 w0.127: v5(11.5,129.37) 11.1,128.97 9.3,128.97 9,128.67 8.47,128.67 8.02,129.12 8.02,129.19 8.5,129.67 9.23,129.67 9.33,129.77 11.11,129.77 v5(11.5,129.37) ; v5(11.5,129.37) 11.9,129.77 12.47,129.77 12.7,129.54 12.7,129.22 13.06,128.86 13.06,128.63 12.82,128.63 12.48,128.96 11.91,128.96 v5(11.5,129.37)
  16_SIG5 w0.381: v1(2.29,169.49) 2.29,157.68 8.57,151.4 8.57,144.76 5.23,141.43 5.23,130.88 6.91,129.19 8.02,129.19 ; 13.06,128.63 14.62,127.06 14.62,122.85 15.09,122.38 15.09,121.08 16.61,119.56 19.99,119.56 20.68,118.87 20.68,117.32 19.69,116.33 19.69,108.13 18.92,107.37 18.92,95.48 22.43,91.97 32.16,91.97 33.3,93.12 v1(39.9,93.12)
  18_SIG6 w0.381: v1(62.85,44.62) 62.29,44.62 61.49,45.42 61.49,61.75 56.62,66.62 56.62,67.41 51.26,72.77 46.18,72.77 44.45,74.5 42.01,74.5 41.2,75.31 41.2,81.46 40.74,81.91 40.74,92.28 v1(39.9,93.12)
  BOTTOM w0.381: R53.2 101.97,137.17 v1(101.55,137.6) 100.72,138.43 96.4,138.43 v1(94.01,136.04) 90.33,139.73 68.87,139.73 v1(67.18,138.03) ; R140.1 2.54,169.24 v1(2.29,169.49)
FPGA_SYSMON_VCC: length 2.5
  TOP w0.381: v2(116.24,59.84) U1.AB18
  BOTTOM w0.254: v2(116.24,59.84) 116.51,59.84 116.99,59.36 C2.1
  vias: v1(125.09,29.52) v1(125.48,30.27)
FPGA_TDO_FMC_TDI: length 244.2
  TOP w0.152: U19.3 52.99,146.44 52.71,146.72 52.71,147.99 52.29,148.4 50.6,148.4 v1(49.85,149.15) ; v2(119.24,54.84) 118.74,55.34 U1.AD13
  07_SIG3 w0.173: v1(49.85,149.15) 50.52,148.49 52.01,148.49 52.76,147.74 52.76,144.8 53.06,144.5 54.07,144.5 54.98,143.59 54.98,129.35 55.28,129.06 55.28,123.6 54.13,122.45 54.13,91.59 47.03,84.49 47.03,83.79 44.1,80.86 42.51,80.86 39.88,78.23 36.37,78.23 31.34,73.2 31.34,68.88 36.07,64.16 36.07,54.13 45.01,45.19 45.01,43.28 47.85,40.44 51.23,40.44 51.87,39.8 v1(53.77,39.8)
  14_SIG4 w0.089: v2(119.24,54.84) 118.74,54.84 117.95,54.05 117.95,52.29 117.76,52.1 117.76,49.62 117.48,49.34 117,49.34 116.74,49.08 116.74,47.48 116.6,47.34 116.03,47.34 115.89,47.2 115.89,47.2 115.73,47.05 115.73,46.64 115.44,46.34 115.01,46.34 114.74,46.08 114.74,44.57 114.51,44.34 113.99,44.34 113.74,44.1 113.74,40.36 107.15,33.77 107.15,30.95 105.78,29.57 105.78,28.88 105.08,28.19 102.42,28.19 97.48,23.24 94.84,23.24 94.13,23.95 89.15,23.95 87.81,22.61 82.33,22.61 79.79,25.15 71.88,25.15 71.3,25.73 71.3,26.85 70.13,28.02 69.17,28.02 67.56,29.63 67.56,30.58 65.02,33.13 65.02,33.53 63.96,34.58 63.96,36.35 61.18,39.13 54.45,39.13 v1(53.77,39.8)
FPGA_TDO_FMC_TDI_BUF: length 27.8
  TOP w0.152: U19.21 60.08,145.79 59.16,146.71 59.16,148.16 59.51,148.51 60.48,148.51 61.16,149.2 61.16,150.9 62.2,151.94 v1(63.27,151.94) ; J22.D30 v1(70.1,162.05)
  BOTTOM w0.152: v1(63.27,151.94) 63.38,152.05 U26.1 65.04,152.05 65.68,151.41 67.67,151.41 69.49,153.24 69.49,161.44 v1(70.1,162.05)
FPGA_VBATT: length 58.7
  TOP w0.381: v1(169.5,24.92) 169.98,24.43 B1.1 ; U1.AT11 v2(131.24,52.84)
  18_SIG6 w0.254: 141.81,47.01 141.46,47.36 133.97,47.36 133.74,47.59 133.74,48.04 133.43,48.34 132.96,48.34 132.74,48.56 132.74,49.09 132.48,49.34 132.02,49.34 131.74,49.62 131.74,50.05 131.45,50.34 131.05,50.34 130.74,50.66 130.74,52.34 v2(131.24,52.84)
  18_SIG6 w0.508: 141.81,47.01 154.51,34.32 161.16,34.32 161.98,33.5 161.98,30.02 162.69,29.31 165.11,29.31 v1(169.5,24.92)
  BOTTOM w0.381: v1(169.5,24.92) 169.73,24.68 R115.2
GPIO_DIP_SW1: length 118.6
  TOP w0.152: v2(96.24,58.84) 96.74,59.34 U1.B17 ; SW12.1 v1(63.12,68.46)
  14_SIG4 w0.089: v2(96.24,58.84) 96.74,58.34 106.44,58.34 106.74,58.05 106.74,57.64 107.03,57.34 107.44,57.34 107.74,57.05 107.74,56.64 108.03,56.34 108.44,56.34 108.74,56.05 108.74,55.64 109.03,55.34 109.44,55.34 109.74,55.05 109.74,49.5 109.57,49.34 109.12,49.34 109.03,49.34 108.74,49.05 108.74,47.59 108.49,47.34 108.03,47.34 108.01,47.32 108,47.32 107.75,47.07 107.75,47.06 107.74,47.05 107.74,46.63 107.45,46.34 106.97,46.34 106.74,46.11 106.74,45.58 106.51,45.34 106.03,45.34 105.74,45.05 105.74,45.01 105.73,45 105.73,44.6 105.48,44.34 105.03,44.34 104.74,44.05 104.74,42.6 95.33,33.19 95.33,32.53 91.31,28.52 81.58,28.52 81.38,28.32 78.72,28.32 77.04,30 72.13,30 68.02,34.12 68.02,34.77 67.09,35.69 67.09,37.57 64.06,40.6 64.06,43.58 64.87,44.39 64.87,45.53 62.86,47.53 62.86,63.89 64.39,65.42 64.39,67.19 v1(63.12,68.46)
  BOTTOM w0.152: R51.1 62.86,68.71 v1(63.12,68.46)
GPIO_DIP_SW2: length 114.3
  TOP w0.152: SW12.2 v1(63.12,69.73) ; U1.G16 101.74,58.34 v2(101.24,57.84)
  14_SIG4 w0.089: v1(63.12,69.73) 62.48,70.36 62.48,71.3 62.87,71.68 63.63,71.68 66.17,69.14 66.17,63.8 64.2,61.83 64.2,56 64.64,55.56 64.64,47.09 65.81,45.92 65.81,43.95 65,43.14 65,41.09 66.87,39.22 68.58,39.22 69.55,38.25 69.55,34.67 69.94,34.29 70.47,34.29 73.82,30.94 77.43,30.94 79.11,29.26 80.95,29.26 81.15,29.46 89.84,29.46 101.23,40.84 101.23,40.84 102.74,42.35 102.74,44.05 103.03,44.34 103.52,44.34 103.74,44.56 103.74,45.14 103.94,45.34 104.47,45.34 104.73,45.61 104.73,47.15 104.92,47.34 106.55,47.34 106.78,47.57 106.78,49.1 106.96,49.28 107.48,49.28 107.74,49.53 107.74,54.05 107.44,54.34 107.03,54.34 106.74,54.64 106.74,55.05 106.44,55.34 106.03,55.34 105.74,55.64 105.74,56.05 105.44,56.34 104.03,56.34 103.74,56.64 103.74,57.05 103.44,57.34 101.74,57.34 v2(101.24,57.84)
  BOTTOM w0.152: R50.1 62.86,69.98 v1(63.12,69.73)
GPIO_DIP_SW3: length 111.1
  TOP w0.152: U1.J16 103.74,58.34 v2(103.24,57.84) ; SW12.3 v1(63.12,71)
  14_SIG4 w0.089: v1(63.12,71) 65.05,69.06 65.05,64.45 63.37,62.77 63.37,47.69 65.34,45.72 65.34,44.19 64.53,43.38 64.53,40.85 66.77,38.61 68.2,38.61 68.75,38.06 68.75,34.6 69.53,33.82 70.28,33.82 73.63,30.47 77.24,30.47 78.92,28.79 81.19,28.79 81.39,28.99 90.1,28.99 103.74,42.62 103.74,44.12 103.96,44.34 104.52,44.34 104.73,44.56 104.73,45.12 104.96,45.34 105.54,45.34 105.74,45.54 105.74,45.64 105.74,46.05 106.03,46.34 106.57,46.34 106.73,46.51 106.73,47.05 107.01,47.32 107.01,47.32 107.03,47.34 107.55,47.34 107.74,47.52 107.74,49.06 108.03,49.35 108.51,49.35 108.74,49.58 108.74,55.05 108.44,55.34 108.03,55.34 107.74,55.64 107.74,56.05 107.44,56.34 107.03,56.34 106.74,56.64 106.74,57.05 106.44,57.34 103.94,57.34 103.44,57.84 v2(103.24,57.84)
  BOTTOM w0.152: R41.1 62.86,71.25 v1(63.12,71)
GPIO_DIP_SW4: length 51.5
  TOP w0.152: U1.D21 v2(98.24,62.84) ; SW12.4 v1(63.12,72.27)
  BOTTOM w0.152: v2(98.24,62.84) 97.75,63.33 93.33,63.33 90.05,60.06 85.09,60.06 83.56,61.59 83.56,66.25 83.29,66.51 82.77,66.51 81.69,67.6 81.69,70.57 81.34,70.93 68.27,70.93 65.05,74.14 63.88,74.14 63.12,73.38 v1(63.12,72.27) 62.99,72.4 R40.1
GPIO_LED0: length 156.7
  TOP w0.14: R124.1 218.3,158.52 218.35,158.47 v1(218.35,158.33)
  TOP w0.152: U1.AT32 v2(131.24,74.84)
  07_SIG3 w0.173: v1(218.35,158.33) 217.72,158.96 216.24,158.96 215.91,158.62 215.91,157.9 214.8,156.79 214.39,156.79 213.54,155.94 211.75,155.94 211.3,155.49 211.3,154.7 211.81,154.18 211.81,147.36 211.22,146.77 211.22,142.01 207.52,138.31 207.52,136.47 208.84,135.15 208.84,134.27 206.1,131.54 206.1,123.79 188.51,106.19 185.88,106.19 183.03,103.35 167.27,103.35 166.84,103.77 148.46,103.77 147.56,104.67 144.93,104.67 144.26,104 139.18,104 136.63,101.45 136.63,100.37 135.28,99.02 135.28,98.02 134.49,97.23 133.15,97.23 130.73,94.82 130.73,75.35 v2(131.24,74.84)
  BOTTOM w0.152: v1(218.35,158.33) 218.35,158.46 218.28,158.53 Q16.1
GPIO_LED1: length 142.8
  TOP w0.14: R123.1 216.26,158.52 216.46,158.33 v1(216.46,158.32)
  TOP w0.152: U1.AV34 v2(133.24,76.84)
  07_SIG3 w0.173: v1(216.46,158.32) 216.46,157.67 215.03,156.24 214.62,156.24 212.37,153.99 212.37,147.13 211.77,146.54 211.77,141.78 208.07,138.08 208.07,136.7 209.39,135.38 209.39,133.92 206.73,131.26 206.73,123.15 187.86,104.28 186.17,104.28 184.69,102.79 174.68,102.79 172.11,100.22 172.11,98.28 169.22,95.38 v1(169.22,94.71)
  20_SIG7 w0.089: v1(169.22,94.71) 168.33,93.82 168.33,87.4 167.44,86.51 156.18,86.51 v1(153.16,83.49)
  BOTTOM w0.152: v1(153.16,83.49) 153.16,82.9 152.29,82.03 148.43,82.03 145.74,79.34 137,79.34 136.74,79.08 136.74,78.64 136.44,78.34 135.95,78.34 135.74,78.13 135.74,76.64 135.44,76.34 133.72,76.34 133.24,76.82 v2(133.24,76.84) ; Q15.1 216.24,158.53 v1(216.46,158.32)
GPIO_LED2: length 182.5
  TOP w0.14: v1(214.56,158.32) 214.56,158.33 214.36,158.52 R122.1
  TOP w0.152: U1.AY30 v2(135.24,72.84)
  03_SIG1 w0.173: v1(214.56,158.32) 214.56,158.12 215.22,157.45 215.22,157.12 214.85,156.75 214.24,156.75 212.34,154.86 212.34,154.08 211.46,153.19 210.7,153.19 210.02,152.52 210.02,150.98 207.62,148.57 207.62,142.46 204.16,139.01 202.51,139.01 201.88,138.38 201.88,134.67 200.84,133.63 194.08,133.63 191.57,136.14 191.57,136.42 185.9,142.09 177.39,142.09 174.9,139.6 174.35,139.6 172.3,137.55 172.3,130.58 169.69,127.97 169.69,121.04 168.01,119.36 168.01,117.16 164.61,113.76 161.78,113.76 157.64,109.63 154.94,109.63 154.02,108.7 148.53,108.7 147.66,107.84 144.74,107.84 142.73,105.83 142.73,104.41 143.55,103.59 143.55,101.25 142.51,100.21 142.51,99.02 143.55,97.98 143.55,86.43 141.47,84.36 141.46,84.36 141.44,84.34 141,84.34 140.74,84.08 140.74,83.58 140.5,83.34 132.03,83.34 131.99,83.3 131.98,83.3 131.74,83.06 131.74,83.05 131.74,82.6 131.48,82.34 131.03,82.34 130.74,82.05 130.74,81.64 130.72,81.62 130.72,81.61 130.46,81.35 130.45,81.35 130.44,81.34 130.03,81.34 129.74,81.05 129.74,79.58 129.5,79.34 128.99,79.34 128.74,79.09 128.74,78.56 128.52,78.34 127.99,78.34 127.74,78.09 127.74,77.63 127.45,77.34 126.94,77.34 126.74,77.14 126.74,76.58 126.5,76.34 126.03,76.34 125.74,76.05 125.74,73.64 125.77,73.6 125.77,73.6 126.03,73.34 126.44,73.34 126.49,73.34 126.74,73.1 126.74,72.56 126.96,72.34 127.44,72.34 127.45,72.34 127.74,72.05 127.74,71.53 127.92,71.34 128.54,71.34 128.74,71.14 128.74,70.64 129.03,70.34 131.44,70.34 131.74,70.64 131.74,71.09 131.99,71.34 133.6,71.34 133.74,71.48 133.74,72.18 133.9,72.34 134.73,72.34 134.73,72.34 v2(135.24,72.84)
  BOTTOM w0.152: Q14.1 214.34,158.53 v1(214.56,158.32)
GPIO_LED3: length 158.6
  TOP w0.14: v1(212.65,158.32) 212.65,158.33 212.45,158.52 R121.1
  TOP w0.152: U1.BB32 v2(137.24,74.84)
  05_SIG2 w0.173: v2(145.31,92.56) 145.31,96.74 146.14,97.56 146.14,99.79 147.82,101.46 147.82,102.47 148.87,103.52 148.87,104.88 149.56,105.56 149.56,106.05 150.11,106.6 156.7,106.6 157.53,107.44 158.81,107.44 159.72,106.52 167.72,106.52 174.59,113.39 175.84,113.39 184.64,122.19 189.55,122.19 198.78,131.42 201.47,131.42 203.05,132.99 203.05,138.42 207.35,142.72 207.35,148.16 206.58,148.93 206.58,149.94 206.19,150.33 206.19,151.34 205.47,152.06 204.87,152.06 204.44,152.49 204.44,153.92 204.95,154.43 206.53,154.43 207.03,154.94 207.03,155.24 207.45,155.66 207.53,155.66 208.95,157.07 209.84,157.07 210.08,156.83 211.17,156.83 v1(212.65,158.32)
  BOTTOM w0.152: v2(137.24,74.84) 137.24,74.54 136.74,74.04 136.74,73.52 136.56,73.34 133.05,73.34 132.74,73.65 132.74,74.04 132.44,74.34 131.97,74.34 131.74,74.58 131.74,75.04 131.44,75.34 130.98,75.34 130.73,75.59 130.73,76.05 130.44,76.34 129.04,76.34 128.74,76.65 128.74,84.01 129.07,84.34 129.44,84.34 129.74,84.64 129.74,84.98 130.1,85.34 130.44,85.34 130.74,85.64 130.74,86.11 130.97,86.34 132.44,86.34 132.74,86.64 132.74,87.02 133.07,87.35 133.5,87.35 133.73,87.58 133.73,89.23 137.06,92.56 v2(145.31,92.56) ; Q13.1 212.43,158.53 v1(212.65,158.32)
GPIO_LED4: length 158.8
  TOP w0.14: R120.1 210.42,158.52 210.62,158.33 v1(210.62,158.32)
  TOP w0.152: v2(141.24,74.84) U1.BF32
  05_SIG2 w0.173: v1(210.62,158.32) 210.28,158.32 209.59,157.62 208.72,157.62 207.67,156.58 203.99,156.58 203.52,156.1 201.83,156.1 201.48,155.75 199.76,155.75 199.31,156.2 193,156.2 192.42,155.61 185.18,155.61 180.87,151.3 175.45,151.3 169.92,145.77 169.92,141.47 168.79,140.34 168.79,132.23 169.11,131.9 173.5,127.51 173.5,124.88 170.56,121.93 170.56,113.7 166.82,109.96 162,109.96 161.67,110.3 155.84,110.3 155.26,109.71 154.34,109.71 153.84,110.21 152.42,110.21 151.93,109.71 148.8,109.71 146.96,107.87 144.91,107.87 142.6,105.56 142.6,103.18 143.99,101.78 143.99,88.67 141.66,86.34 139.98,86.34 139.77,86.13 139.77,85.62 139.51,85.35 138.99,85.35 138.74,85.1 138.74,84.61 138.47,84.34 138.03,84.34 137.74,84.05 137.74,83.63 137.45,83.34 136.95,83.34 136.74,83.13 136.74,82.56 136.52,82.34 135.98,82.34 135.74,82.1 135.74,81.57 135.53,81.36 134.97,81.36 134.76,81.16 134.76,79.58 135.02,79.32 136.49,79.32 136.75,79.06 136.75,78.61 137.02,78.34 137.5,78.34 137.72,78.12 137.72,77.66 138.05,77.33 138.47,77.33 138.72,77.09 138.72,76.63 139,76.35 139.44,76.35 139.72,76.07 139.72,75.63 139.99,75.35 140.4,75.35 140.91,74.84 v2(141.24,74.84)
  BOTTOM w0.152: v1(210.62,158.32) 210.4,158.53 Q12.1
GPIO_LED5: length 150.8
  TOP w0.14: v1(208.71,158.32) 208.71,158.33 208.52,158.52 R119.1
  TOP w0.152: U1.AU37 v2(132.24,79.84)
  05_SIG2 w0.173: v2(132.24,79.84) 132.43,79.84 132.93,80.34 133.47,80.34 133.75,80.62 133.75,81.12 133.98,81.35 134.52,81.35 134.75,81.59 134.75,82.13 134.99,82.37 135.46,82.37 135.76,82.67 135.76,83.12 135.99,83.36 136.49,83.36 136.74,83.61 136.74,84.13 136.96,84.34 137.47,84.34 137.74,84.61 137.74,85.13 137.97,85.36 138.44,85.36 138.71,85.64 138.71,86.14 139,86.43 139.41,86.43 139.65,86.67 139.65,87.06 139.93,87.34 140.89,87.34 141.87,88.32 141.87,100.16 141.19,100.84 141.19,104.22 142.04,105.07 142.04,105.82 143.68,107.46 143.68,109.67 145.42,111.41 146.59,111.41 147.19,112.01 152.82,112.01 154.57,110.27 155.03,110.27 155.61,110.85 161.9,110.85 162.23,110.52 166.51,110.52 169.92,113.93 169.92,122.28 172.95,125.32 172.95,127.28 168.23,132 168.23,140.57 169.37,141.71 169.37,146.08 175.17,151.88 180.67,151.88 184.95,156.17 192.19,156.17 193.22,157.2 194.94,157.2 196.51,158.76 206.64,158.76 206.89,159.01 208.02,159.01 v1(208.71,158.32)
  BOTTOM w0.152: v1(208.71,158.32) 208.5,158.53 Q11.1
GPIO_LED6: length 142.5
  TOP w0.14: v1(204.65,155.14) 204.65,155.15 204.45,155.35 R118.1
  TOP w0.152: U1.AV36 v2(133.24,78.84)
  07_SIG3 w0.173: v1(207.67,128.88) 207.67,128.88 207.67,122.21 187.63,102.17 186.2,102.17 185.12,101.1 174.04,101.1 172.96,100.02 172.96,96.31 v1(170.45,93.8)
  14_SIG4 w0.089: v1(207.67,128.88) 207.67,131.11 205.41,133.37 205.41,135.39 207.52,137.49 207.52,147.98 206.53,148.97 206.53,149.96 206.17,150.32 206.17,151.36 204.65,152.88 v1(204.65,155.14)
  20_SIG7 w0.089: v1(153.17,82.03) 157.1,85.95 167.68,85.95 168.92,87.19 168.92,92.27 v1(170.45,93.8)
  BOTTOM w0.152: Q10.1 204.43,155.36 v1(204.65,155.14) ; v1(153.17,82.03) 152.8,81.66 148.99,81.66 145.68,78.34 137.04,78.34 136.74,78.04 136.74,76.64 136.44,76.34 136.04,76.34 135.74,76.04 135.74,75.59 135.49,75.34 133.04,75.34 132.72,75.67 132.72,77.98 133.24,78.5 v2(133.24,78.84)
GPIO_LED7: length 140
  TOP w0.14: R117.1 202.29,155.86 202.6,155.55 v1(202.82,155.55)
  TOP w0.152: U1.BA37 v2(136.24,79.84)
  05_SIG2 w0.173: v1(202.82,155.55) 202.06,155.55 201.66,155.15 199.57,155.15 199.17,155.55 193.56,155.55 192.29,154.28 184.63,154.28 181.1,150.74 175.68,150.74 170.48,145.54 170.48,141.24 169.34,140.1 169.34,132.46 174.06,127.74 174.06,124.48 171.14,121.57 171.14,112.14 166.99,107.99 162.41,107.99 161.82,108.58 161.82,109.15 161.22,109.74 156.07,109.74 155.33,109 149.06,109 143.66,103.6 143.66,102.9 144.72,101.84 144.72,88.52 141.56,85.37 141.05,85.37 140.74,85.06 140.74,84.57 140.51,84.34 139,84.34 138.72,84.07 138.72,83.56 138.5,83.34 137.97,83.34 137.75,83.11 137.75,82.58 137.53,82.36 137.03,82.36 136.75,82.08 136.75,81.58 136.5,81.34 136.01,81.34 135.75,81.07 135.75,80.33 v2(136.24,79.84)
  BOTTOM w0.152: Q8.1 202.27,155.84 202.57,155.55 v1(202.82,155.55)
GPIO_SW_C: length 344.6
  TOP w0.152: SW7.3 v1(218.41,27.02) SW7.4 ; v2(139.24,64.84) U1.BD23 ; U111.B12 v5(21.1,130.97)
  14_SIG4 w0.089: v1(34.47,99.77) 36.2,101.5 36.2,106.1 35.53,106.76 35.53,115.29 32.44,118.39 27.33,118.39 26.52,119.2 26.52,121.34 25.98,121.87 25.98,124.3 24.53,125.76 24.53,128.33 23.52,129.34 22.61,129.34 22.18,129.77 21.74,129.77 21.5,130 21.5,130.57 v5(21.1,130.97)
  20_SIG7 w0.089: v1(218.41,27.02) 218.41,31.98 212.6,37.79 212.44,37.79 206.63,43.6 206.63,44.93 205.52,46.05 205.52,49.55 204.6,50.47 203.55,50.47 199.28,54.75 198.44,54.75 197.96,55.23 195.67,55.23 195.38,55.52 191.75,55.52 191.02,56.25 183.69,56.25 179.12,60.81 179.12,77.98 178.7,78.4 174.76,78.4 171.93,81.23 167.85,81.23 167.6,81.48 154.81,81.48 154.19,80.86 154.19,79.79 153.31,78.92 150.19,78.92 149.5,78.23 149.5,70.22 144.84,65.55 139.95,65.55 v2(139.24,64.84)
  BOTTOM w0.152: R46.1 v1(218.41,27.02) ; v2(139.24,64.84) 139.79,64.29 139.79,62.7 139.44,62.34 139.08,62.34 138.74,62 138.74,61.64 138.44,61.34 138.04,61.34 137.74,61.04 137.74,60.64 137.44,60.34 137.04,60.34 136.74,60.04 136.74,59.64 136.43,59.33 136.09,59.33 135.74,58.98 135.74,58.64 135.44,58.34 135.04,58.34 134.74,58.04 134.74,57.64 134.44,57.34 132.04,57.34 131.78,57.61 131.78,58 131.41,58.37 131.01,58.37 130.73,58.65 130.73,59.05 130.44,59.34 130.04,59.34 129.74,59.64 129.74,60.04 129.44,60.34 129.04,60.34 128.74,60.64 128.74,61.04 128.44,61.34 127.93,61.34 127.74,61.54 127.74,62.06 127.45,62.34 118.86,62.34 118.55,62.66 118.55,63.16 117.37,64.34 116.04,64.34 115.74,64.04 115.74,63.63 115.46,63.35 115.06,63.35 114.74,63.03 114.74,62.64 114.44,62.34 114.04,62.34 113.74,62.04 113.74,61.64 113.44,61.34 110.04,61.34 109.74,61.04 109.74,59.64 109.4,59.31 109,59.31 108.74,59.04 108.74,52.65 108.43,52.34 94.55,52.34 93.52,51.31 85.27,51.31 84.69,51.89 84.69,54.96 82.9,56.75 82.9,57.33 77.96,62.27 68.65,62.27 67.94,62.98 67.94,65.67 63.12,70.49 62.91,70.49 62.71,70.68 59.88,70.68 59.44,71.13 59.44,74.57 57.54,76.47 57.54,83.91 56.06,85.39 56.06,93.22 53.67,95.61 53.67,96.24 50.32,99.59 34.65,99.59 v1(34.47,99.77)
GPIO_SW_E: length 351.4
  TOP w0.152: U111.B14 v5(21.1,129.37) ; SW9.4 v1(227.4,27.45) SW9.3 ; v2(140.24,64.84) U1.BE23
  14_SIG4 w0.089: v5(21.1,129.37) 21.5,128.97 21.5,128.35 23.16,126.69 23.16,123.47 23.7,122.94 23.7,115.9 24.94,114.66 25.99,114.66 28.07,112.57 28.07,109.16 29.83,107.4 31.68,107.4 34.29,104.8 34.29,100.83 33.96,100.5 33.96,99.42 34.97,98.41 34.97,97.99 34.97,97.36 v1(34.42,96.81)
  20_SIG7 w0.089: v1(227.4,27.45) 225.83,25.88 218.52,25.88 217.74,26.66 217.74,31.41 206.81,42.34 204.5,42.34 203.2,43.64 201.84,43.64 194.64,50.84 194.64,51.84 190.72,55.77 183.31,55.77 178.55,60.52 178.55,73.87 176.5,75.92 169.77,75.92 168.05,77.65 150.46,77.65 149.97,77.17 149.97,69.8 148.13,67.96 147.97,67.96 145.09,65.08 141.85,65.08 141.65,65.27 140.67,65.27 v2(140.24,64.84)
  BOTTOM w0.152: R48.1 v1(227.4,27.45) ; v2(140.24,64.84) 140.69,64.39 141.43,64.39 142.19,63.63 142.19,61.85 141.68,61.34 141.02,61.34 140.74,61.06 140.74,60.52 140.51,60.3 140.03,60.3 139.75,60.02 139.75,59.66 139.45,59.36 139.05,59.36 138.73,59.04 138.73,58.64 138.39,58.29 137.99,58.29 137.72,58.02 137.72,57.63 137.42,57.33 137.02,57.33 136.73,57.03 136.73,56.63 136.44,56.34 136.04,56.34 135.74,56.04 135.74,55.64 135.44,55.34 135.04,55.34 134.74,55.04 134.74,54.64 134.44,54.34 132.04,54.34 131.74,54.64 131.74,55 131.39,55.34 131.02,55.34 130.73,55.63 130.73,56.05 130.42,56.36 130.02,56.36 129.74,56.64 129.74,57.04 129.44,57.34 129.04,57.34 128.74,57.64 128.74,58.04 128.44,58.34 128.02,58.34 127.75,58.61 127.75,59.04 127.45,59.34 118.93,59.34 118.77,59.51 118.77,60.02 117.45,61.34 116.02,61.34 115.74,61.06 115.74,60.63 115.45,60.34 115.04,60.34 114.74,60.04 114.74,59.64 114.44,59.34 114.04,59.34 113.74,59.04 113.74,49.6 113.48,49.34 94.47,49.34 94.28,49.15 83.23,49.15 81.71,50.67 81.71,56.41 78.56,59.56 68.83,59.56 66.85,61.54 66.85,64.43 63.77,67.51 59.41,67.51 58.37,68.55 58.37,73.19 56.44,75.12 56.44,83.06 54.23,85.27 54.23,89.46 53.09,90.6 41.02,90.6 37.13,94.49 34.26,94.49 33.73,95.02 33.73,95.43 34.42,96.11 v1(34.42,96.81)
GPIO_SW_N: length 302.6
  TOP w0.152: U111.A13 v5(21.9,130.17) ; SW10.4 v1(216.94,29.87) SW10.3 ; U1.BB24 v2(137.24,66.84)
  14_SIG4 w0.089: v1(189.51,60.01) 190.65,58.86 190.65,53.3 202.03,41.92 202.03,38.49 203.61,36.91 208.74,36.91 215.78,29.87 v1(216.94,29.87)
  20_SIG7 w0.089: v1(66.27,89.26) 66.69,88.84 66.69,87.09 66.24,86.64 65.18,86.64 64.95,86.86 64.03,86.86 63.97,86.81 61.7,86.81 61.05,87.46 61.05,88.16 60.17,89.04 52.87,89.04 42.18,99.73 42.18,101.83 38.68,105.32 38.68,109.25 36.91,111.02 36.91,115.11 30.61,121.41 29.62,121.41 29.16,121.87 29.16,122.58 27.15,124.59 23.63,124.59 22.25,125.97 22.25,127.64 21.5,128.39 21.5,129.77 v5(21.9,130.17) ; v2(137.24,66.84) 137.68,66.4 141.91,66.4 142.12,66.61 144.51,66.61 148.56,70.66 148.56,80.34 149.71,81.48 153.59,81.48 154.33,82.22 172.52,82.22 175.21,79.53 180.16,79.53 182.55,77.14 182.55,75.49 184.1,73.94 184.1,69.81 191.2,62.7 191.2,60.78 190.43,60.01 v1(189.51,60.01)
  BOTTOM w0.113: 132.74,67.64 132.94,67.44 135.84,67.44 135.93,67.36 136.41,67.36 136.93,66.84 v2(137.24,66.84) ; 124.74,73.74 124.74,74.07 124.56,74.24 121.94,74.24 121.74,74.04 121.74,73.86
  BOTTOM w0.152: 124.74,73.74 124.74,73.64 125.04,73.34 128.44,73.34 128.73,73.05 128.73,72.62 129,72.34 129.44,72.34 129.74,72.04 129.74,71.56 129.92,71.37 130.4,71.37 130.74,71.04 130.74,70.64 131.04,70.34 131.44,70.34 131.74,70.04 131.74,68.62 132.03,68.33 132.45,68.33 132.74,68.04 132.74,67.64 ; v1(216.94,29.87) 217.2,30.12 R49.1 ; 121.74,73.86 121.74,73.65 121.44,73.34 119.06,73.34 118.34,74.07 118.34,74.52 117.52,75.34 108.05,75.34 107.7,75.69 107.7,76.08 107.45,76.33 107.05,76.33 106.73,76.65 106.73,77.17 106.55,77.34 106.04,77.34 105.74,77.64 105.74,78.08 105.48,78.34 105.03,78.34 104.74,78.63 104.74,79.11 104.5,79.34 104.04,79.34 103.74,79.64 103.74,80.04 103.44,80.34 103.04,80.34 102.74,80.64 102.74,81.04 102.44,81.34 102.04,81.34 101.74,81.64 101.74,82.04 101.44,82.34 101.04,82.34 100.74,82.64 100.74,83.04 100.44,83.34 99.99,83.34 99.74,83.6 99.74,87.03 99.47,87.3 95.76,87.3 93.75,89.31 68.98,89.31 68.94,89.26 v1(66.27,89.26)
GPIO_SW_S: length 319.7
  TOP w0.152: U111.C14 v5(20.3,129.37) ; SW17.4 212.38,19.66 212.63,19.4 v1(218.44,19.4) 218.69,19.66 SW17.3 ; U1.BE22 v2(140.24,63.84)
  05_SIG2 w0.173: v1(157.5,56.82) 156.77,57.55 153.66,57.55 152.33,56.22 151.32,56.22 150.96,56.58 148.73,56.58 141.96,63.35 141.12,63.35 140.63,63.84 v2(140.24,63.84)
  14_SIG4 w0.089: v5(20.3,129.37) 19.9,128.97 19.9,127.41 20.86,126.44 20.86,123.58 22.07,122.38 22.07,116.46 25.12,113.41 26.42,113.41 27.57,112.26 27.57,108.95 29.62,106.9 31.47,106.9 33.78,104.59 33.78,101.04 33.46,100.71 33.46,99.21 v1(34.47,98.2)
  20_SIG7 w0.089: v1(218.44,19.4) 210.44,19.4 198.6,31.24 198.6,44.34 192.4,50.54 181.95,50.54 179.11,53.39 172.78,53.39 171.67,54.5 168.35,54.5 167.68,55.17 160.83,55.17 159.74,56.26 158.06,56.26 v1(157.5,56.82)
  BOTTOM w0.152: v1(34.47,98.2) 35.48,99.21 49.81,99.21 53.11,95.91 53.11,95.02 55.42,92.71 55.42,85.34 57.18,83.59 57.18,76.19 59.08,74.3 59.08,70 59.67,69.41 62.71,69.41 62.99,69.14 63.51,69.14 67.58,65.07 67.58,62.26 69.09,60.76 78.71,60.76 82.42,57.04 82.42,55.7 82.7,55.42 83.29,55.42 84,54.71 84,51.72 84.91,50.81 93.99,50.81 94.52,51.34 109.5,51.34 109.74,51.58 109.74,59.04 110.03,59.33 110.43,59.33 110.74,59.64 110.74,60.04 111.04,60.34 113.44,60.34 113.74,60.64 113.74,61.04 114.04,61.34 114.44,61.34 114.74,61.64 114.74,62.04 115.04,62.34 115.44,62.34 115.74,62.64 115.74,63.06 116.02,63.34 117.38,63.34 118.21,62.51 118.21,61.96 118.83,61.34 127.46,61.34 127.74,61.06 127.74,60.63 128.02,60.34 128.44,60.34 128.73,60.05 128.73,59.63 129.02,59.35 129.43,59.35 129.74,59.04 129.74,58.64 130.04,58.34 130.44,58.34 130.74,58.04 130.74,57.64 131.04,57.34 131.44,57.34 131.67,57.11 131.67,56.71 132.04,56.34 134.44,56.34 134.74,56.64 134.74,57.04 135.04,57.34 135.44,57.34 135.74,57.64 135.74,58.04 136.02,58.32 136.45,58.32 136.75,58.62 136.75,59.06 137.05,59.36 137.45,59.36 137.74,59.64 137.74,60.04 138.04,60.34 138.44,60.34 138.74,60.64 138.74,61.04 139.04,61.34 139.44,61.34 139.74,61.64 139.74,62.04 140.04,62.34 140.44,62.34 140.74,62.64 140.74,63.34 v2(140.24,63.84) ; R47.1 v1(218.44,19.4)
GPIO_SW_W: length 309.4
  TOP w0.152: U1.BF22 v2(141.24,63.84) 141.75,63.33 149.52,63.33 150.05,63.86 153.62,63.86 154.15,63.32 154.15,59.05 v1(156.37,56.83) ; SW6.4 v1(203.83,27.58) SW6.3 ; U111.D14 v5(19.5,129.37)
  14_SIG4 w0.089: v5(19.5,129.37) 19.1,128.97 19.1,128.4 18.73,128.03 18.73,127.04 20.02,125.76 20.02,119.25 20.55,118.72 20.55,116.38 25.17,111.76 25.17,107.06 29.08,103.15 29.08,96.39 30.28,95.2 v1(34.44,95.2)
  20_SIG7 w0.089: v1(203.83,27.58) 202.95,27.58 199.11,31.42 199.11,44.61 192.71,51.01 182.27,51.01 179.16,54.12 173.24,54.12 171.88,55.48 161.69,55.48 159.82,57.35 156.89,57.35 v1(156.37,56.83)
  BOTTOM w0.152: v1(34.44,95.2) 36.05,96.81 51.4,96.81 52.55,95.66 52.55,94.56 54.81,92.3 54.81,85.45 56.8,83.46 56.8,75.61 58.72,73.69 58.72,68.83 59.69,67.87 64.09,67.87 67.22,64.75 67.22,61.97 69.06,60.12 78.73,60.12 82.07,56.79 82.07,54.14 83.37,52.84 83.37,51.13 84.89,49.61 93.79,49.61 94.53,50.34 110.44,50.34 110.74,50.64 110.74,59.04 111.04,59.34 113.44,59.34 113.74,59.65 113.74,60.05 114.04,60.34 114.44,60.34 114.74,60.64 114.74,61.04 115.04,61.34 115.45,61.34 115.74,61.63 115.74,62.04 116.04,62.34 117.49,62.34 117.83,62 117.83,61.49 118.98,60.34 127.47,60.34 127.73,60.08 127.73,59.63 128.01,59.35 128.45,59.35 128.74,59.06 128.74,58.64 129.03,58.35 129.43,58.35 129.73,58.04 129.73,57.65 130.03,57.35 130.43,57.35 130.73,57.05 130.73,56.65 131.04,56.34 131.44,56.34 131.74,56.04 131.74,55.51 131.91,55.34 134.44,55.34 134.74,55.64 134.74,56.04 135.04,56.34 135.44,56.34 135.74,56.64 135.74,57.04 136.04,57.34 136.44,57.34 136.73,57.63 136.73,58.01 137.08,58.37 137.46,58.37 137.72,58.63 137.72,59.02 138,59.31 138.4,59.31 138.79,59.69 138.79,60.09 139.04,60.34 139.57,60.34 139.74,60.51 139.74,61.04 140.04,61.34 140.57,61.34 140.74,61.51 140.74,62.04 141.04,62.34 141.64,62.34 141.86,62.56 141.86,63.22 v2(141.24,63.84) ; R45.1 v1(203.83,27.58)
IIC_EEPROM_SCL: length 24.6
  TOP w0.14: U80.11 143.81,122.82 v1(144.46,123.47)
  14_SIG4 w0.089: v1(144.46,123.47) 143.91,122.92 142.9,122.92 142.69,122.72 142.03,122.72 141.48,122.17 141.48,122.03 141.48,121.64 141.48,121.64 141.48,116.85 142.87,115.47 143.71,115.47 144.07,115.11 145.38,115.11 146.01,114.48 146.01,113.39 145.87,113.26 145.76,113.26 v1(145.52,113.49)
  BOTTOM w0.152: R628.2 142.81,123.98 143.41,123.98 143.92,123.47 v1(144.46,123.47) ; v1(145.52,113.49) 145.52,113.37 144.44,112.29 144.07,112.29 143.81,112.56 U12.6
IIC_EEPROM_SDA: length 24.2
  TOP w0.14: U80.10 v1(143.19,122.17)
  14_SIG4 w0.089: v1(145.29,112.32) 145.07,112.54 144.77,112.54 144.5,112.27 144.5,112.04 145.09,111.45 145.44,111.45 145.77,111.78 145.77,112.29 146.51,113.03 146.51,114.69 145.59,115.61 145.03,115.61 144.45,116.19 143.9,116.19 143.68,115.97 143.08,115.97 141.95,117.1 141.95,121.97 142.22,122.25 143.12,122.25 v1(143.19,122.17)
  BOTTOM w0.152: R627.2 141.48,122.5 141.81,122.17 v1(143.19,122.17) ; U12.5 144.87,111.91 v1(145.29,112.32)
IIC_MAIN_SCL: length 227.5
  TOP w0.152: U80.22 134.1,117.62 v1(133.46,118.27) ; U111.A15 v5(21.9,128.57) ; v2(127.24,66.84) U1.AM24
  07_SIG3 w0.173: v1(133.46,118.27) 133.96,117.77 133.96,115.43 133.96,115.43 133.96,113.18 134.85,112.29 134.85,104.77 132.09,102.01 132.09,97.97 128.75,94.64 128.75,76.71 128.43,76.38 128.05,76.38 127.71,76.04 127.71,75.67 127.4,75.36 127.03,75.36 126.76,75.09 126.76,74.69 126.38,74.32 126.08,74.32 125.7,73.94 125.7,73.64 125.41,73.34 124.85,73.34 124.71,73.2 124.71,72.57 124.46,72.31 123.99,72.31 123.82,72.14 123.82,66.61 124.62,65.81 126.51,65.81 126.91,66.21 126.91,66.52 v2(127.24,66.84)
  20_SIG7 w0.089: v5(21.9,128.57) 22.37,129.03 22.37,130.33 22.11,130.58 19.31,130.58 19.11,130.78 19.11,131.97 19.3,132.16 22.07,132.16 22.8,131.43 23.29,131.43 23.98,132.11 23.98,132.92 25.08,134.02 33.41,134.02 35.31,135.92 37.13,135.92 38.96,137.74 38.96,139.65 41.15,141.83 41.15,142.72 42.09,143.66 46.23,143.66 47.61,142.28 48.92,142.28 49.36,141.83 50.34,141.83 50.53,141.83 50.88,142.17 57.95,142.17 59.12,141.01 59.12,139.05 59.86,138.31 v1(60.78,138.31)
  BOTTOM w0.152: U28.22 57.58,141.99 59,140.56 59,139.98 R683.2 59.82,139.27 v1(60.78,138.31) 61.85,137.23 65.08,137.23 70.48,142.63 96.09,142.63 96.62,142.1 96.62,139.75 96.9,139.47 98.96,139.47 99.19,139.7 99.19,142.21 99.61,142.63 102.32,142.63 113.59,131.37 113.59,125.37 116.1,122.86 122.58,122.86 127.79,117.64 128.87,117.64 130.18,118.95 132.08,118.95 132.97,118.06 133.25,118.06 v1(133.46,118.27)
IIC_MAIN_SDA: length 226.4
  TOP w0.14: U80.23 v1(134.59,116.97)
  TOP w0.152: U111.D11 v5(19.5,131.77)
  TOP w0.381: v2(126.24,66.84) U1.AL24
  07_SIG3 w0.173: v2(126.24,66.84) 126.56,66.84 126.65,66.75 126.65,66.32 126.4,66.07 125.06,66.07 124.77,66.35 124.77,72.13 125.06,72.43 125.52,72.43 125.75,72.65 125.75,73.08 126.02,73.35 126.56,73.35 126.73,73.52 126.73,74.03 127.02,74.32 127.55,74.32 127.81,74.59 127.81,75.09 128.07,75.34 128.54,75.34 128.72,75.51 128.72,76.01 129.04,76.34 129.41,76.34 129.73,76.66 129.73,89.53 129.33,89.93 129.33,94.43 132.64,97.74 132.64,101.78 135.4,104.54 135.4,112.52 134.51,113.41 134.51,115.2 135.3,115.99 135.3,117.13 135.1,117.33 134.7,117.33 134.59,117.22 v1(134.59,116.97)
  20_SIG7 w0.089: v5(19.5,131.77) 19.9,131.37 22.19,131.37 22.65,130.91 23.44,130.91 24.49,131.95 24.49,132.76 25.23,133.5 27.34,133.5 27.43,133.41 27.43,133.01 27.52,132.92 27.88,132.92 27.97,133.01 27.97,133.41 28.05,133.5 28.41,133.5 28.5,133.41 28.5,133.01 28.59,132.92 28.94,132.92 29.03,133.01 29.03,133.41 29.12,133.5 29.48,133.5 29.57,133.41 29.57,133.01 29.66,132.92 30.01,132.92 30.1,133.01 30.1,133.41 30.19,133.5 30.54,133.5 30.63,133.41 30.63,133.01 30.72,132.92 31.08,132.92 31.17,133.01 31.17,133.41 31.26,133.5 31.61,133.5 31.7,133.41 31.7,132.96 31.79,132.87 32.14,132.87 32.23,132.96 32.23,133.41 32.32,133.5 33.56,133.5 35.5,135.45 37.33,135.45 39.45,137.56 39.45,139.47 41.62,141.64 41.62,142.19 42.11,142.68 45.71,142.68 45.9,142.49 46.71,142.49 47.4,141.81 48.72,141.81 49.17,141.36 50.14,141.36 50.73,141.36 51.07,141.7 57.75,141.7 58.65,140.81 58.65,138.43 58.28,138.07 v1(57.44,138.07)
  BOTTOM w0.152: v1(134.59,116.97) 133.86,117.7 132.77,117.7 131.88,118.59 130.33,118.59 129.02,117.28 127.65,117.28 122.43,122.5 115.95,122.5 113.23,125.22 113.23,131.22 102.22,142.24 99.72,142.24 99.54,142.06 99.54,139.5 99.16,139.12 96.67,139.12 96.27,139.52 96.27,141.83 95.86,142.24 70.63,142.24 65.25,136.85 57.92,136.85 57.47,137.3 57.47,138.03 v1(57.44,138.07) 57.69,138.32 57.69,139.05 57.91,139.27 R682.2 58.44,139.67 58.52,139.75 58.52,140.39 57.57,141.34 U28.23
IIC_MUX_RESET_B: length 245.4
  TOP w0.14: U80.3 143.81,117.62 144.2,118 v1(144.2,118.34)
  TOP w0.152: U1.AL25 125.74,67.34 v2(126.24,67.84)
  03_SIG1 w0.173: v2(126.24,67.84) 126.24,68.11 126.74,68.61 126.74,72.05 126.73,72.06 126.73,72.08 126.47,72.34 125.97,72.34 125.74,72.58 125.74,73.13 125.52,73.34 125.03,73.34 124.78,73.58 124.78,73.59 124.74,73.64 124.74,76.13 124.95,76.34 125.53,76.34 125.74,76.55 125.74,77.13 125.95,77.35 126.03,77.35 126.03,77.34 126.44,77.34 126.74,77.64 126.74,77.69 126.74,78.05 126.77,78.08 126.77,78.1 127.02,78.34 127.44,78.34 127.74,78.64 127.74,79.05 128.02,79.34 128.03,79.34 128.44,79.34 128.45,79.34 128.5,79.34 128.74,79.58 128.74,81.13 128.95,81.34 129.44,81.34 129.74,81.64 129.74,82.16 129.92,82.34 130.44,82.34 130.47,82.37 130.47,82.37 130.74,82.63 130.74,83.05 131.03,83.34 131.44,83.34 131.74,83.64 131.74,84.05 131.74,84.05 131.74,84.16 131.92,84.34 140.49,84.34 140.74,84.59 140.74,84.63 140.74,84.64 140.74,85.05 141.03,85.34 141.46,85.34 142.32,86.2 142.32,96.69 141.96,97.05 141.96,100.28 141.27,100.96 141.27,102.92 140.84,103.35 140.84,106.2 141.38,106.73 141.38,107.25 141.88,107.75 142.38,107.75 143.08,108.45 143.08,112.69 143.95,113.56 144.55,113.56 144.9,113.91 144.9,115.77 144.51,116.16 144.51,116.53 144.87,116.89 144.87,117.66 v1(144.2,118.34)
  14_SIG4 w0.089: v1(144.2,118.34) 143.62,117.77 142.98,117.77 142.66,118.09 142.66,119.86 142.93,120.13 143.32,120.13 143.93,120.74 143.93,121.15 144.31,121.53 144.63,121.53 145.72,122.62 145.72,123.37 143.8,125.29 143.44,125.29 142.75,125.98 142.75,130.28 142.01,131.01 142.01,142.51 134.99,149.53 133.91,149.53 130.45,152.98 130.45,153.49 129.08,154.86 121.68,154.86 116.71,159.84 116.71,169.48 111.94,174.24 58.71,174.24 55.37,170.9 55.37,166.53 52.35,163.51 52.35,149.5 50.96,148.1 50.96,144.73 49.53,143.31 v1(49.4,143.31)
  BOTTOM w0.152: v1(49.4,143.31) 48.96,142.87 R72.2 48.22,142.46 48.39,142.29 49.09,142.29 49.4,141.98 49.83,141.98 49.84,141.99 U28.3
INA_PMBUS_ALERT: length 376.9
  TOP w0.152: U37.3 128.66,129.53 128.27,129.13 128.27,127.28 126.26,125.27 122.22,125.27 121.36,124.41 121.36,112.62 122.91,111.07 124.49,111.07 125.27,110.29 129.41,110.29 129.82,110.69 129.82,118.44 130.18,118.8 131.83,118.8 133.63,116.99 133.63,116.13 135.08,114.68 135.08,114.05 135.36,113.77 141.63,113.77 143.09,112.31 144.52,112.31 144.8,112.59 144.8,113.72 146.17,115.09 146.17,115.99 146.01,116.16 146.01,116.92 145.95,116.97 145.95,118.41 v1(146.02,118.47) ; v1(173.58,65.43) 173.32,65.18 U36.3 ; U29.3 225.34,62.61 225.07,62.33 225.07,62.05 v1(224.34,61.32)
  03_SIG1 w0.173: v1(173.58,65.43) 172.45,64.31 172.45,63.1 172.74,62.81 175.55,62.81 177.49,64.75 182.9,64.75 184.45,66.29 189.97,66.29 192.18,64.08 v1(194.52,64.08) 195.32,63.29 195.32,61.75 195.68,61.39 196.24,61.39 196.63,60.99 196.63,59.45 198.22,57.86 204.59,57.86 205.22,57.23 206.43,57.23 206.81,56.85 209.98,56.85 210.81,57.67 210.81,61.7 212.06,62.95 213.3,62.95 213.71,63.37 215.54,63.37 216.36,62.55 218.88,62.55 220.34,61.09 224.11,61.09 v1(224.34,61.32)
  05_SIG2 w0.173: v1(185.19,119.04) 184.47,119.76 184.47,120.99 184.91,121.43 187.07,121.43 188.71,119.79 189.89,119.79 192.75,116.93 192.75,85.34 187.66,80.25 187.66,78.64 181.97,72.95 180.17,72.95 174.29,67.07 174.07,67.07 173.58,66.58 v1(173.58,65.43) ; v1(189.49,159.39) 190.21,158.68 192.07,158.68 192.77,159.38 192.77,161.92 191.93,162.76 191.92,162.76 191.75,162.92 188.45,162.92 181,155.47 174.05,155.47 166.87,148.29 158.99,148.29 152.93,142.23 152.93,137.79 153.21,137.52 153.21,136.55 151.92,135.25 151.92,132.74 149.43,130.25 149.43,128.64 146.34,125.56 146.34,119.7 146.02,119.38 v1(146.02,118.47)
  07_SIG3 w0.173: v1(189.49,159.39) 189.49,160.29 190.4,161.2 190.89,161.2 195.17,156.92 198.8,156.92 199.97,155.75 201.86,155.75 202.22,156.11 208.6,156.11 209.23,155.49 209.23,155.13 210.49,153.87 210.49,142.07 206.77,138.35 206.77,136.09 205.5,134.81 205.5,125.91 200.95,121.36 193.74,121.36 192.84,120.46 190.81,120.46 190.15,119.8 185.95,119.8 v1(185.19,119.04)
  BOTTOM w0.152: U23.3 v1(146.02,118.47) ; U35.3 185.56,119.41 v1(185.19,119.04) ; U8.3 195.02,65.19 195.03,65.18 195.03,64.59 v1(194.52,64.08) ; U27.3 189.67,159.22 v1(189.49,159.39)
INA_PMBUS_SCL: length 331.6
  TOP w0.152: U36.5 174.33,65.37 v1(174.39,65.43) ; U37.5 129.61,128.53 130.29,127.85 130.29,124.46 131.13,123.62 133.17,123.62 v1(133.32,123.47) 133.84,123.47 134.49,122.82 U80.14 136.94,122.82 137.09,122.97 137.28,122.97 137.35,122.9 137.35,118.93 138.2,118.08 139.59,118.08 140.07,117.6 140.07,116.09 140.87,115.29 142.82,115.29 143.37,114.74 144.82,114.74 145.61,115.53 145.61,116.67 145.02,117.27 v1(145.02,118.47) ; v1(226.19,61.9) 226.34,62.06 U29.5 226.34,63.9 226.16,64.08 225.02,64.08 224.84,63.91 U29.2
  03_SIG1 w0.173: v1(174.39,65.43) 174.37,65.41 174.37,64.83 174.54,64.66 175.64,64.66 176.89,65.9 182.31,65.9 184.05,67.64 190.75,67.64 192.06,66.33 194.86,66.33 195.6,65.59 195.6,65.15 195.77,64.97 v1(196.02,64.97) 196.65,65.6 196.65,66.58 198.05,67.98 202.49,67.98 203.39,67.08 216.03,67.08 216.92,67.97 219.71,67.97 220.4,67.28 222.15,67.28 224.76,64.67 224.76,63.6 225.84,62.53 225.84,62.25 v1(226.19,61.9)
  05_SIG2 w0.173: v1(145.02,118.47) 145.69,117.8 147.85,117.8 148.43,118.37 148.43,119.2 147.7,119.93 147.7,120.66 147.04,121.32 147.04,125.46 149.72,128.14 150.09,128.14 150.79,128.84 150.79,129.01 156.54,134.76 156.54,140.75 163.37,147.58 167.17,147.58 173.59,154 180.43,154 188.81,162.37 191.52,162.37 192.05,161.84 192.05,159.96 191.49,159.4 v1(190.67,159.4) ; v1(185.22,120.74) 185.46,120.5 187.22,120.5 192.13,115.59 192.13,85.67 186.93,80.48 186.93,78.7 182.81,74.58 177.18,74.58 171.87,69.26 171.87,65.23 172.3,64.8 173.76,64.8 v1(174.39,65.43)
  07_SIG3 w0.173: v1(190.67,159.4) 194.44,155.63 198.5,155.63 201.19,152.94 203.02,152.94 203.48,152.94 204.58,154.04 208.71,154.04 209.31,153.44 209.31,147.2 209.3,147.2 209.3,142.44 205.59,138.73 205.59,136.55 204.39,135.35 204.39,126.68 200.45,122.74 191.69,122.74 190.67,121.72 186.2,121.72 185.39,120.91 v1(185.22,120.74)
  BOTTOM w0.152: v1(185.22,120.74) 185.55,120.41 U35.5 ; v1(133.32,123.47) 135.65,125.8 R630.2 ; U8.5 v1(196.02,64.97) ; U27.5 v1(190.67,159.4) ; U23.5 v1(145.02,118.47)
INA_PMBUS_SDA: length 337.3
  TOP w0.14: U80.13 v1(134.59,123.47)
  TOP w0.152: U80.13 136.94,123.47 137.09,123.32 137.45,123.32 137.73,123.05 137.73,119.06 138.35,118.44 139.73,118.44 140.43,117.75 140.43,116.24 141.01,115.65 142.96,115.65 143.52,115.1 144.66,115.1 145.1,115.53 v1(145.1,116.3) ; v1(174.08,63.34) 173.82,63.6 U36.4 ; U37.4 129.72,129.03 130.65,128.1 130.65,124.61 131.22,124.03 134.04,124.03 v1(134.59,123.47) ; v1(225.55,61.26) 225.55,62.2 225.84,62.5 U29.4
  03_SIG1 w0.173: v1(174.08,63.34) 174.84,64.1 175.87,64.1 177.11,65.34 182.63,65.34 184.37,67.09 190.52,67.09 191.83,65.78 194.59,65.78 195.04,65.32 195.04,64.92 195.54,64.42 195.69,64.42 v1(196.02,64.08) 197.21,65.27 197.21,66.35 198.28,67.42 202.26,67.42 203.16,66.52 216.26,66.52 217.14,67.41 219.23,67.41 219.92,66.72 221.92,66.72 224.21,64.44 224.21,63.37 225.28,62.3 225.28,61.53 v1(225.55,61.26)
  05_SIG2 w0.173: v1(185.22,119.91) 185.25,119.94 186.97,119.94 191.53,115.38 191.53,86.08 186.28,80.82 186.28,78.82 182.58,75.13 176.95,75.13 171.31,69.49 171.31,65 172.07,64.25 173.9,64.25 174.19,63.95 174.19,63.46 v1(174.08,63.34) ; v1(145.1,116.3) 144.77,116.63 144.77,117.29 144.94,117.47 145.24,117.47 145.46,117.25 148.08,117.25 148.99,118.15 148.99,120.63 148.64,120.98 148.19,120.98 147.59,121.58 147.59,125.15 149.96,127.51 150.25,127.51 151.35,128.61 151.35,128.78 157.09,134.53 157.09,140.52 163.6,147.02 167.4,147.02 173.82,153.45 180.66,153.45 189.04,161.82 191.29,161.82 191.49,161.62 191.49,160.32 191.23,160.06 190.88,160.06 190.65,160.29 v1(190.65,160.6)
  07_SIG3 w0.173: v1(190.65,160.6) 190.65,160.1 190.77,159.98 190.92,159.98 194.72,156.19 198.72,156.19 201.42,153.49 203.25,153.49 204.36,154.6 208.93,154.6 209.54,153.99 209.86,153.67 209.86,146.97 209.86,146.97 209.86,142.22 206.17,138.53 206.17,136.3 204.95,135.07 204.95,126.45 200.68,122.18 191.92,122.18 190.9,121.17 186.48,121.17 v1(185.22,119.91)
  BOTTOM w0.152: U35.4 v1(185.22,119.91) ; U8.1 194.02,66.68 193.78,66.92 193.78,67.35 194.07,67.64 195.04,67.64 195.52,67.16 U8.4 195.52,65.19 195.51,65.18 195.51,64.59 v1(196.02,64.08) ; v1(134.59,123.47) 135.65,124.53 R629.2 ; U23.4 145.52,116.72 v1(145.1,116.3) ; U27.2 189.17,157.49 189.36,157.3 190.02,157.3 190.17,157.45 U27.4 190.17,159.03 190.09,159.11 190.09,160.05 v1(190.65,160.6)
INPUT_GND: length 773.7
  TOP w0.381: 223.24,136.08 J15.6 ; J15.6 222.8,137.33 ; J15.6 224.5,135.63 ; J15.6 226.2,137.33 ; J15.6 224.5,139.03 ; J15.6 223.24,138.58 ; J15.6 225.75,136.08 ; J15.6 225.75,138.58 ; U16.3 215.51,132.97 ; U16.3 213.38,132.06 ; U16.3 214.59,133.28 ; U16.3 215.51,131.15 ; U16.3 213.68,132.97 ; U16.3 215.81,132.06 ; U16.3 213.68,131.15 ; U16.3 214.59,130.84 ; J15.2 230,143.23 ; J15.2 231.7,141.53 ; J15.2 231.25,140.28 ; J15.2 231.25,142.78 ; J15.2 228.74,140.28 ; J15.2 228.74,142.78 ; J15.2 230,139.83 ; J15.2 228.3,141.53 ; J15.3 231.25,138.58 ; J15.3 230,139.03 ; J15.3 230,135.63 ; J15.3 228.3,137.33 ; J15.3 231.25,136.08 ; J15.3 231.7,137.33 ; J15.3 228.74,138.58 ; J15.3 228.74,136.08 ; J12.1 220.74,134.34 ; J12.1 219.67,133.27 ; J12.1 219.67,134.34 ; J12.1 221.81,134.34 ; J12.1 221.81,133.27 ; J12.1 220.74,132.21 ; J12.1 219.67,132.21 ; J12.1 221.81,132.21 ; 220.69,140.93 v1(220.7,140.92) ; Q4.2 v1(224.62,160.19) ; R640.2 224.29,152.57 v1(223.79,153.07) ; R637.2 v1(226.19,151.79) ; C358.2 C549.2 221.61,155.19 221.64,155.22 v1(221.64,155.24)
  03_SIG1 w0.381: 237.06,151.32 SW1.SH2 ; SW1.SH2 237.47,150.15 ; SW1.SH2 238.63,152.89 ; SW1.SH2 238.63,149.74 ; SW1.SH2 239.8,152.48 ; SW1.SH2 239.8,150.15 ; SW1.SH2 237.47,152.48 ; 228.55,141.53 J15.2 ; J15.2 228.92,142.6 ; J15.2 228.92,140.45 ; J15.2 231.45,141.53 ; J15.2 230,140.08 ; J15.2 231.07,142.6 ; J15.2 231.07,140.45 ; J15.2 230,142.98 ; 213.68,131.15 U16.3 ; U16.3 213.38,132.06 ; U16.3 215.81,132.06 ; U16.3 215.51,131.15 ; U16.3 214.59,130.84 ; U16.3 214.59,133.28 ; U16.3 213.68,132.97 ; U16.3 215.51,132.97 ; J15.6 224.5,138.78 ; J15.6 223.05,137.33 ; J15.6 223.42,136.25 ; J15.6 223.42,138.4 ; J15.6 225.57,138.4 ; J15.6 225.57,136.25 ; J15.6 224.5,135.88 ; J15.6 225.95,137.33 ; 219.67,133.27 J12.1 ; J12.1 220.74,134.34 ; J12.1 219.94,134.08 ; J12.1 219.94,132.47 ; J12.1 220.74,132.21 ; J12.1 221.81,133.27 ; J12.1 221.55,134.08 ; J12.1 221.55,132.47 ; 228.92,136.25 J15.3 ; J15.3 231.45,137.33 ; J15.3 231.07,138.4 ; J15.3 230,138.78 ; J15.3 228.92,138.4 ; J15.3 231.07,136.25 ; J15.3 230,135.88 ; J15.3 228.55,137.33 ; SW1.3 230.68,153.22 ; SW1.3 227.94,152.06 ; SW1.3 229.11,151.65 ; SW1.3 227.94,154.39 ; SW1.3 229.11,154.8 ; SW1.3 230.27,154.39 ; SW1.3 230.27,152.06 ; SW1.SH1 239.8,165.69 ; SW1.SH1 237.47,165.69 ; SW1.SH1 239.8,163.36 ; SW1.SH1 237.06,164.53 ; SW1.SH1 237.47,163.36 ; SW1.SH1 238.63,162.95 ; SW1.SH1 238.63,166.1
  05_SIG2 w0.381: SW1.3 229.11,154.8 ; SW1.3 230.27,152.06 ; SW1.3 230.68,153.22 ; SW1.3 227.94,152.06 ; SW1.3 230.27,154.39 ; SW1.3 227.94,154.39 ; SW1.3 229.11,151.65 ; 238.63,162.95 SW1.SH1 ; SW1.SH1 238.63,166.1 ; SW1.SH1 237.47,163.36 ; SW1.SH1 237.06,164.53 ; SW1.SH1 239.8,165.69 ; SW1.SH1 237.47,165.69 ; SW1.SH1 239.8,163.36 ; 230,135.88 J15.3 ; J15.3 231.45,137.33 ; J15.3 228.92,136.25 ; J15.3 228.92,138.4 ; J15.3 231.07,136.25 ; J15.3 231.07,138.4 ; J15.3 228.55,137.33 ; J15.3 230,138.78 ; U16.3 215.51,132.97 ; U16.3 215.81,132.06 ; U16.3 215.51,131.15 ; U16.3 214.59,130.84 ; U16.3 213.38,132.06 ; U16.3 213.68,131.15 ; U16.3 213.68,132.97 ; U16.3 214.59,133.28 ; J12.1 221.55,134.08 ; J12.1 219.94,134.08 ; J12.1 221.55,132.47 ; J12.1 221.81,133.27 ; J12.1 220.74,134.34 ; J12.1 219.94,132.47 ; J12.1 219.67,133.27 ; J12.1 220.74,132.21 ; SW1.SH2 239.8,152.48 ; SW1.SH2 237.47,150.15 ; SW1.SH2 237.06,151.32 ; SW1.SH2 238.63,152.89 ; SW1.SH2 239.8,150.15 ; SW1.SH2 238.63,149.74 ; SW1.SH2 237.47,152.48 ; 228.55,141.53 J15.2 ; J15.2 228.92,142.6 ; J15.2 231.07,142.6 ; J15.2 230,140.08 ; J15.2 228.92,140.45 ; J15.2 231.45,141.53 ; J15.2 231.07,140.45 ; J15.2 230,142.98 ; 223.05,137.33 J15.6 ; J15.6 225.95,137.33 ; J15.6 225.57,138.4 ; J15.6 224.5,135.88 ; J15.6 225.57,136.25 ; J15.6 224.5,138.78 ; J15.6 223.42,138.4 ; J15.6 223.42,136.25
  07_SIG3 w0.381: 228.92,136.25 J15.3 ; J15.3 230,135.88 ; J15.3 228.55,137.33 ; J15.3 228.92,138.4 ; J15.3 231.07,138.4 ; J15.3 231.07,136.25 ; J15.3 230,138.78 ; J15.3 231.45,137.33 ; 230,140.08 J15.2 ; J15.2 231.07,140.45 ; J15.2 228.92,142.6 ; J15.2 228.55,141.53 ; J15.2 230,142.98 ; J15.2 228.92,140.45 ; J15.2 231.07,142.6 ; J15.2 231.45,141.53 ; J15.6 224.5,138.78 ; J15.6 223.42,138.4 ; J15.6 225.57,138.4 ; J15.6 223.42,136.25 ; J15.6 225.57,136.25 ; J15.6 225.95,137.33 ; J15.6 224.5,135.88 ; J15.6 223.05,137.33 ; 213.68,131.15 U16.3 ; U16.3 215.51,132.97 ; U16.3 215.81,132.06 ; U16.3 215.51,131.15 ; U16.3 214.59,133.28 ; U16.3 214.59,130.84 ; U16.3 213.38,132.06 ; U16.3 213.68,132.97 ; J12.1 221.55,132.47 ; J12.1 219.67,133.27 ; J12.1 219.94,132.47 ; J12.1 220.74,132.21 ; J12.1 221.81,133.27 ; J12.1 220.74,134.34 ; J12.1 221.55,134.08 ; J12.1 219.94,134.08 ; SW1.SH2 239.8,152.48 ; SW1.SH2 237.06,151.32 ; SW1.SH2 237.47,152.48 ; SW1.SH2 237.47,150.15 ; SW1.SH2 238.63,149.74 ; SW1.SH2 239.8,150.15 ; SW1.SH2 238.63,152.89 ; SW1.SH1 239.8,163.36 ; SW1.SH1 237.47,163.36 ; SW1.SH1 239.8,165.69 ; SW1.SH1 237.47,165.69 ; SW1.SH1 238.63,166.1 ; SW1.SH1 237.06,164.53 ; SW1.SH1 238.63,162.95 ; SW1.3 230.27,152.06 ; SW1.3 230.68,153.22 ; SW1.3 229.11,151.65 ; SW1.3 230.27,154.39 ; SW1.3 227.94,154.39 ; SW1.3 227.94,152.06 ; SW1.3 229.11,154.8
  14_SIG4 w0.381: 237.06,151.32 SW1.SH2 ; SW1.SH2 238.63,149.74 ; SW1.SH2 239.8,152.48 ; SW1.SH2 239.8,150.15 ; SW1.SH2 237.47,152.48 ; SW1.SH2 238.63,152.89 ; SW1.SH2 237.47,150.15 ; SW1.SH1 239.8,163.36 ; SW1.SH1 237.06,164.53 ; SW1.SH1 237.47,163.36 ; SW1.SH1 237.47,165.69 ; SW1.SH1 239.8,165.69 ; SW1.SH1 238.63,166.1 ; SW1.SH1 238.63,162.95 ; 228.55,141.53 J15.2 ; J15.2 230,142.98 ; J15.2 231.45,141.53 ; J15.2 231.07,142.6 ; J15.2 228.92,142.6 ; J15.2 230,140.08 ; J15.2 231.07,140.45 ; J15.2 228.92,140.45 ; 230,135.88 J15.3 ; J15.3 231.45,137.33 ; J15.3 231.07,138.4 ; J15.3 230,138.78 ; J15.3 228.55,137.33 ; J15.3 228.92,138.4 ; J15.3 228.92,136.25 ; J15.3 231.07,136.25 ; 213.38,132.06 U16.3 ; U16.3 214.59,130.84 ; U16.3 214.59,133.28 ; U16.3 215.51,132.97 ; U16.3 215.51,131.15 ; U16.3 213.68,131.15 ; U16.3 213.68,132.97 ; U16.3 215.81,132.06 ; 220.74,132.21 J12.1 ; J12.1 221.81,133.27 ; J12.1 219.94,134.08 ; J12.1 220.74,134.34 ; J12.1 219.67,133.27 ; J12.1 221.55,134.08 ; J12.1 219.94,132.47 ; J12.1 221.55,132.47 ; J15.6 224.5,138.78 ; J15.6 223.05,137.33 ; J15.6 223.42,136.25 ; J15.6 225.95,137.33 ; J15.6 225.57,136.25 ; J15.6 223.42,138.4 ; J15.6 225.57,138.4 ; J15.6 224.5,135.88 ; SW1.3 230.68,153.22 ; SW1.3 229.11,154.8 ; SW1.3 230.27,152.06 ; SW1.3 230.27,154.39 ; SW1.3 227.94,152.06 ; SW1.3 227.94,154.39 ; SW1.3 229.11,151.65
  16_SIG5 w0.089: 239.73,156.8 239.57,156.8 239.23,156.46 239.23,154.04 239.51,153.76 ; 237.64,158.84 237.4,158.6 237.4,158.28 237.19,158.07 ; 239.39,153.48 238.95,153.93 238.95,156.71 238.86,156.8 238.46,156.8 ; 236.86,157.55 236.41,157.1 236.41,153.08 236.32,152.99 235.92,152.99 ; 239.99,157.27 236.97,157.27 236.69,156.99 236.69,152.8 236.77,152.72 236.92,152.72 237.19,152.99 ; 238.46,158.07 238.35,157.96 237.76,157.96 237.68,158.04 237.68,158.49 237.75,158.56
  16_SIG5 w0.381: 228.55,141.53 J15.2 ; J15.2 228.92,140.45 ; J15.2 231.45,141.53 ; J15.2 228.92,142.6 ; J15.2 231.07,142.6 ; J15.2 230,140.08 ; J15.2 231.07,140.45 ; J15.2 230,142.98 ; J12.1 221.55,134.08 ; J12.1 219.67,133.27 ; J12.1 221.55,132.47 ; J12.1 219.94,134.08 ; J12.1 221.81,133.27 ; J12.1 220.74,134.34 ; J12.1 219.94,132.47 ; J12.1 220.74,132.21 ; 237.06,151.32 SW1.SH2 ; SW1.SH2 238.63,152.89 ; SW1.SH2 239.8,150.15 ; SW1.SH2 239.8,152.48 ; SW1.SH2 237.47,150.15 ; SW1.SH2 237.47,152.48 ; SW1.SH2 238.63,149.74 ; 228.92,138.4 J15.3 ; J15.3 231.07,136.25 ; J15.3 230,135.88 ; J15.3 228.55,137.33 ; J15.3 228.92,136.25 ; J15.3 230,138.78 ; J15.3 231.07,138.4 ; J15.3 231.45,137.33 ; 213.68,132.97 U16.3 ; U16.3 215.81,132.06 ; U16.3 213.38,132.06 ; U16.3 215.51,132.97 ; U16.3 213.68,131.15 ; U16.3 215.51,131.15 ; U16.3 214.59,130.84 ; U16.3 214.59,133.28 ; 223.05,137.33 J15.6 ; J15.6 225.95,137.33 ; J15.6 224.5,138.78 ; J15.6 224.5,135.88 ; J15.6 225.57,138.4 ; J15.6 225.57,136.25 ; J15.6 223.42,136.25 ; J15.6 223.42,138.4 ; SW1.SH1 239.8,165.69 ; SW1.SH1 239.8,163.36 ; SW1.SH1 238.63,166.1 ; SW1.SH1 237.06,164.53 ; SW1.SH1 238.63,162.95 ; SW1.SH1 237.47,163.36 ; SW1.SH1 237.47,165.69 ; SW1.3 230.27,152.06 ; SW1.3 227.94,152.06 ; SW1.3 229.11,154.8 ; SW1.3 230.68,153.22 ; SW1.3 230.27,154.39 ; SW1.3 227.94,154.39 ; SW1.3 229.11,151.65
  18_SIG6 w0.381: J15.2 231.45,141.53 ; J15.2 228.55,141.53 ; J15.2 231.07,142.6 ; J15.2 231.07,140.45 ; J15.2 230,140.08 ; J15.2 228.92,140.45 ; J15.2 230,142.98 ; J15.2 228.92,142.6 ; 230,135.88 J15.3 ; J15.3 231.45,137.33 ; J15.3 228.92,136.25 ; J15.3 230,138.78 ; J15.3 231.07,138.4 ; J15.3 228.55,137.33 ; J15.3 231.07,136.25 ; J15.3 228.92,138.4 ; 237.06,151.32 SW1.SH2 ; SW1.SH2 237.47,152.48 ; SW1.SH2 238.63,152.89 ; SW1.SH2 239.8,150.15 ; SW1.SH2 238.63,149.74 ; SW1.SH2 237.47,150.15 ; SW1.SH2 239.8,152.48 ; 223.05,137.33 J15.6 ; J15.6 224.5,138.78 ; J15.6 223.42,136.25 ; J15.6 223.42,138.4 ; J15.6 225.95,137.33 ; J15.6 225.57,136.25 ; J15.6 225.57,138.4 ; J15.6 224.5,135.88 ; U16.3 214.59,133.28 ; U16.3 215.81,132.06 ; U16.3 213.68,132.97 ; U16.3 214.59,130.84 ; U16.3 213.38,132.06 ; U16.3 215.51,131.15 ; U16.3 215.51,132.97 ; U16.3 213.68,131.15 ; SW1.SH1 238.63,166.1 ; SW1.SH1 239.8,163.36 ; SW1.SH1 237.47,163.36 ; SW1.SH1 239.8,165.69 ; SW1.SH1 238.63,162.95 ; SW1.SH1 237.47,165.69 ; SW1.SH1 237.06,164.53 ; J12.1 221.55,132.47 ; J12.1 220.74,134.34 ; J12.1 219.67,133.27 ; J12.1 221.81,133.27 ; J12.1 221.55,134.08 ; J12.1 219.94,132.47 ; J12.1 219.94,134.08 ; J12.1 220.74,132.21 ; 227.94,152.06 SW1.3 ; SW1.3 227.94,154.39 ; SW1.3 229.11,151.65 ; SW1.3 230.68,153.22 ; SW1.3 230.27,154.39 ; SW1.3 229.11,154.8 ; SW1.3 230.27,152.06
  20_SIG7 w0.381: 224.5,135.88 J15.6 ; J15.6 223.05,137.33 ; J15.6 225.95,137.33 ; J15.6 223.42,138.4 ; J15.6 223.42,136.25 ; J15.6 224.5,138.78 ; J15.6 225.57,138.4 ; J15.6 225.57,136.25 ; 237.06,164.53 SW1.SH1 ; SW1.SH1 239.8,163.36 ; SW1.SH1 239.8,165.69 ; SW1.SH1 238.63,162.95 ; SW1.SH1 237.47,165.69 ; SW1.SH1 237.47,163.36 ; SW1.SH1 238.63,166.1 ; 230,135.88 J15.3 ; J15.3 231.07,138.4 ; J15.3 231.07,136.25 ; J15.3 228.92,138.4 ; J15.3 230,138.78 ; J15.3 228.55,137.33 ; J15.3 231.45,137.33 ; J15.3 228.92,136.25 ; SW1.3 230.27,152.06 ; SW1.3 229.11,154.8 ; SW1.3 227.94,152.06 ; SW1.3 230.27,154.39 ; SW1.3 227.94,154.39 ; SW1.3 229.11,151.65 ; SW1.3 230.68,153.22 ; J12.1 221.81,133.27 ; J12.1 219.94,132.47 ; J12.1 221.55,132.47 ; J12.1 221.55,134.08 ; J12.1 220.74,132.21 ; J12.1 219.67,133.27 ; J12.1 220.74,134.34 ; J12.1 219.94,134.08 ; U16.3 214.59,133.28 ; U16.3 214.59,130.84 ; U16.3 215.51,132.97 ; U16.3 215.51,131.15 ; U16.3 213.68,131.15 ; U16.3 215.81,132.06 ; U16.3 213.68,132.97 ; U16.3 213.38,132.06 ; SW1.SH2 238.63,152.89 ; SW1.SH2 237.47,150.15 ; SW1.SH2 238.63,149.74 ; SW1.SH2 237.06,151.32 ; SW1.SH2 239.8,152.48 ; SW1.SH2 239.8,150.15 ; SW1.SH2 237.47,152.48 ; 228.92,142.6 J15.2 ; J15.2 230,140.08 ; J15.2 228.55,141.53 ; J15.2 228.92,140.45 ; J15.2 230,142.98 ; J15.2 231.45,141.53 ; J15.2 231.07,140.45 ; J15.2 231.07,142.6
  BOTTOM w0.381: 219.67,132.21 J12.1 ; J12.1 219.67,134.34 ; J12.1 220.74,134.34 ; J12.1 221.81,132.21 ; J12.1 220.74,132.21 ; J12.1 219.67,133.27 ; J12.1 221.81,133.27 ; J12.1 221.81,134.34 ; J15.3 231.25,138.58 ; J15.3 231.7,137.33 ; J15.3 228.74,136.08 ; J15.3 230,139.03 ; J15.3 231.25,136.08 ; J15.3 228.74,138.58 ; J15.3 228.3,137.33 ; J15.3 230,135.63 ; v1(223.79,153.07) U15.2 ; U16.3 214.59,133.28 ; U16.3 215.81,132.06 ; U16.3 213.38,132.06 ; U16.3 213.68,131.15 ; U16.3 214.59,130.84 ; U16.3 215.51,131.15 ; U16.3 215.51,132.97 ; U16.3 213.68,132.97 ; J15.2 231.25,142.78 ; J15.2 231.7,141.53 ; J15.2 228.74,142.78 ; J15.2 230,139.83 ; J15.2 231.25,140.28 ; J15.2 228.3,141.53 ; J15.2 230,143.23 ; J15.2 228.74,140.28 ; J15.6 226.2,137.33 ; J15.6 225.75,138.58 ; J15.6 223.24,138.58 ; J15.6 225.75,136.08 ; J15.6 223.24,136.08 ; J15.6 224.5,139.03 ; J15.6 224.5,135.63 ; J15.6 222.8,137.33 ; C871.2 v1(222.89,151.03)
