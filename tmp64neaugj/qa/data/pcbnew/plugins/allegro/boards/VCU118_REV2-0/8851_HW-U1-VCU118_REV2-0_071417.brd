# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RLD3_C3_72B_DQ41: length 121.1
  TOP w0.152: v2(107.24,67.84) 107.74,67.34 U1.N25 ; U142.B9 v2(81.32,114.17)
  14_SIG4 w0.089: 79.73,108.81 79.73,108.88 79.82,108.98 79.82,109.37 80.12,109.67 80.53,109.67 80.82,109.96 80.82,112.37 80.82,112.45 80.6,112.67 80.01,112.67 79.82,112.86 79.82,113.45 80.04,113.67 80.52,113.67 81.02,114.17 v2(81.32,114.17) ; 94.39,67.34 101.52,67.34 101.73,67.13 101.73,66.42 102.11,66.04 105.14,66.04 105.74,66.64 105.74,67.05 106.03,67.34 106.48,67.34 106.98,67.84 v2(107.24,67.84)
  14_SIG4 w0.14: 94.39,67.34 94.27,67.34 93.74,66.8 91.71,66.8 89.63,68.88 86.33,68.88 86,69.22 86,72.81 85.75,73.06 85.13,73.06 84.82,73.37 84.82,74.47 84.53,74.76 84.26,74.76 83.97,74.47 83.7,74.47 83.43,74.74 83.43,75.8 83.46,75.83 83.46,77.75 83.27,77.94 83.2,77.94 83.01,78.13 83.01,78.94 83.2,79.13 83.27,79.13 83.46,79.32 83.46,85.11 83.15,85.41 82.83,85.41 81.83,86.42 81.34,86.42 80.97,86.04 79.49,86.04 79.33,86.21 79.33,88.44 79.16,88.6 78.92,88.6 78.75,88.44 78.75,86.21 78.59,86.04 78.35,86.04 78.18,86.21 78.18,88.44 78.02,88.6 77.78,88.6 77.61,88.44 77.61,86.21 77.44,86.04 77.21,86.04 77.04,86.21 77.04,88.44 76.87,88.6 76.64,88.6 76.47,88.44 76.47,86.21 76.3,86.04 76.06,86.04 75.9,86.21 75.9,88.44 75.73,88.6 75.49,88.6 75.33,88.44 75.33,86.21 75.16,86.04 74.63,86.04 74.33,86.34 74.33,88.54 75.15,89.36 83.19,89.36 83.46,89.63 83.46,90.99 82.85,91.6 82.85,93.62 84.43,95.19 84.43,99.89 84.04,100.28 84.04,101.14 84.02,101.16 84.02,101.48 83.57,101.93 82.91,101.93 82.5,102.35 82.5,104.11 82.23,104.38 81.19,104.38 81,104.57 81,105.14 81.42,105.56 81.42,106.98 81.3,107.1 80.94,107.1 80.82,106.98 80.82,106.06 80.59,105.83 80.02,105.83 79.73,106.13 79.73,107.47 79.92,107.66 80.58,107.66 80.77,107.85 80.77,108.23 80.58,108.42 79.92,108.42 79.73,108.61 79.73,108.81
RLD3_C3_72B_DQ42: length 120.5
  TOP w0.152: U1.P26 108.74,68.34 v2(108.24,68.84) ; U142.B11 v2(81.32,112.17)
  14_SIG4 w0.089: 94.39,68.33 101.5,68.33 101.73,68.1 101.73,67.61 101.98,67.36 102.51,67.36 102.72,67.16 102.72,66.52 102.9,66.34 104.44,66.34 104.74,66.64 104.74,67.05 105.03,67.34 105.44,67.34 105.74,67.64 105.74,68.05 106.03,68.34 108.36,68.34 108.45,68.43 108.45,68.72 108.32,68.84 v2(108.24,68.84) ; v2(81.32,112.17) 81.2,112.29 81.2,112.55 81.28,112.63 81.56,112.63 81.82,112.37 81.82,109.75 81.93,109.64 82.36,109.64 82.47,109.53 82.47,109.37 82.36,109.26 81.93,109.26 81.82,109.15 81.82,108.74
  14_SIG4 w0.14: 81.82,108.74 81.82,108.51 81.46,108.14 81.46,107.75 81.53,107.67 81.53,107.67 82,107.21 82,106.96 82.12,106.83 82.12,106.02 82.25,105.89 82.25,105.58 81.96,105.29 81.96,105.13 82.13,104.96 82.37,104.96 82.65,105.25 82.89,105.25 83.77,104.37 83.77,103 84,102.77 85.32,102.77 85.58,102.51 85.58,102.22 85.36,102 84.81,102 84.59,101.78 84.59,101.4 84.75,101.23 85.16,101.23 85.35,101.04 85.35,100.16 85.17,99.98 85.17,95.12 83.81,93.77 83.81,93.21 84.03,93 84.57,93 84.76,93.19 84.76,93.61 84.95,93.8 85.33,93.8 85.52,93.61 85.52,93.19 85.71,93 86.6,93 86.79,92.81 86.79,92.43 86.61,92.25 84.11,92.25 83.86,92 83.86,91.62 84.01,91.48 86.6,91.48 86.79,91.29 86.79,87.01 86.6,86.82 86.12,86.82 85.92,87.02 85.92,90.26 85.46,90.71 84.44,90.71 84.25,90.52 84.25,89.03 83.39,88.17 82.67,88.17 82.27,88.57 80.87,88.57 80.67,88.37 80.67,87.56 80.9,87.33 82.09,87.33 82.65,86.77 83.08,86.77 83.59,86.26 83.85,86.26 84.05,86.46 84.05,87.71 84.28,87.93 84.59,87.93 84.79,87.74 84.79,85.85 84.62,85.68 84.22,85.68 84.05,85.51 84.05,85.28 84.22,85.11 84.62,85.11 84.79,84.94 84.79,84.7 84.62,84.54 84.22,84.54 84.05,84.37 84.05,84.13 84.22,83.97 84.62,83.97 84.79,83.8 84.79,83.56 84.62,83.39 84.22,83.39 84.05,83.23 84.05,82.99 84.22,82.82 84.62,82.82 84.79,82.65 84.79,82.42 84.62,82.25 84.22,82.25 84.05,82.08 84.05,81.85 84.22,81.68 84.62,81.68 84.79,81.51 84.79,81.28 84.62,81.11 84.22,81.11 84.05,80.94 84.05,80.7 84.22,80.54 84.62,80.54 84.79,80.37 84.79,80.13 84.62,79.96 84.22,79.96 84.05,79.8 84.05,79.56 84.22,79.39 84.98,79.39 85.18,79.2 85.18,78.96 85.04,78.82 83.88,78.82 83.71,78.66 83.71,78.42 83.83,78.31 85.01,78.31 85.18,78.14 85.18,77.91 84.95,77.68 84.22,77.68 84.05,77.51 84.05,77.28 84.22,77.11 84.74,77.11 84.91,76.94 84.91,76.71 84.74,76.54 84.22,76.54 84.05,76.37 84.05,75.52 84.21,75.36 85.57,75.36 85.87,75.06 85.87,73.87 86.74,73 86.74,69.93 87.08,69.58 89.75,69.58 91.68,67.65 93.6,67.65 94.28,68.33 94.39,68.33
RLD3_C3_72B_DQ43: length 119.4
  TOP w0.152: U1.N27 107.74,69.34 v2(107.24,69.84) ; U142.A8 v2(82.32,115.17)
  14_SIG4 w0.089: v2(82.32,115.17) 82.32,114.83 82.49,114.67 83.56,114.67 83.59,114.63 ; 94.39,70.33 101.5,70.33 101.73,70.1 101.73,69.55 101.92,69.35 102.43,69.35 102.72,69.06 102.72,68.55 102.92,68.34 104.44,68.34 104.74,68.64 104.74,69.05 105.03,69.34 105.44,69.34 105.74,69.64 105.74,70.05 106.03,70.34 107.32,70.34 107.44,70.23 107.44,69.94 107.34,69.84 v2(107.24,69.84)
  14_SIG4 w0.14: 83.59,114.63 83.9,114.33 83.9,109.82 83.73,109.66 83.48,109.66 83.31,109.49 83.31,109.25 83.48,109.09 83.73,109.09 83.9,108.92 83.9,108.47 83.73,108.3 83.58,108.3 83.41,108.13 83.41,107.89 83.58,107.73 83.73,107.73 83.9,107.56 83.9,107.49 84.18,107.2 84.42,107.2 84.55,107.34 84.79,107.34 84.96,107.17 84.96,106.93 84.83,106.8 84.83,106.56 84.99,106.4 85.23,106.4 85.36,106.53 85.6,106.53 85.77,106.36 85.77,106.12 85.63,105.99 85.63,105.76 85.8,105.59 86.04,105.59 86.17,105.72 86.41,105.72 86.57,105.55 86.57,105.32 86.44,105.18 86.44,104.95 86.61,104.78 86.85,104.78 86.98,104.91 87.21,104.91 87.38,104.74 87.38,104.51 87.25,104.38 87.25,104.14 87.31,104.08 87.31,103.46 87.99,102.78 89.14,102.78 89.27,102.65 89.27,101.69 88.99,101.41 88.1,101.41 87.9,101.22 87.9,100.95 88.22,100.63 89.46,100.63 89.65,100.44 89.65,100.17 89.31,99.83 87.46,99.83 87.27,99.64 87.27,98.91 87.53,98.64 89.07,98.64 89.27,98.44 89.27,98.17 88.88,97.78 88.88,97.51 89.15,97.24 89.42,97.24 89.81,97.63 90.08,97.63 90.35,97.36 90.35,97.09 90.02,96.76 90.02,96.48 90.28,96.22 90.55,96.22 90.89,96.55 91.16,96.55 91.63,96.08 91.63,95.83 91.44,95.64 91.25,95.64 91.06,95.45 91.06,95.07 91.25,94.88 91.44,94.88 91.63,94.69 91.63,93.74 91.34,93.45 91.1,93.45 90.27,94.28 90.04,94.28 89.87,94.11 89.87,93.87 90.7,93.04 90.7,92.81 90.53,92.64 90.3,92.64 89.47,93.47 89.23,93.47 89.06,93.3 89.06,93.07 89.89,92.24 89.89,92 89.72,91.83 89.49,91.83 88.43,92.89 88.25,92.89 88.08,92.72 88.08,92.43 89.08,91.43 89.08,91.19 88.59,90.7 88.41,90.7 88.22,90.51 88.22,89.98 88.39,89.81 88.99,89.81 89.1,89.7 89.1,89.36 88.99,89.24 88.39,89.24 88.22,89.07 88.22,88.84 88.39,88.67 88.99,88.67 89.1,88.55 89.1,88.21 88.99,88.1 88.39,88.1 88.22,87.93 88.22,87.69 88.39,87.53 88.99,87.53 89.1,87.41 89.1,87.07 88.99,86.96 88.39,86.96 88.22,86.79 88.22,86.55 88.39,86.38 88.99,86.38 89.1,86.27 89.1,85.93 88.99,85.81 88.39,85.81 88.22,85.64 88.22,85.41 88.39,85.24 88.99,85.24 89.1,85.12 89.1,84.79 88.99,84.67 88.39,84.67 88.22,84.5 88.22,84.27 88.39,84.1 88.99,84.1 89.1,83.98 89.1,83.64 88.99,83.53 88.39,83.53 88.22,83.36 88.22,83.09 88.43,82.87 89.01,82.87 89.1,82.78 89.1,82.46 88.94,82.29 88.31,82.29 88.14,82.12 88.14,81.89 88.31,81.72 88.94,81.72 89.1,81.55 89.1,81.31 88.94,81.15 88.31,81.15 88.14,80.98 88.14,80.74 88.31,80.58 88.94,80.58 89.1,80.41 89.1,80.06 88.87,79.83 87.95,79.83 87.78,79.66 87.78,79.43 87.95,79.26 88.61,79.26 88.78,79.09 88.78,78.85 88.61,78.69 87.95,78.69 87.78,78.52 87.78,78.28 87.95,78.11 88.61,78.11 88.78,77.95 88.78,77.71 88.61,77.54 87.95,77.54 87.78,77.38 87.78,77.14 87.95,76.97 88.61,76.97 88.78,76.8 88.78,76.57 88.61,76.4 87.95,76.4 87.78,76.23 87.78,76 87.95,75.83 88.61,75.83 88.78,75.66 88.78,75.29 88.61,75.13 87.24,75.13 87.07,74.96 87.07,74.72 87.24,74.55 88.61,74.55 88.78,74.39 88.78,71.26 89.17,70.87 90.12,70.87 91.65,69.34 93.27,69.34 94.26,70.33 94.39,70.33
RLD3_C3_72B_DQ44: length 120.6
  TOP w0.152: U142.A10 v2(82.32,113.17) ; U1.P24 v2(108.24,66.84)
  14_SIG4 w0.089: v2(108.24,66.84) 106.8,65.41 101.65,65.41 101.22,65.84 94.79,65.84 94.39,65.43 ; v2(82.32,113.17) 82.32,113.45 81.83,113.94 81.83,114.52 81.68,114.67 80.13,114.67 79.82,114.36 79.82,113.96 79.53,113.67 79.12,113.67 78.82,113.37 78.82,112.96 79.12,112.67 79.52,112.67 79.82,112.37 79.82,110.97 79.52,110.67 79.12,110.67 78.82,110.37 78.82,109.89 78.37,109.44 78.37,108.81
  14_SIG4 w0.14: 78.37,108.81 78.37,108.53 77.43,107.58 77.43,107.14 76.74,106.45 76.26,106.45 76.07,106.26 76.07,105.88 76.26,105.69 76.74,105.69 76.93,105.5 76.93,105.08 77.26,104.75 78.04,104.75 78.26,104.52 78.26,103.6 78.07,103.41 76.89,103.41 76.7,103.22 76.7,102.84 76.89,102.65 78.07,102.65 78.26,102.45 78.26,101.59 78.84,101.02 81.16,101.02 82.91,99.27 82.91,95.29 81.61,93.99 81.61,91.27 81.01,90.68 75.01,90.68 73.31,88.98 73.31,85.69 73.81,85.19 81.18,85.19 81.61,84.76 81.61,77.17 81.2,76.76 75.71,76.76 75,76.04 75,72.5 75.28,72.21 82.05,72.21 82.68,72.84 83.15,72.84 83.52,72.47 83.52,68.37 84.82,67.07 84.82,66.52 85.11,66.23 85.94,66.23 87.2,67.49 89.05,67.49 91.14,65.41 94.36,65.41 94.39,65.43
RLD3_C3_72B_DQ45: length 118.7
  TOP w0.152: v2(106.24,67.84) 106.74,67.34 U1.M25 ; v2(73.32,113.17) U142.J10
  20_SIG7 w0.089: 94.39,66.32 97.33,66.32 97.81,65.84 106.19,65.84 106.74,66.39 106.74,67.67 106.56,67.84 v2(106.24,67.84) ; 68.91,117.75 69,117.67 70.66,117.67 70.82,117.51 70.82,116.37 70.67,116.22 69.93,116.22 69.77,116.07 69.77,115.85 69.93,115.7 70.67,115.7 70.82,115.55 70.82,114.96 71.12,114.67 71.62,114.67 71.82,114.47 71.82,113.96 72.12,113.67 73.15,113.67 73.32,113.49 v2(73.32,113.17)
  20_SIG7 w0.14: 94.39,66.32 91.78,66.32 89.65,68.45 86.22,68.45 85.94,68.72 84.94,68.72 83.5,70.16 83.5,73.56 83.05,74.01 83.05,74.21 83.33,74.49 83.33,74.69 83.04,74.98 82.84,74.98 82.56,74.7 82.36,74.7 82.11,74.95 82.11,75.61 82.24,75.74 82.82,75.74 82.96,75.88 82.96,76.3 82.82,76.44 82.45,76.44 82.31,76.58 82.31,85.45 81.68,86.08 80.13,86.08 79.79,86.42 79.79,89.76 80.03,90 81.46,90 82.17,90.71 82.17,99.53 81.97,99.73 66.82,99.73 64.2,102.35 64.2,114.94 64.82,115.56 65.01,115.56 65.51,115.06 65.71,115.06 65.91,115.26 65.91,115.46 65.41,115.95 65.41,116.15 65.58,116.32 65.78,116.32 66.49,115.61 66.69,115.61 66.89,115.81 66.89,116.01 66.2,116.69 66.2,116.94 66.39,117.14 66.59,117.14 67.37,116.35 67.57,116.35 67.77,116.55 67.77,116.75 66.99,117.53 66.99,117.73 67.34,118.08 68.58,118.08 68.91,117.75
RLD3_C3_72B_DQ46: length 118.9
  TOP w0.152: v2(105.24,68.84) 105.74,68.34 U1.L26 ; U142.K11 v2(72.32,112.17)
  20_SIG7 w0.089: 95.05,72.34 96.44,72.34 96.74,72.05 96.74,71.64 97.03,71.34 97.5,71.34 97.5,71.33 97.74,71.09 97.74,70.64 98.03,70.34 98.44,70.34 98.74,70.05 98.74,69.64 99.03,69.34 104.51,69.34 105.01,68.84 v2(105.24,68.84) ; v2(72.32,112.17) 72.32,111.94 71.82,111.44 71.82,110.96 71.53,110.67 71.12,110.67 70.82,110.37 70.82,109.74 71.28,109.29 73.74,109.29 73.82,109.37 73.82,109.37 74.12,109.67 74.86,109.67 75.41,110.22 75.41,114.2 75.87,114.67 76.43,114.67 76.79,115.03 76.79,115.67 77.14,116.02 78.08,116.02 78.82,116.75 78.82,118.49 78.98,118.66 80.62,118.66 80.82,118.86 80.82,120.44 81.01,120.63 81.58,120.63 81.82,120.39 81.82,108.81
  20_SIG7 w0.14: 95.05,72.34 94.71,72.34 89.63,77.42 89.63,78.23 89.49,78.36 88.65,78.36 88.51,78.5 88.51,89.95 88.65,90.09 88.93,90.09 89.07,89.95 89.07,79.06 89.21,78.92 89.49,78.92 89.63,79.06 89.63,93.67 90.27,94.32 90.27,96.26 88.77,97.76 87.21,97.76 87.04,97.93 87.04,98.43 87.24,98.63 88.22,98.63 88.49,98.91 88.49,99.58 88.64,99.72 88.64,100.96 87.6,102 87.6,102.35 81.82,108.12 81.82,108.81
RLD3_C3_72B_DQ47: length 115.1
  TOP w0.152: U1.L28 105.74,70.34 v2(105.24,70.84) ; U142.K13 v2(72.32,110.17)
  20_SIG7 w0.089: v2(105.24,70.84) 105.63,70.84 105.77,70.98 105.77,71.16 105.58,71.34 99.03,71.34 98.74,71.64 98.74,72.05 98.44,72.34 98.03,72.34 97.74,72.64 97.74,73.05 97.44,73.34 97.03,73.34 96.74,73.64 96.74,74.1 96.49,74.34 95.11,74.34 ; v2(72.32,110.17) 72.62,110.17 73.12,110.67 73.15,110.67 73.53,110.67 73.82,110.96 73.82,111.37 73.82,111.37 73.82,114.37 74.12,114.67 74.19,114.67 74.53,114.67 75.01,115.15 75.01,115.28 74.56,115.73 74.56,115.85 74.75,116.04 74.88,116.04 75.33,115.59 75.45,115.59 75.99,116.13 75.99,116.26 75.83,116.42 75.83,116.55 76.02,116.74 76.14,116.74 76.31,116.57 76.43,116.57 76.8,116.94 76.8,120.4 77.09,120.7 78.56,120.7 78.79,120.93 78.79,123.72
  20_SIG7 w0.14: 95.11,74.34 94.56,74.34 93.68,75.22 93.68,75.42 94.35,76.09 94.35,76.3 94.05,76.59 93.87,76.59 93.19,75.91 92.99,75.91 92.69,76.21 92.69,76.41 93,76.71 93,76.91 92.7,77.21 92.51,77.21 92.2,76.9 92,76.9 91.71,77.2 91.71,77.39 92.01,77.7 92.01,77.9 91.72,78.19 91.52,78.19 91.21,77.89 91.01,77.89 90.76,78.14 90.76,91.39 91.45,92.08 91.45,98.45 91.04,98.86 91.04,100.18 90.9,100.32 90.54,100.32 90.4,100.46 90.4,100.88 90.54,101.02 90.9,101.02 91.04,101.16 91.04,102.46 91.18,102.6 91.5,102.6 91.63,102.74 91.63,103.16 91.5,103.3 91.18,103.3 91.04,103.44 91.04,104.02 90.29,104.77 86.84,104.77 83.02,108.6 83.02,109.38 83.2,109.56 83.87,109.56 83.97,109.65 83.97,120.35 82.86,121.46 82.86,123.27 82.76,123.37 82.45,123.37 82.27,123.55 82.27,123.83 82.38,123.94 83.55,123.94 83.64,124.03 83.64,124.21 83.55,124.29 82.95,124.29 82.86,124.38 82.86,126.33 82.72,126.47 82.31,126.47 82.17,126.33 82.17,124.35 82.03,124.21 81.61,124.21 81.47,124.35 81.47,126.16 81.2,126.43 79.07,126.43 78.79,126.15 78.79,123.72
RLD3_C3_72B_DQ48: length 115.4
  TOP w0.152: U1.K28 104.74,70.34 v2(104.24,70.84) ; U142.L8 v2(71.32,115.17)
  20_SIG7 w0.089: 94.39,65.55 94.69,65.86 97.36,65.86 97.64,65.57 106.64,65.57 107.74,66.67 107.74,68.05 107.44,68.34 106.03,68.34 105.74,68.64 105.74,69.05 105.44,69.34 105,69.34 104.74,69.61 104.74,70.34 v2(104.24,70.84) ; 68.91,118.67 71.53,118.67 71.82,118.37 71.82,118.19 71.82,117.96 71.82,116.96 71.82,116.86 71.32,116.36 v2(71.32,115.17)
  20_SIG7 w0.14: 68.91,118.67 66.97,118.67 63.43,115.13 63.43,102.36 66.67,99.11 81.36,99.11 81.56,98.9 81.56,90.81 81.33,90.57 79.72,90.57 79.27,90.12 79.27,85.78 79.57,85.47 81.31,85.47 81.61,85.18 81.61,75.91 80.84,75.14 80.84,71.74 85.01,67.57 88.99,67.57 91.01,65.55 94.39,65.55
RLD3_C3_72B_DQ49: length 117.2
  TOP w0.152: U1.L24 v2(105.24,66.84) ; U142.L10 v2(71.32,113.17)
  20_SIG7 w0.089: 68.91,112.67 68.93,112.65 69.51,112.65 69.82,112.96 69.82,113.37 70.12,113.67 70.53,113.67 71.03,113.17 v2(71.32,113.17) ; v2(105.24,66.84) 104.77,66.38 98.99,66.38 98.74,66.64 98.74,67.05 98.44,67.34 98.03,67.34 97.74,67.64 97.74,68.05 97.44,68.34 97.03,68.34 96.74,68.64 96.74,69.05 96.44,69.34 95.05,69.34
  20_SIG7 w0.14: 95.05,69.34 92.49,69.34 88.15,73.69 88.15,74.06 88.74,74.66 88.74,75.03 88.37,75.4 87.42,75.4 87.16,75.13 87.16,73.96 86.9,73.7 86.25,73.7 85.88,74.07 85.88,76.45 85.65,76.68 85,76.68 84.66,77.02 84.66,87.46 84.52,87.6 84.26,87.6 84.12,87.74 84.12,88.02 84.26,88.16 84.52,88.16 84.66,88.3 84.66,88.58 84.52,88.72 84.26,88.72 84.12,88.86 84.12,89.14 84.26,89.28 84.52,89.28 84.66,89.42 84.66,99.29 85.34,99.98 85.34,100.91 84.16,102.1 81.59,102.1 81.18,102.52 81.18,104.48 80.98,104.67 72.05,104.67 71.81,104.43 69,104.43 68.82,104.61 68.82,105.09 68.96,105.23 70.38,105.23 70.61,105 71.47,105 71.71,105.23 79.65,105.23 79.79,105.37 79.79,105.93 79.65,106.07 79.29,106.07 79.15,106.21 79.15,106.36 79.01,106.5 78.59,106.5 78.45,106.36 78.45,106.21 78.31,106.07 77.89,106.07 77.75,106.21 77.75,106.36 77.61,106.5 77.19,106.5 77.05,106.36 77.05,106.21 76.91,106.07 68.48,106.07 68.22,105.81 68.22,104.5 68.08,104.36 67.65,104.36 67.51,104.5 67.51,112 68.18,112.67 68.91,112.67
RLD3_C3_72B_DQ50: length 117.3
  TOP w0.152: U142.L12 v2(71.32,111.17) ; U1.L25 105.74,67.34 v2(105.24,67.84)
  20_SIG7 w0.089: v2(71.32,111.17) 71.32,111.44 71.82,111.94 71.82,112.37 71.53,112.67 71.12,112.67 70.12,112.67 69.82,112.37 69.82,111.96 69.53,111.67 69.1,111.67 68.91,111.48 ; 78.82,108.81 78.82,109.44 79.05,109.67 79.54,109.67 79.82,109.95 79.82,110.37 79.53,110.67 79.12,110.67 78.82,110.96 78.82,111.37 79.12,111.67 79.15,111.67 79.15,111.67 79.71,111.67 79.82,111.77 79.82,112.52 79.67,112.67 77.96,112.67 77.82,112.53 77.82,112.38 77.82,112.37 77.82,111.96 77.82,111.96 77.82,110.96 77.53,110.67 77.12,110.67 76.82,110.37 76.82,109.89 77.04,109.67 77.88,109.67 78.04,109.51 78.04,108.81 ; v2(105.24,67.84) 104.74,67.34 99.03,67.34 98.74,67.64 98.74,68.05 98.44,68.34 98.03,68.34 97.74,68.64 97.74,69.05 97.44,69.34 97.03,69.34 96.74,69.64 96.74,70.1 96.5,70.34 95.05,70.34
  20_SIG7 w0.14: 78.04,108.81 78.04,108.28 77.66,107.9 77.07,107.9 76.93,107.76 76.93,107.26 76.79,107.12 76.37,107.12 76.23,107.26 76.23,107.76 76.09,107.9 75.67,107.9 75.53,107.76 75.53,107.26 75.39,107.12 74.97,107.12 74.83,107.26 74.83,107.76 74.69,107.9 74.28,107.9 74.14,107.76 74.14,107.26 74,107.12 73.58,107.12 73.44,107.26 73.44,107.76 73.3,107.9 72.88,107.9 72.74,107.76 72.74,107.26 72.6,107.12 72.18,107.12 72.04,107.26 72.04,107.76 71.9,107.9 71.48,107.9 71.34,107.76 71.34,107.26 71.2,107.12 70.78,107.12 70.64,107.26 70.64,107.76 70.5,107.9 68.96,107.9 68.82,108.04 68.82,111.39 68.91,111.48 ; 95.05,70.34 94.53,70.34 94.14,70.73 93.77,70.73 93.23,70.19 92.86,70.19 92.49,70.56 92.49,70.93 93.03,71.47 93.03,71.84 92.66,72.21 92.29,72.21 91.75,71.67 91.38,71.67 91.01,72.04 91.01,72.41 91.55,72.95 91.55,73.32 91.18,73.69 90.81,73.69 90.27,73.15 89.9,73.15 89.53,73.52 89.53,73.89 90.07,74.43 90.07,74.8 89.21,75.66 89.21,75.93 88.95,76.19 87.13,76.19 86.46,76.86 86.46,77.73 86.32,77.87 86.04,77.87 85.9,78.01 85.9,78.43 86.04,78.57 86.32,78.57 86.46,78.71 86.46,79.13 86.32,79.27 86.04,79.27 85.9,79.41 85.9,79.83 86.04,79.97 86.32,79.97 86.46,80.11 86.46,80.53 86.32,80.67 86.04,80.67 85.9,80.81 85.9,81.23 86.04,81.37 86.32,81.37 86.46,81.51 86.46,81.93 86.32,82.07 86.04,82.07 85.9,82.2 85.9,82.62 86.04,82.76 86.32,82.76 86.46,82.9 86.46,83.32 86.32,83.46 86.04,83.46 85.9,83.6 85.9,84.02 86.04,84.16 86.32,84.16 86.46,84.3 86.46,84.72 86.32,84.86 86.04,84.86 85.9,85 85.9,85.42 86.04,85.56 86.32,85.56 86.46,85.7 86.46,86.12 86.32,86.26 86.04,86.26 85.9,86.4 85.9,86.81 86.04,86.95 86.32,86.95 86.46,87.09 86.46,87.51 86.32,87.65 86.04,87.65 85.9,87.79 85.9,88.21 86.04,88.35 86.32,88.35 86.46,88.49 86.46,88.91 86.32,89.05 86.04,89.05 85.9,89.19 85.9,89.61 86.04,89.75 86.32,89.75 86.46,89.89 86.46,90.32 86.32,90.46 85.64,90.46 85.5,90.6 85.5,91.02 85.64,91.16 86.32,91.16 86.46,91.3 86.46,91.72 86.32,91.86 85.64,91.86 85.5,91.99 85.5,92.41 85.64,92.55 86.32,92.55 86.46,92.69 86.46,93.3 86.06,93.7 86.06,93.71 85.44,94.33 85.44,98.87 86.61,100.04 86.61,100.81 85.99,101.44 85.99,102.03 85.65,102.37 84.62,102.37 84.37,102.62 82.9,102.62 82.52,103 82.52,104.71 80.97,106.26 80.97,107.02 80.3,107.69 80.3,107.71 79.45,108.57 79.06,108.57 78.82,108.8 78.82,108.81
RLD3_C3_72B_DQ51: length 117.1
  TOP w0.152: U142.M9 v2(70.32,114.17) ; U1.K26 104.74,68.34 v2(104.24,68.84)
  20_SIG7 w0.089: v2(104.24,68.84) 104.74,68.34 105.58,68.34 105.74,68.18 105.74,66.36 105.49,66.11 98.22,66.11 97.74,66.6 97.74,67.05 97.44,67.34 97.03,67.34 96.74,67.64 96.74,68.05 96.44,68.34 95.05,68.34 ; v2(70.32,114.17) 70.03,114.17 69.53,113.67 68.91,113.67
  20_SIG7 w0.14: 95.05,68.34 92.41,68.34 90.17,70.58 89.98,70.58 89.64,70.24 89.44,70.24 89.15,70.54 89.15,70.73 89.48,71.07 89.48,71.27 88.54,72.21 88.34,72.21 87.86,71.73 87.66,71.73 87.46,71.93 87.46,72.12 87.95,72.61 87.95,72.8 87.72,73.03 86.83,73.03 86.69,72.89 86.69,71.74 86.55,71.6 86.27,71.6 86.13,71.74 86.13,72.89 85.99,73.03 85.09,73.03 84.78,73.34 84.78,75 84.11,75.67 84.11,86.73 83.56,87.28 83.56,89.86 84.11,90.42 84.11,91.73 83.48,92.35 83.48,99.13 84.1,99.74 84.1,100.95 83.47,101.58 80.43,101.58 80.29,101.72 80.29,101.94 80.15,102.08 79.87,102.08 79.73,101.94 79.73,101.72 79.59,101.58 79.31,101.58 79.17,101.72 79.17,102.31 79.03,102.45 78.75,102.45 78.61,102.31 78.61,101.72 78.47,101.58 78.19,101.58 78.06,101.72 78.06,103.25 77.9,103.41 77.64,103.41 77.5,103.27 77.5,101.72 77.36,101.58 77.08,101.58 76.94,101.72 76.94,103.25 76.78,103.41 76.52,103.41 76.38,103.27 76.38,101.72 76.24,101.58 75.96,101.58 75.82,101.72 75.82,103.25 75.66,103.41 75.4,103.41 75.26,103.27 75.26,101.72 75.12,101.58 74.84,101.58 74.7,101.72 74.7,102.31 74.56,102.45 74.28,102.45 74.14,102.31 74.14,101.72 74,101.58 73.72,101.58 73.58,101.72 73.58,102.31 73.45,102.45 73.17,102.45 73.03,102.31 73.03,101.72 72.89,101.58 72.61,101.58 72.47,101.72 72.47,102.31 72.33,102.45 72.05,102.45 71.91,102.31 71.91,101.72 71.77,101.58 71.49,101.58 71.35,101.72 71.35,102.31 71.21,102.45 70.93,102.45 70.79,102.31 70.79,101.72 70.65,101.58 70.37,101.58 70.23,101.72 70.23,102.31 70.09,102.45 69.81,102.45 69.67,102.31 69.67,101.72 69.53,101.58 69.25,101.58 69.11,101.72 69.11,102.31 68.97,102.45 68.7,102.45 68.56,102.31 68.56,101.72 68.42,101.58 67.88,101.58 66.42,103.04 66.42,104.61 66.73,104.92 66.73,113.36 67.03,113.67 68.91,113.67
RLD3_C3_72B_DQ52: length 117.5
  TOP w0.152: U142.M11 v2(70.32,112.17) ; U1.J26 v2(103.24,68.84)
  20_SIG7 w0.089: 70.76,108.81 69.82,109.75 69.82,111.38 70.32,111.88 v2(70.32,112.17) ; 95.05,71.34 96.44,71.34 96.74,71.05 96.74,70.64 97.03,70.34 97.44,70.34 97.74,70.05 97.74,69.64 98.03,69.34 98.44,69.34 98.74,69.05 98.74,68.64 99.03,68.34 103.63,68.34 103.74,68.45 103.74,68.75 103.55,68.94 103.33,68.94 v2(103.24,68.84) ; 75.05,108.81 75.82,109.59 75.82,111.96 75.82,111.96 75.82,113.37 76.11,113.67 79.73,113.67 79.83,113.77 79.83,114.57 79.72,114.68 77.94,114.68 77.8,114.83 77.8,115.49 77.95,115.65 79.7,115.65 79.83,115.78 79.83,117.6 79.91,117.68 80.69,117.68 80.82,117.54 80.82,111.96 80.82,111.96 80.82,108.81
  20_SIG7 w0.14: 80.82,108.81 80.82,107.91 81.52,107.21 81.52,107.02 83.87,104.66 83.87,103.86 84.84,102.9 86.31,102.9 86.77,102.44 86.77,101.92 87.99,100.7 87.99,100.25 86.21,98.48 86.21,94.54 87.44,93.31 88.69,93.31 89.06,92.95 89.06,92.69 88.92,92.55 87.37,92.55 87.23,92.41 87.23,92.13 87.37,91.99 88.92,91.99 89.06,91.86 89.06,90.92 88.92,90.77 87.23,90.77 87,90.54 87,90 87.14,89.86 87.84,89.86 87.98,89.72 87.98,89.44 87.84,89.3 87.14,89.3 87,89.16 87,88.88 87.14,88.74 87.84,88.74 87.98,88.61 87.98,88.33 87.84,88.19 87.14,88.19 87,88.05 87,87.77 87.14,87.63 87.84,87.63 87.98,87.49 87.98,87.21 87.84,87.07 87.14,87.07 87,86.93 87,86.65 87.14,86.51 87.84,86.51 87.98,86.37 87.98,86.09 87.84,85.95 87.14,85.95 87,85.81 87,85.53 87.14,85.39 87.84,85.39 87.98,85.25 87.98,84.97 87.84,84.83 87.14,84.83 87,84.69 87,84.41 87.14,84.27 87.84,84.27 87.98,84.13 87.98,83.86 87.84,83.72 87.14,83.72 87,83.58 87,83.3 87.14,83.16 87.84,83.16 87.98,83.02 87.98,82.74 87.84,82.6 87.14,82.6 87,82.46 87,82.18 87.14,82.04 87.84,82.04 87.98,81.9 87.98,81.62 87.84,81.48 87.14,81.48 87,81.34 87,81.06 87.14,80.92 87.84,80.92 87.98,80.78 87.98,80.5 87.84,80.36 87.14,80.36 87,80.22 87,79.94 87.14,79.8 87.84,79.8 87.98,79.66 87.98,79.38 87.84,79.25 87.14,79.25 87,79.11 87,78.83 87.14,78.69 87.84,78.69 87.98,78.55 87.98,77.99 94.62,71.34 95.05,71.34 ; 75.05,108.81 74.71,108.47 71.11,108.47 70.76,108.81
RLD3_C3_72B_DQ53: length 116.8
  TOP w0.152: U1.K27 104.74,69.34 v2(104.24,69.84) ; U142.N8 v2(69.32,115.17)
  20_SIG7 w0.089: v2(69.32,115.17) 69.82,114.67 70.53,114.67 70.82,114.37 70.82,113.96 71.12,113.67 71.53,113.67 71.82,113.37 71.82,112.96 72.12,112.67 72.53,112.67 72.82,112.37 72.82,111.96 72.82,111.96 72.82,110.96 72.53,110.67 72.12,110.67 71.82,110.37 71.82,109.89 72.05,109.67 72.11,109.67 72.12,109.67 73.53,109.67 73.54,109.67 73.59,109.67 73.82,109.9 73.82,109.95 73.82,109.96 73.82,110.42 74.07,110.67 74.55,110.67 74.82,110.94 74.82,110.96 74.82,111.37 74.82,111.37 74.82,114.39 76.88,116.45 77.34,116.45 77.85,116.96 77.85,119.47 78.04,119.66 79.67,119.66 79.84,119.83 79.84,123.4 ; 95.05,73.34 96.44,73.34 96.74,73.05 96.74,72.64 97.03,72.34 97.44,72.34 97.74,72.05 97.74,71.64 97.95,71.43 97.95,71.43 98.04,71.34 98.44,71.34 98.74,71.05 98.74,70.64 99.03,70.34 103.74,70.34 v2(104.24,69.84) ; 81.82,123.34 81.82,120.98 82.12,120.68 82.65,120.68 82.82,120.51 82.82,109.84 82.39,109.41 82.39,108.81
  20_SIG7 w0.14: 82.39,108.81 82.39,108.36 86.83,103.92 87.26,103.92 87.58,104.24 89.39,104.24 89.63,104 89.63,103.63 89.3,103.3 88.16,103.3 87.97,103.12 87.97,102.76 88.16,102.57 89.41,102.57 89.99,103.16 90.34,103.16 90.52,102.99 90.52,102.7 89.86,102.04 89.86,101.85 89.72,101.71 89.28,101.71 89.12,101.56 89.12,101.14 89.25,101.02 89.72,101.02 89.86,100.88 89.86,100.46 89.72,100.32 89.58,100.32 89.44,100.18 89.44,99.76 89.58,99.62 89.72,99.62 89.86,99.48 89.86,99.18 89.28,98.59 89.28,98.01 89.53,97.76 89.73,97.76 90.42,98.46 90.62,98.46 90.92,98.16 90.92,97.96 90.22,97.27 90.22,97.07 90.91,96.38 90.91,93.65 90.77,93.51 90.31,93.51 90.17,93.37 90.17,92.96 90.31,92.82 90.77,92.82 90.91,92.68 90.91,92.3 90.24,91.63 90.24,77.9 94.8,73.34 95.05,73.34 ; 79.84,123.4 79.84,123.72 79.46,124.1 79.46,125.55 79.81,125.9 80.54,125.9 80.82,125.61 80.82,123.9 81.01,123.71 81.72,123.71 81.82,123.61 81.82,123.34
RLD3_C3_72B_DQ54: length 116
  TOP w0.152: U142.D3 v2(79.32,121.17) ; U1.H27 v2(102.24,69.84)
  18_SIG6 w0.089: 68.91,114.51 69.07,114.67 74.55,114.67 74.85,114.97 74.85,118.41 74.6,118.67 74.12,118.67 73.82,118.96 73.82,119.45 73.6,119.67 73.12,119.67 72.82,119.96 72.82,122.42 73.07,122.67 74.59,122.67 75.59,121.67 79.12,121.67 79.32,121.46 v2(79.32,121.17) ; 94.39,64.98 94.63,64.98 94.93,65.29 95.68,65.29 95.84,65.44 95.84,65.49 96.01,65.67 96.35,65.67 96.53,65.49 96.53,65.44 96.7,65.27 97.04,65.27 97.22,65.44 97.22,65.49 97.39,65.67 97.74,65.67 97.91,65.49 97.91,65.44 98.08,65.27 98.43,65.27 98.6,65.44 98.6,65.49 98.77,65.67 99.12,65.67 99.29,65.49 99.29,65.44 99.46,65.27 99.99,65.27 100.16,65.44 100.16,65.8 100.34,65.97 100.68,65.97 100.85,65.8 100.85,65.44 100.99,65.3 101.95,65.3 102.99,66.34 103.44,66.34 103.74,66.64 103.74,69.05 103.44,69.34 102.99,69.34 102.49,69.84 v2(102.24,69.84)
  18_SIG6 w0.14: 68.91,114.51 68.7,114.29 68.7,113.42 68.36,113.08 68.36,112.85 67.96,112.45 67.86,112.45 66.22,110.82 66.22,104.84 66.4,104.66 66.4,101.6 66.98,101.02 67.84,101.02 68.25,100.61 68.25,99.58 68.69,99.13 71.03,99.13 71.4,98.76 71.4,96.04 72.05,95.39 82.01,95.39 82.7,94.7 82.7,91.82 83.5,91.03 83.5,76.45 83.36,76.31 82.87,76.31 82.73,76.17 82.73,75.76 82.87,75.62 83.36,75.62 83.5,75.48 83.5,75.06 83.36,74.92 82.87,74.92 82.73,74.78 82.73,74.36 82.87,74.22 83.36,74.22 83.5,74.08 83.5,70.28 85.04,68.74 89.97,68.74 93.72,64.98 94.39,64.98
RLD3_C3_72B_DQ55: length 115.5
  TOP w0.152: U1.G27 v2(101.24,69.84) ; U142.E4 v2(78.32,120.17)
  18_SIG6 w0.089: 68.91,112.48 69.1,112.67 69.54,112.67 69.82,112.95 69.82,113.36 70.13,113.67 70.51,113.67 70.82,113.35 70.82,112.85 71,112.67 71.64,112.67 71.82,112.85 71.82,113.37 72.12,113.67 72.55,113.67 72.82,113.4 72.82,112.85 73,112.67 73.62,112.67 73.82,112.87 73.82,113.39 74.1,113.67 74.54,113.67 74.83,113.38 74.83,111.85 75,111.67 75.35,111.67 75.45,111.77 75.45,119.44 75.67,119.67 77.58,119.67 78.08,120.17 v2(78.32,120.17) ; v2(101.24,69.84) 101.24,69.59 101.74,69.09 101.74,68.48 101.6,68.34 101.03,68.34 100.74,68.05 100.74,66.55 100.49,66.3 100.01,66.3 99.65,65.94 95.22,65.94 94.83,65.94 94.39,65.94
  18_SIG6 w0.14: 94.39,65.94 93.86,65.94 88.98,70.82 88.69,70.82 88.59,70.71 88.59,69.64 88.36,69.41 88.03,69.41 87.8,69.64 87.8,71.98 87.6,72.19 87.27,72.19 87.02,71.93 87.02,69.64 86.79,69.41 86.46,69.41 86.23,69.64 86.23,71.38 85.7,71.91 84.55,71.91 84.14,72.32 84.14,91.46 83.52,92.08 83.52,95.5 83.29,95.73 82.62,95.73 82.39,95.96 82.39,96.28 82.62,96.51 83.29,96.51 83.52,96.74 83.52,97.05 83.01,97.55 82.68,97.55 82.17,97.05 81.85,97.05 81.62,97.28 81.62,97.6 82.13,98.11 82.13,98.44 81.48,99.08 71.67,99.08 71.04,99.71 69.94,99.71 69.55,100.1 69.55,100.58 68.39,101.74 67.3,101.74 67.05,101.99 67.05,103.18 67.7,103.82 67.7,105.04 66.87,105.87 66.87,109.74 67.54,110.42 68.4,110.42 68.74,110.76 68.74,112.31 68.91,112.48
RLD3_C3_72B_DQ56: length 112.6
  TOP w0.152: U142.C6 v2(80.32,118.17) ; U1.F28 v2(100.24,70.84)
  18_SIG6 w0.089: 83.59,119.7 83.57,119.67 83.12,119.67 82.83,119.38 82.83,118.95 82.54,118.67 81.05,118.67 80.55,118.17 v2(80.32,118.17) ; 94.39,73.21 94.81,72.78 94.81,72.67 95.13,72.34 99.44,72.34 99.74,72.05 99.74,71.64 100.03,71.34 100.66,71.34 100.74,71.26 100.74,70.92 100.66,70.84 v2(100.24,70.84) ; 83.58,108.81 83.59,108.82
  18_SIG6 w0.14: 83.59,108.82 84.16,109.39 84.16,109.82 83.81,110.17 83.81,110.37 83.8,110.37 83.8,110.61 84.01,110.82 85.53,110.82 85.73,111.03 85.73,111.66 85.6,111.79 84.5,111.79 84.3,112 84.3,112.63 84.52,112.85 85.52,112.85 85.73,113.06 85.73,113.71 85.63,113.81 84.39,113.81 84.25,113.95 84.25,114.58 84.5,114.84 85.57,114.84 85.7,114.97 85.7,115.56 85.47,115.8 85.47,116.11 85.6,116.24 86.17,116.24 86.33,116.4 86.33,116.6 86.18,116.74 85.19,116.74 84.98,116.95 84.98,117.58 85.16,117.76 85.86,117.76 86.39,118.28 86.39,119.3 86.17,119.52 85.94,119.52 85.78,119.36 85.78,118.99 85.59,118.8 84.96,118.8 84.58,118.42 84.15,118.42 83.94,118.63 83.94,119.18 84.32,119.56 84.32,120.5 84.18,120.63 83.97,120.63 83.84,120.5 83.84,119.95 83.59,119.7 ; 94.39,73.21 90.29,77.3 90.29,87.93 91.19,88.83 91.19,89.2 90.9,89.48 90.9,89.85 91.27,90.22 91.64,90.22 92.05,89.82 92.42,89.82 92.79,90.19 92.79,90.56 92.38,90.96 92.38,91.33 92.75,91.7 93.12,91.7 93.55,91.28 93.87,91.28 94.24,91.65 94.24,92.06 93.86,92.44 93.86,92.95 94.1,93.18 94.6,93.18 94.89,92.9 95.26,92.9 95.51,93.16 95.51,96.14 93.44,98.21 92.94,98.21 92.4,98.76 92.4,100.23 91.08,101.54 91.08,101.57 91.07,101.59 91.07,102.33 90.16,103.23 90.16,103.55 90.38,103.77 90.38,104.1 90.15,104.33 89.83,104.33 89.61,104.11 89.28,104.11 89.05,104.34 89.05,104.66 89.27,104.88 89.27,105.21 89.04,105.44 88.72,105.44 88.5,105.22 88.17,105.22 87.84,105.55 87.29,105.55 87.07,105.77 87.07,107.12 86.84,107.34 86.53,107.34 86.3,107.12 86.3,105.77 86.08,105.55 85.77,105.55 85.54,105.77 85.54,109.3 85.31,109.53 84.99,109.53 84.78,109.32 84.78,105.77 84.56,105.55 84.24,105.55 84.02,105.77 84.02,107.44 83.8,107.66 83.49,107.66 83.26,107.43 83.26,105.55 82.89,105.18 81.7,105.18 81.48,105.4 81.48,105.75 82.16,106.42 82.16,107.39 83.58,108.81
RLD3_C3_72B_DQ57: length 112.5
  TOP w0.152: U1.E28 v2(99.24,70.84) ; U142.C4 v2(80.32,120.17)
  18_SIG6 w0.089: 94.39,71.03 94.64,70.77 94.64,70.73 95.03,70.34 98.74,70.34 v2(99.24,70.84) ; v2(80.32,120.17) 80.32,120.58 80.41,120.67 81.64,120.67 81.81,120.5 81.81,119.97 81.51,119.67 81.07,119.67 80.81,119.41 80.81,118.97 80.52,118.68 80.1,118.68 79.82,118.4 79.82,116.48 80.02,116.28 81.66,116.28 81.82,116.13 81.82,115.88 81.6,115.66 80.1,115.66 79.82,115.39 79.82,114.92 80.07,114.67 81.55,114.67 81.82,114.4 81.82,113.9 81.59,113.67 80.1,113.67 79.82,113.4 79.82,112.95 80.1,112.67 81.51,112.67 81.82,112.37 81.82,111.97 81.51,111.66 80.08,111.66 79.82,111.4 79.82,110.91 80.06,110.67 81.53,110.67 81.82,110.38 81.82,109.96 81.53,109.66 81.08,109.66 80.82,109.4 80.82,108.81
  18_SIG6 w0.14: 80.82,108.81 80.82,108.07 80.65,107.89 80.32,107.89 80.04,108.18 79.71,108.18 79.48,107.95 79.48,107.62 79.77,107.34 79.77,107.01 79.17,106.42 79,106.42 78.32,105.74 75.52,105.74 74.73,106.53 72.67,106.53 72.46,106.33 72.46,106.02 72.94,105.54 74.15,105.54 74.9,104.79 78.12,104.79 78.65,104.27 78.65,103.74 78.26,103.35 75.8,103.35 75.61,103.16 75.61,102.7 75.8,102.51 80.12,102.51 80.36,102.75 80.36,103.11 80.59,103.34 80.91,103.34 81.14,103.11 81.14,102.75 81.38,102.51 83.5,102.51 83.73,102.74 83.73,103.21 83.96,103.44 84.28,103.44 84.51,103.21 84.51,102.83 84.72,102.62 85.04,102.62 85.31,102.35 85.31,102.11 85.08,101.88 84.92,101.88 84.69,101.65 84.69,101.32 84.92,101.09 85.08,101.09 85.34,100.83 85.34,99.59 87.15,97.78 91.4,97.78 91.87,97.32 91.87,97.02 91.7,96.86 90.46,96.86 90.27,96.67 90.27,96.14 90.51,95.9 91.23,95.9 91.38,95.75 91.38,95.32 88.98,92.92 88.98,76.43 94.39,71.03
RLD3_C3_72B_DQ58: length 116.3
  TOP w0.152: U142.C2 v2(80.32,122.17) ; U1.H28 v2(102.24,70.84)
  18_SIG6 w0.089: v2(80.32,122.17) 79.82,122.67 79.82,123.39 79.52,123.69 78.45,123.69 78.32,123.82 78.32,124.56 78.14,124.73 77.8,124.73 77.62,124.56 77.62,123.82 77.46,123.66 77.1,123.66 76.93,123.82 76.93,124.56 76.76,124.73 76.42,124.73 76.24,124.56 76.24,123.82 76.07,123.65 75.63,123.65 75.07,124.21 74.02,124.21 73.41,124.82 ; 97.52,90.96 97.52,89.85 96.33,88.66 95.21,88.66 94.39,87.84 ; 94.39,76.09 94.68,75.79 94.68,75.69 95.03,75.34 97.44,75.34 97.74,75.64 97.74,76.05 98.03,76.34 98.44,76.34 98.74,76.05 98.74,75.64 99.03,75.34 99.44,75.34 99.74,75.05 99.74,74.64 100.03,74.34 101.44,74.34 101.74,74.05 101.74,72.53 101.94,72.33 102.44,72.33 102.75,72.64 102.75,73.27 102.85,73.37 103.6,73.37 103.79,73.18 103.79,72.53 103.61,72.35 103.11,72.35 102.77,72.01 102.77,71.5 102.99,71.29 103.59,71.29 103.74,71.14 103.74,70.64 103.44,70.34 102.52,70.34 102.24,70.62 v2(102.24,70.84) ; 90.4,108.46 90.38,108.46 89.73,109.11 89.73,115.53 89.22,116.04 88.71,116.04 88.35,116.41 88.35,116.7 88.72,117.08 88.72,119.56 88.44,119.84 88.03,119.84 87.73,120.14 87.73,120.52 87.43,120.82 86.96,120.82 86.82,120.96
  18_SIG6 w0.14: 94.39,87.84 94.13,87.58 94.13,76.34 94.39,76.09 ; 86.82,120.96 86.74,121.04 86.74,121.59 86.26,122.08 86.26,123.88 84.31,125.82 81.95,125.82 80.6,127.17 79.95,127.17 79.08,128.04 79.08,129.5 78.94,129.64 78.52,129.64 78.38,129.5 78.38,128.66 78.24,128.52 77.82,128.52 77.68,128.66 77.68,129.5 77.54,129.64 77.13,129.64 76.99,129.5 76.99,128.66 76.45,128.12 72.27,128.12 72.13,127.98 72.13,126.59 72.33,126.39 73.08,126.39 73.27,126.2 73.27,124.95 73.41,124.82 ; 97.52,90.96 97.52,97.05 95.93,98.64 95.93,100.38 95.03,101.28 95.03,103.73 94.9,103.86 94.9,104.05 95.47,104.62 95.47,104.82 95.18,105.12 94.98,105.12 94.41,104.55 94.21,104.55 92.08,106.68 91.36,106.68 90.84,107.2 90.84,108.02 90.4,108.46
RLD3_C3_72B_DQ59: length 115.8
  TOP w0.152: U1.G28 v2(101.24,70.84) ; U142.B5 v2(81.32,119.17)
  18_SIG6 w0.089: 83.59,123.4 83.34,123.4 83.06,123.12 83.06,122.63 83.22,122.47 83.22,120.81 82.83,120.41 82.83,119.91 82.58,119.67 82,119.67 81.5,119.17 v2(81.32,119.17) ; 94.39,74.18 94.69,73.87 94.69,73.67 95.02,73.34 99.44,73.34 99.74,73.05 99.74,72.64 100.03,72.34 100.44,72.34 100.74,72.05 100.74,71.64 101.03,71.34 101.33,71.34 101.45,71.22 101.45,70.99 101.3,70.84 v2(101.24,70.84)
  18_SIG6 w0.14: 94.39,74.18 92.75,75.81 92.75,77 92.55,77.2 91.33,77.2 91.1,77.43 91.1,77.76 91.33,77.99 92.5,77.99 92.75,78.24 92.75,78.57 92.55,78.77 91.33,78.77 91.1,79 91.1,79.33 91.33,79.56 92.5,79.56 92.75,79.81 92.75,80.14 92.55,80.34 91.33,80.34 91.1,80.57 91.1,80.9 91.33,81.13 92.5,81.13 92.75,81.38 92.75,81.71 92.55,81.91 91.33,81.91 91.1,82.14 91.1,82.47 91.33,82.7 92.5,82.7 92.75,82.95 92.75,83.28 92.55,83.48 91.33,83.48 91.1,83.71 91.1,84.04 91.33,84.27 92.5,84.27 92.75,84.52 92.75,84.85 92.55,85.05 91.33,85.05 91.1,85.28 91.1,85.61 91.33,85.84 92.5,85.84 92.75,86.09 92.75,86.42 92.55,86.62 91.33,86.62 91.1,86.85 91.1,87.18 91.36,87.43 92.52,87.43 92.65,87.55 92.65,88.3 92.31,88.63 92.31,88.96 92.54,89.19 92.87,89.19 93.2,88.85 93.53,88.85 93.79,89.12 93.79,89.45 93.43,89.8 93.43,90.13 93.66,90.36 93.99,90.36 94.35,90 94.67,90 94.95,90.27 94.95,90.31 94.95,90.93 95.18,91.16 95.85,91.16 96.16,91.47 96.16,96.42 93.72,98.86 93.72,100 92.43,101.3 92.43,101.95 92.31,102.06 92.31,102.39 92.86,102.93 92.86,103.26 92.63,103.49 92.3,103.49 91.76,102.94 91.43,102.94 91.31,103.06 91.31,104.11 91.09,104.32 91.09,104.65 91.12,104.68 91.12,105 90.89,105.23 90.57,105.23 90.54,105.2 90.21,105.2 89.15,106.27 88.83,106.27 88.57,106 88.23,106 88,106.23 88,106.55 88.27,106.82 88.27,107.15 88.14,107.28 88.14,107.79 87.89,108.04 86.43,108.04 86.29,108.18 86.29,108.52 86.44,108.66 88.14,108.66 88.27,108.79 88.27,109.1 88.15,109.21 86.36,109.21 86.15,109.42 86.15,109.63 86.37,109.85 87.47,109.85 87.73,110.11 87.73,110.65 87.57,110.8 86.46,110.8 86.18,111.08 86.18,111.54 86.44,111.81 87.51,111.81 87.73,112.03 87.73,112.59 87.52,112.81 86.45,112.81 86.18,113.08 86.18,113.73 86.28,113.83 87.44,113.83 87.73,114.12 87.73,114.66 87.58,114.81 86.48,114.81 86.26,115.03 86.26,115.41 86.74,115.89 86.74,116.15 86.88,116.29 87.22,116.29 87.37,116.44 87.37,116.65 87.22,116.8 86.93,116.8 86.74,116.99 86.74,119.62 86.44,119.92 84.9,119.92 84.74,120.08 84.74,120.67 85.03,120.96 85.03,121.58 84.9,121.71 84.32,121.71 84.16,121.86 84.16,122.11 84.3,122.25 84.88,122.25 85.02,122.39 85.02,122.8 84.41,123.4 83.59,123.4
RLD3_C3_72B_DQ60: length 113.5
  TOP w0.152: U1.E26 v2(99.24,68.84) ; U142.B3 v2(81.32,121.17)
  18_SIG6 w0.089: v2(81.32,121.17) 81.82,121.67 81.82,123.39 81.52,123.69 81.52,123.91 80.78,124.65 79.88,124.65 79.71,124.82 ; 78.53,124.82 79.32,124.03 80.36,124.03 80.82,123.57 80.82,121.92 80.57,121.67 80.11,121.67 79.82,121.37 79.82,118.94 79.54,118.65 79.12,118.65 78.83,118.36 78.83,116.82 78.69,116.68 77.6,116.68 77.42,116.5 77.42,115.87 77.61,115.69 78.09,115.69 78.57,116.17 79.48,116.17 79.63,116.02 79.63,115.69 79.54,115.6 79.01,115.6 78.82,115.41 78.82,110.84 78.81,110.82 78.81,110.37 78.81,110.37 78.81,109.96 78.81,109.96 78.81,108.81 ; v2(99.24,68.84) 98.74,69.34 94.98,69.34 94.39,69.94
  18_SIG6 w0.14: 94.39,69.94 88.33,76 88.33,92.03 87.99,92.37 87.33,92.37 87.09,92.61 87.09,93.71 86.08,94.72 86.08,97.87 84.14,99.82 84.14,100.73 82.9,101.96 75.43,101.96 74.8,102.59 73.86,102.59 73.81,102.65 73.81,103.02 73.98,103.19 74.55,103.19 74.71,103.36 74.71,104.07 73.89,104.89 72.78,104.89 71.71,105.96 71.71,106.99 71.94,107.22 74.95,107.22 75.48,106.69 78.36,106.69 78.81,107.14 78.81,108.81 ; 78.53,124.82 78.17,125.19 74.24,125.19 73.97,125.46 73.97,126.35 74.19,126.58 75.04,126.58 75.19,126.42 75.19,125.87 75.33,125.73 75.75,125.73 75.89,125.87 75.89,126.45 76.01,126.58 76.43,126.58 76.59,126.42 76.59,125.87 76.73,125.73 77.15,125.73 77.29,125.87 77.29,126.45 77.41,126.58 77.83,126.58 77.99,126.42 77.99,125.87 78.12,125.73 78.8,125.73 79.71,124.82
RLD3_C3_72B_DQ61: length 113.1
  TOP w0.152: U1.E27 v2(99.24,69.84) ; U142.A6 v2(82.32,118.17)
  18_SIG6 w0.089: 83.59,115.65 83.57,115.67 82.08,115.67 81.83,115.41 81.83,114.93 82.08,114.67 83.55,114.67 83.59,114.63 ; 83.59,116.63 83.46,116.49 82.99,116.49 82.82,116.65 81.08,116.65 80.82,116.91 80.82,117.47 81.02,117.67 82.64,117.67 82.77,117.8 82.77,118.07 82.67,118.17 v2(82.32,118.17) ; 83.59,112.67 82.08,112.67 81.82,112.94 81.82,113.42 82.07,113.67 83.57,113.67 83.59,113.68 ; 83.59,111.69 83.57,111.67 82.12,111.67 81.84,111.39 81.84,110.94 82.1,110.68 82.66,110.68 82.82,110.52 82.82,109.74 82.64,109.56 82.15,109.56 81.94,109.36 81.94,108.81 ; v2(99.24,69.84) 99.24,70.13 99.74,70.63 99.74,71.05 99.44,71.34 95.03,71.34 94.64,71.73 94.64,71.86 94.39,72.12
  18_SIG6 w0.14: 83.59,113.68 83.85,113.95 83.85,114.37 83.59,114.63 ; 83.59,111.69 83.85,111.95 83.85,112.45 83.63,112.67 83.59,112.67 ; 83.59,116.63 83.85,116.89 83.85,117.75 84.02,117.92 84.26,117.92 84.54,117.64 84.54,115.9 84.29,115.65 83.59,115.65 ; 94.39,72.12 89.62,76.88 89.62,90.02 90.91,91.3 90.91,91.67 90.09,92.49 90.09,92.86 90.46,93.23 90.83,93.23 91.65,92.41 92.02,92.41 92.39,92.78 92.39,93.15 91.57,93.97 91.57,94.34 91.94,94.71 92.31,94.71 93.13,93.89 93.5,93.89 94.6,94.99 94.6,96.11 93.65,97.05 93.17,97.05 91.79,98.43 87.61,98.43 87.25,98.79 87.25,99.5 87.63,99.88 90.72,99.88 90.92,100.08 90.92,100.8 90.62,101.09 88.52,101.09 88.25,101.36 88.25,101.59 87.99,101.85 87.47,101.85 87.21,101.59 87.21,101.36 86.85,101 86.4,101 86.05,101.35 86.05,102.62 86.31,102.88 88.48,102.88 88.68,103.08 88.68,103.74 87.52,104.9 87.16,104.9 86.9,104.64 86.9,103.97 86.64,103.71 86.11,103.71 85.85,103.97 85.85,104.64 85.59,104.9 83.83,104.9 83.57,104.64 79.28,104.64 78.85,105.07 78.85,105.49 79.14,105.78 80.59,105.78 80.93,106.12 80.93,107.27 81.94,108.28 81.94,108.81
RLD3_C3_72B_DQ62: length 115.1
  TOP w0.152: U1.G25 v2(101.24,67.84) ; U142.A4 v2(82.32,120.17)
  18_SIG6 w0.089: 86.82,120.01 87.01,119.81 87.43,119.81 87.73,119.51 87.73,116.18 88.09,115.82 88.52,115.82 88.73,115.62 88.73,109.08 89.35,108.46 ; v2(82.32,120.17) 82.32,120.17 82.32,120.43 82.87,120.99 82.87,122.39 82.31,122.95 82.31,123.75 82.4,123.84 83.27,123.84 83.42,123.99 83.42,124.33 83.17,124.58 81.63,124.58 81.4,124.82 ; 94.39,75.09 94.39,75.05 94.74,74.7 94.74,74.64 95.03,74.34 99.49,74.34 99.74,74.1 99.74,73.64 100.03,73.34 100.44,73.34 100.74,73.05 100.74,72.64 101.03,72.34 101.44,72.34 101.74,72.05 101.74,69.64 102.03,69.34 102.44,69.34 102.74,69.05 102.74,66.6 101.78,65.64 101.41,65.64 101.1,65.96 101.1,66.23 101.23,66.36 101.6,66.36 101.75,66.5 101.75,67.77 101.68,67.84 v2(101.24,67.84)
  18_SIG6 w0.14: 86.82,120.01 86.67,120.16 86.67,120.51 86.4,120.78 85.96,120.78 85.65,121.08 85.65,122.87 84.98,123.54 84.98,123.66 84.61,124.03 84.41,124.03 83.2,125.24 81.72,125.24 80.51,126.46 79.82,126.46 78.69,127.58 72.89,127.58 72.75,127.44 72.75,127.25 72.9,127.1 78.22,127.1 79.49,125.83 80.38,125.83 81.4,124.82 ; 89.35,108.46 89.58,108.22 89.58,107.16 89.42,106.99 89.42,106.8 89.96,106.26 90.15,106.26 90.25,106.36 90.25,106.47 90.41,106.63 90.61,106.63 91.73,105.51 91.93,105.51 92.1,105.68 92.3,105.68 92.59,105.38 92.59,105.18 92.23,104.82 92.23,104.51 92.44,104.3 92.7,104.3 93.09,104.69 93.29,104.69 93.58,104.39 93.58,104.19 93.41,104.03 93.41,103.83 93.72,103.53 93.72,103.3 93.85,103.17 94.35,103.17 94.49,103.03 94.49,102.61 94.35,102.47 93.85,102.47 93.72,102.33 93.72,101.21 95.11,99.82 95.11,98.44 96.81,96.73 96.81,91.17 96.45,90.8 96.45,90.48 96.82,90.1 96.82,89.78 96.59,89.55 96.27,89.55 95.89,89.92 95.57,89.92 93.49,87.85 93.49,75.98 94.39,75.09
RLD3_C3_72B_DQ63: length 112.1
  TOP w0.152: U1.B28 96.74,70.34 v2(96.24,70.84) ; v2(73.32,120.17) U142.J4
  16_SIG5 w0.089: 68.91,110.8 69.03,110.68 74.52,110.68 74.81,110.96 74.81,115.37 74.31,115.87 74.31,116.49 74.14,116.67 72.11,116.67 71.82,116.95 71.82,119.37 72.12,119.67 72.82,119.67 v2(73.32,120.17) ; v2(96.24,70.84) 96.24,71.12 95.74,71.62 95.74,72.05 95.44,72.34 94.89,72.34 94.39,72.85
  16_SIG5 w0.14: 68.91,110.8 68.73,110.98 68.73,112.98 66.3,115.42 66.3,116.08 66.16,116.22 64.73,116.22 64.59,116.36 64.59,116.78 64.73,116.92 66.16,116.92 66.3,117.06 66.3,117.47 65.92,117.85 65.72,117.85 65.38,117.52 65.19,117.52 64.89,117.81 64.89,118.01 65.23,118.35 65.23,118.54 64.98,118.79 64.03,118.79 63.68,118.43 63.68,117.45 64.06,117.07 64.06,112.12 64.54,111.63 64.54,109.04 67.28,106.3 67.74,106.3 67.88,106.44 67.88,106.46 68.02,106.6 68.44,106.6 68.58,106.46 68.58,106.44 68.72,106.3 69.14,106.3 69.28,106.44 69.28,106.46 69.42,106.6 69.84,106.6 69.98,106.46 69.98,106.44 70.12,106.3 70.24,106.3 70.72,106.78 71.43,106.78 72.5,105.71 78.57,105.71 78.87,105.41 78.87,104.85 79.01,104.71 79.01,104.42 79.01,102.83 79.34,102.5 80.1,102.5 80.35,102.74 80.35,103.06 80.58,103.29 80.9,103.29 81.13,103.06 81.13,102.74 81.4,102.47 82.15,102.47 82.4,102.72 82.66,102.72 82.91,102.47 83.96,102.47 85.34,101.09 85.34,100.03 84.89,99.57 84.89,99.09 85.03,98.95 85.2,98.95 85.34,98.81 85.34,98.39 85.2,98.25 85.03,98.25 84.89,98.11 84.89,97.69 85.03,97.55 85.2,97.55 85.34,97.41 85.34,96.99 85.2,96.85 85.03,96.85 84.89,96.71 84.89,96.29 85.03,96.15 85.2,96.15 85.34,96.01 85.34,95.59 85.2,95.45 85.03,95.45 84.89,95.31 84.89,94.19 85.2,93.89 85.2,93.56 85.06,93.42 85.06,93.1 85.29,92.87 85.62,92.87 85.75,93.01 86.08,93.01 86.31,92.78 86.31,92.45 86.17,92.31 86.17,91.99 86.4,91.76 86.73,91.76 86.97,92 87.28,92 87.63,91.65 87.63,79.27 93.9,72.99 94.25,72.99 94.39,72.85
RLD3_C3_72B_DQ64: length 110.8
  TOP w0.152: v2(95.24,70.84) 95.74,70.34 U1.A28 ; U142.K3 v2(72.32,121.17)
  16_SIG5 w0.089: v2(72.32,121.17) 72.32,120.87 71.82,120.37 71.82,119.96 71.53,119.67 71.12,119.67 70.82,119.37 70.82,117.96 70.51,117.65 70.12,117.65 69.84,117.37 69.84,116.81 69.36,116.33 69.36,115.96 69.66,115.66 72.59,115.66 72.81,115.45 72.81,112.97 72.52,112.68 71.12,112.68 70.81,113 70.81,114.37 70.49,114.68 68.91,114.68
  16_SIG5 w0.14: 68.91,114.68 68.86,114.68 67.76,115.78 67.76,117.68 66.66,118.77 66.66,119.72 66.29,120.1 61.73,120.1 61.65,120.02 60.46,120.02 59.51,119.08 59.51,117.65 60.29,116.88 62.65,116.88 63.02,116.51 63.02,111.68 63.5,111.2 63.5,108.61 65.92,106.19 65.92,104.84 66.13,104.64 66.69,104.64 67.15,105.1 67.73,105.1 68.19,104.64 68.78,104.64 69.24,105.1 69.83,105.1 70.28,104.64 71.68,104.64 71.92,104.41 74.22,104.41 75.24,103.38 77.16,103.38 77.72,102.82 77.72,101.53 78.18,101.08 81.54,101.08 83.33,99.29 83.33,92.85 85.95,90.23 85.95,79.48 85.7,79.23 85.54,79.23 85.27,78.95 85.27,78.48 85.53,78.21 85.69,78.21 85.95,77.95 85.95,77.56 86.27,77.24 87.67,77.24 88.09,76.81 88.09,76.44 88.04,76.38 88.04,76.01 88.41,75.64 88.78,75.64 88.83,75.7 89.2,75.7 89.57,75.33 89.57,74.96 89.52,74.9 89.52,74.53 89.89,74.16 90.26,74.16 90.31,74.22 90.68,74.22 91.05,73.85 91.05,73.48 91,73.42 91,73.05 91.37,72.68 91.74,72.68 91.79,72.74 92.16,72.74 93.91,71 94.66,71 94.82,70.84 v2(95.24,70.84)
RLD3_C3_72B_DQ65: length 111.2
  TOP w0.152: U1.C27 97.74,69.34 v2(97.24,69.84) ; U142.K1 v2(72.32,123.17)
  16_SIG5 w0.089: 72.95,124.82 72.95,123.48 72.84,123.37 72.84,122.97 73.12,122.68 73.49,122.68 73.81,122.37 73.81,121 74.15,120.65 74.52,120.65 74.81,120.37 74.81,120 76.15,118.65 76.52,118.65 76.82,118.35 76.82,111.96 76.82,111.96 76.82,108.82 76.83,108.81 ; 94.39,75.34 95.62,75.34 95.74,75.23 95.74,74.64 96.03,74.34 96.44,74.34 96.74,74.05 96.74,73.64 97.03,73.34 97.44,73.34 97.74,73.05 97.74,72.64 98.03,72.34 98.44,72.34 98.74,72.05 98.74,69.64 98.44,69.34 97.94,69.34 97.44,69.84 v2(97.24,69.84)
  16_SIG5 w0.14: 72.95,124.82 72.95,124.99 71.6,126.34 68.78,126.34 67.38,127.75 66.83,127.75 66,126.91 64.84,126.91 64.48,127.27 64.48,128.44 64.35,128.57 63.54,128.57 63.41,128.44 63.41,127.44 63.27,127.3 62.99,127.3 62.85,127.44 62.85,128.44 62.71,128.57 61.13,128.57 60.99,128.44 60.99,128.19 61.15,128.02 62.18,128.02 62.32,127.88 62.32,127.6 62.18,127.46 61.56,127.46 61.42,127.32 61.42,126.47 61.63,126.25 64.1,126.25 64.62,125.73 65.88,125.73 66.43,125.18 67.67,125.18 68.21,125.73 71.35,125.73 72.32,124.76 v2(72.32,123.17) ; 94.39,75.34 94.1,75.34 89.48,79.96 89.48,93.83 90.27,94.61 90.27,96.29 89.03,97.54 87.31,97.54 86.85,97.99 86.85,99.11 87.92,100.18 87.92,100.81 86.5,102.23 86.5,103.14 81.76,107.87 77.77,107.87 76.83,108.81
RLD3_C3_72B_DQ66: length 111.2
  TOP w0.152: U142.L6 v2(71.32,118.17) ; U1.B27 96.74,69.34 v2(96.24,69.84)
  16_SIG5 w0.089: 94.39,71.91 94.95,71.34 95.44,71.34 95.74,71.05 95.74,70.56 95.96,70.33 96.39,70.33 96.49,70.23 96.49,69.95 96.38,69.84 v2(96.24,69.84) ; v2(71.32,118.17) 71.32,117.86 70.85,117.39 70.85,116.79 70.75,116.68 70.17,116.68 70.01,116.52 70.01,116.11 70.1,116.02 70.81,116.02 71.32,116.54 71.7,116.54 72,116.23 73.71,116.23 73.82,116.12 73.82,111.87 73.62,111.66 70.14,111.66 69.81,112 69.81,113.41 69.54,113.68 68.94,113.68 68.91,113.72
  16_SIG5 w0.14: 68.91,113.72 67.11,115.51 67.11,117.41 65.08,119.44 61.99,119.44 61.42,118.87 60.93,118.87 60.68,118.62 60.68,117.73 61.01,117.4 62.99,117.4 63.54,116.85 63.54,111.9 64.02,111.42 64.02,108.83 67.08,105.77 67.31,105.77 67.32,105.76 70.63,105.76 70.97,106.1 71.37,106.1 72.41,105.06 74.48,105.06 74.92,104.63 75.15,104.63 75.59,105.06 75.94,105.06 76.37,104.63 76.59,104.63 77.02,105.06 77.68,105.06 78.03,104.71 78.37,104.38 78.37,102.2 78.82,101.74 80.29,101.74 80.43,101.88 80.43,101.97 80.57,102.11 80.99,102.11 81.13,101.97 81.13,101.88 81.27,101.74 82.15,101.74 82.3,101.59 82.3,101.06 82.64,100.72 82.86,100.72 83.09,100.95 83.09,101.74 83.26,101.92 83.78,101.92 84.4,101.3 84.4,100.86 84.1,100.56 84.1,99.76 84.35,99.51 84.35,99.07 84.1,98.81 84.1,98.37 84.35,98.11 84.35,97.67 84.1,97.41 84.1,96.97 84.35,96.71 84.35,96.27 84.1,96.01 84.1,95.57 84.35,95.32 84.35,94.87 84.1,94.62 84.1,93.15 86.74,90.5 86.74,79.13 86.93,78.94 86.93,78.61 86.78,78.46 86.78,78.13 87.01,77.9 87.33,77.9 87.49,78.06 87.81,78.06 93.71,72.16 94.13,72.16 94.39,71.91
RLD3_C3_72B_DQ67: length 110.7
  TOP w0.152: U1.B26 96.74,68.34 v2(96.24,68.84) ; U142.L4 v2(71.32,120.17)
  16_SIG5 w0.089: 70.61,123.59 70.82,123.37 70.82,122.96 71.12,122.67 71.53,122.67 71.82,122.37 71.82,121.96 71.53,121.67 70.12,121.67 69.82,121.37 69.82,120.96 70.12,120.67 70.53,120.67 71.03,120.17 v2(71.32,120.17) ; 94.39,67.71 94.56,67.71 94.93,67.34 97.44,67.34 97.74,67.64 97.74,68.05 97.44,68.34 97.03,68.34 96.53,68.84 v2(96.24,68.84)
  16_SIG5 w0.14: 94.39,67.71 91.81,67.71 86.49,73.03 84.97,73.03 84.18,73.82 84.18,74.11 81.61,76.69 81.61,84.76 80.9,85.46 79.37,85.46 73.66,91.17 73.66,94 72.77,94.89 72.41,94.89 71.32,95.99 71.32,98.69 70.67,99.34 65.53,99.34 63.04,101.83 63.04,102.87 60.53,105.38 60.53,106.74 58.46,108.81 58.46,112.18 57.76,112.88 57.76,115.16 57.1,115.82 55.98,115.82 55.63,116.18 55.63,123.67 55.94,123.98 58.83,123.98 59.68,124.84 63.04,124.84 65.1,122.78 66.89,122.78 68.52,124.41 69.78,124.41 70.61,123.59
RLD3_C3_72B_DQ68: length 110.6
  TOP w0.152: U1.A26 95.74,68.34 v2(95.24,68.84) ; U142.L2 v2(71.32,122.17)
  16_SIG5 w0.089: 69.64,123.54 69.81,123.37 69.81,122.95 70.07,122.68 70.51,122.68 71.03,122.17 v2(71.32,122.17)
  16_SIG5 w0.14: 69.64,123.54 69.43,123.74 68.73,123.74 68.5,123.51 68.5,122.48 68.25,122.22 64.31,122.22 62.77,123.77 61.73,123.77 61.31,123.34 61.06,123.34 56.44,123.34 56.15,123.05 56.15,117.59 57.33,116.41 58.55,116.41 59.11,115.85 59.11,115.2 58.92,115.01 58.5,115.01 58.29,114.81 58.29,113.41 58.98,112.73 58.98,109.04 60.74,107.28 62.57,107.28 63.69,106.15 63.69,102.29 64.96,101.03 71.45,101.03 71.87,100.61 71.87,99.35 71.91,99.31 71.91,95.99 72.34,95.55 73.43,95.55 74.22,94.77 74.22,91.32 75.16,90.38 75.53,90.38 76.07,90.93 76.45,90.93 76.82,90.56 76.82,90.19 76.27,89.64 76.27,89.27 76.64,88.9 77.01,88.9 79,90.89 79.35,90.89 79.72,90.52 79.72,90.13 79.48,89.89 79.48,89.52 79.8,89.2 79.8,88.87 79.43,88.5 79.03,88.5 78.74,88.78 78.37,88.78 77.75,88.16 77.75,87.79 79.5,86.04 81.04,86.04 82.3,84.78 82.3,76.77 83.39,75.69 83.52,75.69 85.04,74.16 86.56,74.16 92.24,68.48 94.88,68.48 v2(95.24,68.84)
RLD3_C3_72B_DQ69: length 114.2
  TOP w0.152: U1.D25 98.74,67.34 v2(98.24,67.84) ; U142.M5 v2(70.32,119.17)
  16_SIG5 w0.089: 94.39,70.02 94.71,70.34 95.44,70.34 95.74,70.05 95.74,69.64 96.03,69.34 97.44,69.34 97.74,69.05 97.74,68.64 98.03,68.34 98.62,68.34 98.68,68.28 98.68,67.92 98.6,67.84 v2(98.24,67.84) ; 68.91,117.67 69.6,117.67 69.82,117.89 69.82,118.49 70.32,118.98 v2(70.32,119.17)
  16_SIG5 w0.14: 68.91,117.67 68.67,117.67 67.4,118.94 67.4,119.58 67.72,119.9 67.72,120.6 67.56,120.75 63.83,120.75 63.4,121.18 62.9,121.18 62.76,121.04 62.76,120.79 62.62,120.65 62.2,120.65 62.06,120.79 62.06,121.04 61.92,121.18 60.93,121.18 60.76,121.01 60.76,120.65 60.66,120.55 60.35,120.55 60.22,120.68 60.22,121.08 60.12,121.18 59.75,121.18 59.46,120.9 59.46,120.47 59.28,120.29 58.31,120.29 57.79,119.76 57.79,119.23 58.17,118.85 58.72,118.85 58.99,118.58 58.99,117.44 60.15,116.28 60.15,113.36 60.66,112.85 62.1,112.85 62.5,112.46 62.5,111.47 62.98,110.99 62.98,108.39 64.86,106.52 64.86,102.97 65.52,102.31 65.89,102.31 66.11,102.54 66.11,103.26 66.35,103.5 66.67,103.5 66.88,103.3 66.88,102.54 67.11,102.31 67.43,102.31 67.65,102.54 67.65,103 67.88,103.22 68.2,103.22 68.42,103 68.42,102.54 68.65,102.31 70.79,102.31 72.61,102.31 72.87,102.05 72.87,101.97 73.14,101.7 73.67,101.7 73.92,101.95 73.92,102.25 74.18,102.51 74.7,102.51 74.97,102.25 74.97,101.19 75.13,101.03 75.75,101.03 76.01,101.3 76.01,102.41 76.3,102.69 76.64,102.69 76.97,102.37 76.97,100.86 77.22,100.6 77.22,99.96 77.46,99.71 81.93,99.71 82.45,99.19 82.45,92.16 83.52,91.09 83.52,90.42 83.75,90.19 84.41,90.19 84.64,89.96 84.64,89.63 84.41,89.4 83.75,89.4 83.52,89.17 83.52,88.85 83.75,88.62 84.41,88.62 84.64,88.39 84.64,88.06 84.41,87.83 83.75,87.83 83.52,87.6 83.52,86.44 84.58,85.38 84.58,77.12 84.96,76.75 85.11,76.75 85.11,76.74 85.57,76.74 85.71,76.6 86.49,76.6 93.07,70.02 94.39,70.02
