# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JTAG_TCK: length 456.8
  TOP w0.14: v1(21.98,83.25) J3.6
  TOP w0.152: U19.8 56.3,143.19 56.43,143.32 56.43,143.71 56.3,143.84 U19.7 v1(53.33,143.84) ; U1.AE13 119.74,55.34 v2(120.24,54.84)
  03_SIG1 w0.173: v2(120.24,54.84) 119.71,55.37 118.93,55.37 118.24,56.06 118.24,61.01 117.86,61.39 109.11,61.39 108.71,61 108.71,51.64 108.43,51.36 94.93,51.36 94.68,51.61 88.14,51.61 86.49,53.26 84.71,53.26 84.33,53.64 83.21,53.64 81.79,55.07 81.79,56.36 81.36,56.79 78.03,56.79 74.77,60.06 69.79,60.06 66.99,62.86 66.99,82.15 67.27,82.44 67.27,84.41 66.8,84.89 66.8,96.82 64.26,99.36 64.26,128.32 v1(62.87,129.72) ; v1(21.98,83.25) 19.89,85.34 19.89,86.72 3.51,103.1 3.51,127.76 1.62,129.65 1.62,135.69 2.94,137.01 6.18,137.01 6.34,137.16 v1(6.91,137.16)
  05_SIG2 w0.173: v1(6.91,137.16) 6.91,143.27 8.38,144.74 8.38,155.85 v1(7.87,156.36)
  14_SIG4 w0.089: v2(120.24,54.84) 120.24,54.55 119.74,54.05 119.74,53.64 119.73,53.64 119.73,53.64 119.44,53.35 119.02,53.35 118.46,52.79 118.46,51.92 118.27,51.73 118.27,49.3 118.13,49.15 118.03,49.06 118.03,46.94 117.44,46.34 117.02,46.34 116.73,46.06 116.73,44.62 116.45,44.34 116.03,44.34 115.74,44.05 115.74,40.76 110.74,35.76 110.72,35.76 110.72,32.16 111.39,31.49 111.39,28.84 108.18,25.63 107.09,25.63 104.84,23.38 99.61,23.38 98.06,21.83 91.83,21.83 91.74,21.92 89.25,21.92 87.98,20.65 80.56,20.65 80,21.21 71.91,21.21 70.91,20.21 67.29,20.21 66.56,20.94 66.56,21.93 65.68,22.82 65.68,24.15 64.15,25.68 64.15,29.79 62.06,31.88 61.25,31.88 58.37,34.76 58.37,35.46 57.2,36.63 53.93,36.63 53.34,37.22 51.64,38.92 51.13,39.44 51.13,43.13 50.72,43.53 50.72,58.75 51.1,59.13 51.1,64.36 47.27,68.2 47.27,84.2 46.51,84.97 29.7,84.97 28.97,84.24 26.76,84.24 26.47,83.95 22.69,83.95 v1(21.98,83.25)
  BOTTOM w0.152: R211.2 21.7,90.93 21.86,90.78 21.86,86.21 21.48,85.83 21.48,83.75 v1(21.98,83.25) ; R573.1 v1(7.87,156.36) ; v1(53.33,143.84) 54.11,143.06 54.11,139.75 53.26,138.91 53.26,135.23 51.69,133.65 51.69,128.83 52.36,128.16 56.68,128.16 57.28,128.76 61.02,128.76 61.98,129.72 v1(62.87,129.72) ; R810.1 v1(6.91,137.16)
JTAG_TDI: length 272.6
  TOP w0.152: J3.10 v1(21.98,79.25) ; U1.AD15 118.74,57.34 v2(119.24,56.84)
  05_SIG2 w0.173: v1(21.98,79.25) 21.01,80.22 21.01,85.36 12.91,93.46 12.91,96.28 6.58,102.62 6.58,126.46 7.15,127.03 7.15,127.45 6.52,128.07 6.52,129.67 5.32,130.87 5.32,134.11 6.91,135.69 v1(6.91,136.02) 7.51,136.62 7.51,143.02 8.98,144.49 8.98,157.16 v1(7.87,158.26)
  14_SIG4 w0.089: v2(119.24,56.84) 117.74,55.34 117.03,55.34 116.74,55.05 116.74,52.59 116.48,52.34 115.92,52.34 115.74,52.16 115.74,52.05 115.74,52.05 115.74,49.59 115.49,49.34 115.15,49.34 115.03,49.34 114.74,49.05 114.74,48.96 114.74,47.52 114.56,47.34 114.03,47.34 113.74,47.05 113.74,46.9 113.73,46.9 113.73,46.64 113.44,46.34 112.95,46.34 112.74,46.13 112.74,44.63 112.46,44.36 112.46,44.36 112.44,44.34 112.03,44.34 111.88,44.2 111.88,44.19 111.74,44.05 111.74,42.64 102.61,33.51 102.61,31.21 101.32,29.92 101.32,28.41 97.09,24.18 95.22,24.18 93.27,26.13 89.01,26.13 87.52,24.64 83.33,24.64 81.53,26.44 77.94,26.44 76.26,28.12 71.36,28.12 70.47,29.01 69.51,29.01 68.5,30.01 68.5,30.97 65.99,33.48 65.99,33.93 65.07,34.85 65.07,36.73 60.04,41.77 60.04,45.45 59.61,45.87 59.61,51.76 60.6,52.75 60.6,65.25 59.58,66.27 59.58,73.28 56.4,76.45 56.4,81.33 54.03,83.7 51.93,83.7 46.62,89.02 24.54,89.02 21.3,85.78 21.3,79.93 v1(21.98,79.25)
  BOTTOM w0.152: R574.1 v1(7.87,158.26) ; R811.1 v1(6.91,136.02)
JTAG_TMS: length 365.7
  TOP w0.14: v1(22.01,85.24) 22.01,85.25 J3.4
  TOP w0.152: v1(53.32,145.14) U19.5 56.29,145.14 56.42,145.27 56.42,145.66 56.29,145.79 U19.4 ; U1.AF15 120.74,57.34 v2(121.24,56.84)
  05_SIG2 w0.173: v1(4.76,169.85) 4.76,169.23 8.69,165.29 8.69,164.21 9.98,162.92 9.98,158.7 9.58,158.3 9.58,144.25 8.64,143.31 8.64,140.13 8.08,139.58 8.08,134.76 v1(7.04,133.71) 7.95,132.8 7.95,102.16 13.78,96.33 13.78,94.07 16.62,91.23 19.55,91.23 22.01,88.77 v1(22.01,85.24)
  07_SIG3 w0.173: v1(4.76,169.85) 5.39,170.49 10.17,170.49 15.43,165.23 21.48,165.23 25.98,160.73 40.51,160.73 47.4,153.85 49.65,153.85 52.31,151.19 52.31,150.82 54.62,148.51 54.62,146.44 v1(53.32,145.14)
  14_SIG4 w0.089: v1(22.01,85.24) 23.3,86.53 25.92,86.53 27.19,85.26 29.06,85.26 29.27,85.47 48.44,85.47 49.91,84 49.91,80.64 50.21,80.34 50.21,77.39 52.03,75.58 55.39,75.58 58.44,72.53 58.44,64.45 59.34,63.55 59.34,56.42 59.13,56.21 59.13,53.11 58.49,52.47 58.49,44.88 58.49,44.71 55.48,41.7 54.28,41.7 53.16,40.58 53.16,39.55 54.56,38.15 58.65,38.15 60.52,36.28 60.52,34.63 61.2,33.95 63.19,33.95 64.21,32.94 64.21,32.36 66.96,29.61 66.96,28.87 68.83,27 68.83,25.6 69.32,25.12 70.87,25.12 71.32,24.66 71.32,23.16 71.78,22.71 75.86,22.71 77.18,24.03 80.24,24.03 82.68,21.59 87.53,21.59 89.42,23.48 93.93,23.48 94.64,22.77 97.67,22.77 102.29,27.39 104.95,27.39 106.46,28.9 106.46,29.47 108.82,31.83 108.82,34.6 114.74,40.52 114.74,44.05 115.04,44.34 115.44,44.34 115.73,44.64 115.73,44.82 115.73,46.02 115.74,46.02 115.74,46.05 116.04,46.34 116.44,46.34 116.74,46.64 116.74,47.05 117.03,47.34 117.57,47.34 117.76,47.53 117.76,49.23 118.02,49.49 118.02,51.91 118.17,52.06 118.17,53.48 119.03,54.34 119.44,54.34 119.74,54.64 119.74,56.05 120.03,56.34 120.74,56.34 v2(121.24,56.84)
  BOTTOM w0.14: R575.1 v1(4.76,169.85)
  BOTTOM w0.152: v1(22.01,85.24) 22.36,85.6 22.36,90.91 21.6,91.67 20.21,91.67 19.94,91.41 R212.2 ; R812.1 v1(7.04,133.71)
MASTER_SW_12V: length 12.9
  TOP w0.381: SW1.2 230.27,159.09 ; SW1.2 229.11,159.5 ; SW1.2 230.27,156.76 ; SW1.2 227.53,157.92 ; SW1.2 227.94,156.76 ; SW1.2 229.11,156.35 ; SW1.2 227.94,159.09 ; SW1.2 230.68,157.92
MAXIM_CABLE_B: length 320.8
  TOP w0.152: v1(170.46,94.77) 169.74,95.48 169.74,96.63 168.71,97.66 153.34,97.66 152.68,98.32 151.64,98.32 150.99,97.68 147.13,97.68 146.43,96.98 144.71,96.98 143.64,98.05 142.36,98.05 140.49,96.19 126.62,96.19 124.46,98.34 124.46,105.95 123.88,106.53 118.64,106.53 116.28,104.17 110.19,104.17 109.19,105.16 106.3,105.16 104.55,103.4 90.04,103.4 v1(88.66,102.02) Q27.3
  05_SIG2 w0.173: J39.2 229.69,30.48 229.69,31.11 v1(227.09,33.71)
  20_SIG7 w0.089: v1(227.09,33.71) 229.41,33.71 231.85,36.14 231.85,39.04 225.08,45.81 222.59,45.81 221.56,46.84 221.56,51.29 217.73,55.12 201.99,55.12 197.2,59.92 197.2,60.92 196.28,61.84 193.72,61.84 185.37,70.19 185.37,76.73 181.33,80.77 175.74,80.77 171.78,84.73 171.78,93.44 v1(170.46,94.77)
  BOTTOM w0.152: R327.2 v1(227.09,33.71) ; U109.18 25.1,120.02 25.37,120.29 30.15,120.29 30.48,119.96 30.48,117.45 29.9,116.87 29.9,116.31 28.95,115.37 28.95,114.8 28.04,113.89 26.47,113.89 25.43,112.85 25.43,107.44 28.07,104.8 32.92,104.8 35.26,102.46 42.19,102.46 44.45,104.72 44.45,107.09 45.11,107.75 51.05,107.75 53.25,105.55 53.25,99.05 54.76,97.54 54.76,96.34 55.93,95.17 62.33,95.17 64.06,96.9 64.06,101.19 65.68,102.82 84.38,102.82 85.18,102.02 v1(88.66,102.02)
MAXIM_CABLE_B_SYSCTLR: length 21.4
  TOP w0.152: U111.R11 v5(9.9,131.77)
  18_SIG6 w0.089: v1(23.72,125.4) 23.72,126.61 23.5,126.84 15.87,126.84 14.3,128.4 14.3,128.76 14.09,128.97 12.94,128.97 12.7,129.2 12.7,129.54 12.47,129.77 12.07,129.77 11.9,129.93 11.9,130.31 11.9,130.34 11.67,130.57 11.64,130.57 11.27,130.57 11.1,130.73 11.1,131.14 10.87,131.37 10.3,131.37 v5(9.9,131.77)
  BOTTOM w0.152: U109.3 25.1,125.06 24.77,125.4 v1(23.72,125.4)
MAXIM_CABLE_LS_B: length 81.8
  TOP w0.152: v1(89.15,99.26) 89.13,99.26 89.06,99.32 Q27.2 89.52,100.29 89.69,100.46 89.69,102.49 90.22,103.02 104.67,103.02 106.45,104.8 108.99,104.8 109.98,103.81 116.76,103.81 118.03,102.54 123.52,102.54 123.93,102.13 123.93,98.37 126.11,96.19 126.47,95.83 140.99,95.83 v1(142.7,97.54) ; v2(141.24,82.84) 140.74,82.34 U1.BF40
  20_SIG7 w0.089: v2(141.24,82.84) 140.74,83.34 140.74,90.94 142.7,92.91 v1(142.7,97.54)
  BOTTOM w0.152: v1(89.15,99.26) 89.15,99.38 R105.2
MGT223_REFCLK1_N: length 133.5
  TOP w0.104: v1(56.95,106.21) 57.06,106.32 C244.2 ; U1.J8 v2(103.24,49.84)
  16_SIG5 w0.076: v2(103.24,49.84) 103.24,49.95 103.07,50.11 102.91,50.11 102.84,50.03 102.84,49.23 102.86,49.21 102.86,47.51 102.82,47.48 102.82,44.18 102.86,44.14 102.86,42.3 102.9,42.26 102.9,42.24
  16_SIG5 w0.089: v1(56.95,106.21) 56.63,105.88 55.71,105.88 53.15,103.33 53.15,95.96 56.31,92.8 56.31,85.87 56.81,85.37 56.81,79.9 58.55,78.17 58.55,65.28 59.09,64.74 63.09,60.74 63.09,48.33 64.65,46.77 64.65,44.12 64.43,43.9 64.43,39.63 67.32,36.74 67.32,32.92 68.37,31.88 83.83,31.88 84.96,30.75 91.76,30.75 95.14,34.13 95.75,34.13 102.9,41.28 102.9,42.24
MGT226_CLK0_N: length 5.4
  TOP w0.104: C241.1 J30.1
MGT226_CLK0_P: length 5.4
  TOP w0.104: C243.1 J31.1
MGT226_REFCLK0_N: length 230.4
  TOP w0.104: v1(24.37,101.78) 24.47,101.67 C241.2 ; U1.AG8 v2(122.24,49.84)
  18_SIG6 w0.076: v2(122.24,49.84) 122.24,50.16 122.14,50.25 121.94,50.25 121.85,50.17 121.85,46.71 121.81,46.67 121.81,44.4 121.85,44.36 121.85,42.36 121.83,42.33 121.83,41.41 121.96,41.28 122.01,41.28 122.02,41.26
  18_SIG6 w0.089: 122.02,41.26 122.24,41.05 126.48,41.05 130.05,37.48 130.05,30.16 125.73,25.85 125.73,25.21 121.35,20.83 111.28,20.83 109.17,18.72 105.21,18.72 103.61,20.32 78.97,20.32 78.55,20.74 73.27,20.74 71.47,18.95 61.58,18.95 59.69,20.84 59.69,28.7 58.54,29.86 58.54,30.87 58.92,31.25 58.92,32.68 58.58,33.02 58.58,34.63 56.39,36.82 41.63,36.82 40.59,35.78 36.41,35.78 32.78,39.41 32.78,56.3 31.06,58.02 31.06,67.66 29.39,69.33 29.39,88.49 35.31,94.41 35.31,101.88 33.3,103.89 24.29,103.89 24.04,103.64 24.04,103.51 24.18,103.38 24.22,103.38 24.36,103.24 24.36,102.97 24.22,102.84 24.18,102.84 24.04,102.7 24.04,102.1 v1(24.37,101.78)
MGT226_REFCLK0_P: length 230.3
  TOP w0.104: C243.2 23.33,101.67 v1(23.44,101.78) ; U1.AG9 v2(122.24,50.84)
  18_SIG6 w0.076: v2(122.24,50.84) 122.24,50.53 122.16,50.45 121.86,50.45 121.66,50.25 121.66,46.79 121.61,46.75 121.61,44.31 121.66,44.27 121.66,42.44 121.63,42.41 121.63,41.33 121.81,41.15 121.81,41.08 121.83,41.07
  18_SIG6 w0.089: 121.83,41.07 122.13,40.77 126.36,40.77 129.77,37.36 129.77,30.28 125.45,25.96 125.45,25.33 121.23,21.11 111.16,21.11 109.06,19 105.32,19 103.73,20.59 79.09,20.59 78.66,21.02 73.15,21.02 71.36,19.23 61.7,19.23 59.97,20.96 59.97,28.82 58.82,29.97 58.82,30.76 59.19,31.14 59.19,32.8 58.86,33.13 58.86,34.75 56.51,37.1 41.51,37.1 40.48,36.06 36.53,36.06 33.06,39.53 33.06,56.42 31.34,58.14 31.34,67.77 29.67,69.45 29.67,88.38 35.59,94.3 35.59,102 33.42,104.17 24.18,104.17 23.76,103.75 23.76,102.1 v1(23.44,101.78)
MGT233_CLK1_N: length 5.4
  TOP w0.104: C244.1 J32.1
MGT233_CLK1_P: length 5.4
  TOP w0.104: C245.1 J33.1
MGT233_REFCLK1_P: length 133.4
  TOP w0.104: U1.J9 v2(103.24,50.84) ; C245.2 57.06,105.17 v1(56.95,105.28)
  16_SIG5 w0.076: 102.62,42.24 102.62,42.26 102.66,42.3 102.66,44.06 102.62,44.1 102.62,47.56 102.66,47.6 102.66,49.13 102.64,49.15 102.64,50.11 102.83,50.31 103.14,50.31 103.24,50.41 v2(103.24,50.84)
  16_SIG5 w0.089: v1(56.95,105.28) 56.63,105.61 55.82,105.61 55.36,105.14 55.36,105.02 55.44,104.94 55.44,104.81 55.31,104.69 55.19,104.69 55.11,104.77 54.98,104.77 54.86,104.64 54.86,104.52 54.94,104.44 54.94,104.31 54.81,104.19 54.68,104.19 54.61,104.26 54.48,104.26 53.43,103.21 53.43,96.08 56.59,92.92 56.59,85.99 57.09,85.48 57.09,80.02 58.83,78.28 58.83,65.4 63.37,60.86 63.37,48.45 64.93,46.89 64.93,44.01 64.71,43.79 64.71,39.75 67.6,36.85 67.6,33.03 68.48,32.16 83.95,32.16 85.07,31.03 91.64,31.03 95.03,34.41 95.63,34.41 102.62,41.4 102.62,42.24
MGT_SI570_CLOCK1_C_N: length 37.9
  TOP w0.104: C10.1 107.15,29.11 v1(107.38,29.34) ; v2(124.24,49.84) U1.AJ8
  20_SIG7 w0.076: v2(124.24,49.84) 124.24,50.22 124.31,50.3 124.54,50.3 124.62,50.22 124.62,46.32 124.66,46.28 124.66,44.41 124.62,44.36 124.62,40.99 124.58,40.95 124.58,40.93
  20_SIG7 w0.089: 124.58,40.93 124.58,40.59 123.79,39.8 111.96,39.8 106.96,34.8 106.96,32.07 107.68,31.35 107.68,29.51 107.52,29.34 v1(107.38,29.34)
MGT_SI570_CLOCK1_C_P: length 38
  TOP w0.104: C9.1 108.29,29.11 108.13,29.27 v1(108.13,29.34) ; v2(124.24,50.84) U1.AJ9
  20_SIG7 w0.076: 124.86,40.93 124.86,40.95 124.82,40.99 124.82,44.28 124.86,44.32 124.86,46.37 124.82,46.41 124.82,50.3 124.62,50.49 124.31,50.49 124.24,50.57 v2(124.24,50.84)
  20_SIG7 w0.089: v1(108.13,29.34) 107.96,29.52 107.96,31.46 107.24,32.18 107.24,34.68 112.08,39.52 123.91,39.52 124.86,40.47 124.86,40.93
MGT_SI570_CLOCK1_N: length 4.1
  TOP w0.104: U104.12 105.64,25.96 105.77,26.09 105.77,26.72 106.17,27.13 107.42,27.13 107.54,27.25 107.54,27.41 107.27,27.68 C10.2
MGT_SI570_CLOCK1_P: length 4.1
  TOP w0.104: U104.11 106.14,25.91 105.99,26.06 105.99,26.63 106.27,26.9 107.51,26.9 107.77,27.16 107.77,27.28 108.18,27.68 C9.2
MGT_SI570_CLOCK2_C_N: length 25.7
  TOP w0.104: C1398.1 104.42,28.77 104.42,29.15 v1(104.34,29.22) ; v2(109.24,49.84) U1.R8
  16_SIG5 w0.076: 109.58,42.34 109.58,42.36 109.62,42.4 109.62,44.42 109.66,44.46 109.66,47.36 109.62,47.39 109.62,49.38 109.64,49.4 109.64,50.28 109.53,50.38 109.3,50.38 109.24,50.31 v2(109.24,49.84)
  16_SIG5 w0.089: v1(104.34,29.22) 104.58,29.45 104.58,30.51 105.38,31.31 105.38,35.78 107.74,38.14 109.58,39.99 109.58,42.34
MGT_SI570_CLOCK2_C_P: length 25.7
  TOP w0.104: v1(105.09,29.22) 105.09,28.96 C1397.1 ; v2(109.24,50.84) U1.R9
  16_SIG5 w0.076: v2(109.24,50.84) 109.5,50.58 109.62,50.58 109.84,50.36 109.84,49.32 109.82,49.3 109.82,47.48 109.85,47.44 109.85,44.38 109.82,44.34 109.82,42.4 109.86,42.36 109.86,42.34
  16_SIG5 w0.089: v1(105.09,29.22) 104.86,29.45 104.86,30.4 105.66,31.19 105.66,35.67 107.93,37.95 109.86,39.87 109.86,42.34
MGT_SI570_CLOCK2_N: length 4.7
  TOP w0.104: U104.14 104.46,24.12 104.32,24.25 104.12,24.25 103.89,24.49 103.89,25.14 104.55,25.8 104.55,27.24 C1398.2
MGT_SI570_CLOCK2_P: length 4.7
  TOP w0.104: U104.13 104.45,24.62 104.31,24.48 104.21,24.48 104.11,24.58 104.11,25.04 104.77,25.7 104.77,27.25 105.09,27.57 C1397.2
MGT_SI570_CLOCK3_C_N: length 27.8
  TOP w0.104: v2(105.24,49.84) U1.L8 ; v1(101.99,29.27) 102.26,28.99 102.26,28.87 102.16,28.77 101.83,28.77 101.65,28.59 101.65,28.38 C89.1
  16_SIG5 w0.076: 105.58,42.21 105.58,42.23 105.62,42.27 105.62,44.49 105.63,44.5 105.63,45.65 105.66,45.68 105.66,47.34 105.62,47.38 105.62,49.11 105.63,49.12 105.63,50.08 105.52,50.19 105.31,50.19 105.24,50.11 v2(105.24,49.84)
  16_SIG5 w0.089: v1(101.99,29.27) 102.23,29.51 102.23,30.02 99.87,32.38 99.87,34.75 102.93,37.81 105.58,40.46 105.58,42.21
MGT_SI570_CLOCK3_C_P: length 28.3
  TOP w0.104: v2(105.24,50.84) U1.L9 ; v1(102.84,29.27) 102.49,28.91 102.49,28.78 102.25,28.54 101.93,28.54 101.88,28.49 101.88,28.38 C88.1
  16_SIG5 w0.076: 105.86,42.21 105.86,42.23 105.82,42.27 105.82,44.41 105.83,44.42 105.83,45.57 105.85,45.6 105.85,47.42 105.82,47.46 105.82,49.03 105.83,49.04 105.83,50.16 105.61,50.38 105.32,50.38 105.24,50.47 v2(105.24,50.84)
  16_SIG5 w0.089: 105.86,42.21 105.86,40.34 103.13,37.62 100.15,34.63 100.15,32.49 102.51,30.13 102.51,29.6 v1(102.84,29.27)
MGT_SI570_CLOCK3_N: length 6.2
  TOP w0.104: C89.2 101.53,26.92 101.65,26.8 101.65,26.39 101.88,26.16 102.57,26.16 103.17,25.55 103.17,24.4 104.46,23.12 U104.16
MGT_SI570_CLOCK3_P: length 5.7
  TOP w0.104: C88.2 101.95,26.92 101.88,26.85 101.88,26.49 101.97,26.39 102.66,26.39 103.4,25.65 103.4,24.52 104.3,23.62 U104.15
MGTAVCC: length 13.8
  TOP w0.152: v1(137.2,130.67) 137.02,130.49 136.78,130.49 R114.2 ; R1204.2 133.03,134.19 133.18,134.34 134.11,134.34 134.93,135.16 v1(134.93,135.3)
  BOTTOM w0.152: v1(137.2,130.67) 137.42,130.45 138.15,130.45 138.86,131.17 138.86,133.78 137.17,135.48 135.11,135.48 v1(134.93,135.3)
MGTAVCC_A3_IN: length 12.3
  TOP w0.152: R1274.2 164.65,130.46 C1698.1 163.64,132 v1(164.02,132.38) 164.69,133.05 U166.30
  BOTTOM w0.152: C1698.1 163.64,131.87 164.02,132.25 v1(164.02,132.38) 163.56,132.83 161.42,132.83 160.87,133.39 160.87,135.15 R1227.1
MGTAVCC_FPGA: length 230.2
  TOP w0.152: v1(134.93,136.06) 134.42,135.54 134.42,135.15 134.03,134.76 133.18,134.76 133.03,134.92 R1204.1 ; R113.2 136.78,130.09 137.02,130.09 v1(137.2,129.91)
  TOP w0.381: v2(127.24,49.84) U1.AM8 ; v1(127.28,33.86) 127.89,33.86 128.65,33.1 C1516.1 ; U1.AD11 v2(119.24,52.84) ; U1.AL39 125.74,81.34 v2(126.24,81.84) ; C1548.1 91.77,99.36 v1(91.64,99.24) ; v1(99.52,99.23) 99.39,99.36 C628.1 ; v2(113.24,78.84) U1.W36 ; v1(85.34,86.07) 85.28,86.07 85.19,86.16 C590.1 ; v2(114.24,79.84) U1.Y37 ; C622.1 109.98,32.81 v1(109.98,33.17) ; C1549.1 90.5,99.31 v1(90.45,99.25) ; v2(116.24,79.84) U1.AB37 ; v2(113.24,51.84) U1.W10 ; v1(114.19,107.48) 114.19,106.35 C1733.1 115.98,106.36 v1(115.98,107.47) ; v1(119.79,32.27) 119.79,32.15 119.51,31.87 C630.1 ; U1.AH8 v2(123.24,49.84) ; 131.88,137.93 J109.1 ; J109.1 132.69,139.8 ; J109.1 133.49,139.54 ; J109.1 133.75,138.74 ; J109.1 133.49,137.93 ; J109.1 132.69,137.67 ; J109.1 131.88,139.54 ; J109.1 131.62,138.74 ; U1.AT8 v2(131.24,49.84) ; v1(85.61,48.52) 85.27,48.18 C596.1 C1474.1 ; U1.P9 v2(108.24,50.84) ; v2(115.24,51.84) U1.AA10 ; U1.AC36 v2(117.24,78.84) ; U1.M8 v2(106.24,49.84) ; U1.P40 108.74,82.34 v2(108.24,82.84) ; U1.U38 111.74,80.34 v2(111.24,80.84) ; v2(128.24,51.84) U1.AN10 ; v1(100.99,99.24) 100.96,99.26 C1520.1 ; U1.K9 v2(104.24,50.84) ; U1.AC39 117.74,81.34 v2(117.24,81.84) ; U1.AF37 v2(121.24,79.84) ; C618.1 v1(118.11,31.91) ; v1(98.02,99.24) 98.12,99.34 C1547.1 ; U1.AD37 v2(119.24,79.84) ; v2(124.24,80.84) 123.74,80.34 U1.AJ38 ; U1.AG10 v2(122.24,51.84) ; v2(112.24,79.84) U1.V37 ; U1.AF11 v2(121.24,52.84) ; U1.AE10 v2(120.24,51.84) ; v2(129.24,82.84) 128.74,82.34 U1.AP40 ; v1(85.62,50.22) 85.12,50.72 C602.1 C1505.1 ; v2(129.24,50.84) U1.AP9 ; v1(117.17,108.36) 118.61,108.36 C903.1 118.25,109.79 v1(117.17,109.79) ; v2(114.24,49.84) U1.Y8 ; v1(117.38,127.69) 118.5,127.69 C1740.1 118.51,125.91 v1(117.47,125.91) ; U1.AE36 v2(120.24,78.84) ; U1.AG37 v2(122.24,79.84) ; v2(115.24,78.84) U1.AA36 ; U1.AR10 v2(130.24,51.84) ; v2(126.24,51.84) U1.AL10 ; v2(116.24,50.84) U1.AB9 ; U1.AJ10 v2(124.24,51.84) ; v2(117.24,51.84) U1.AC10 ; v2(125.24,50.84) U1.AK9
  05_SIG2 w0.191: v2(119.24,52.84) 118.62,53.46 118.62,59.42 117.65,60.39 104.95,60.39 104.74,60.61 104.74,61.07 105.01,61.34 105.45,61.34 105.74,61.63 105.74,62.06 106.02,62.34 112.51,62.34 112.74,62.57 112.74,80.07 112.44,80.37 111.99,80.37 111.74,80.62 111.74,82.07 111.98,82.31 117.71,82.31 118.72,81.3 118.72,80.61 118.99,80.34 121.54,80.34 121.73,80.54 121.73,86.99 122.04,87.29 125.31,87.29 125.7,87.69 125.7,89.38 v2(125.24,89.84)
  11_PWR2 w0.381: 131.88,139.54 J109.1 ; J109.1 133.49,139.54 ; J109.1 132.69,139.8 ; J109.1 132.69,137.67 ; J109.1 133.49,137.93 ; J109.1 133.75,138.74 ; J109.1 131.62,138.74 ; J109.1 131.88,137.93
  BOTTOM w0.152: v1(134.93,136.06) 135.11,135.88 137.34,135.88 139.26,133.95 139.26,130.86 138.46,130.05 137.34,130.05 v1(137.2,129.91)
  BOTTOM w0.191: v2(125.24,89.84) 130.28,94.88 130.28,102.03 130.66,102.41 131.32,102.41 ; 131.32,102.41 131.32,101.7 131.14,101.52 131.14,94.12 126.74,89.72 126.74,86.62 126.51,86.39 126.05,86.39 125.75,86.09 125.75,85.63 125.47,85.35 125.01,85.35 124.74,85.08 124.74,81.62 124.46,81.34 123,81.34 122.74,81.08 122.74,80.6 122.48,80.34 121.81,80.34 121.8,80.34 121.73,80.34 v2(121.24,79.84) ; 131.32,102.41 Z132.2
  BOTTOM w0.381: v1(114.19,107.48) 114.19,106.35 C1733.1 115.98,106.36 v1(115.98,107.47) ; v1(99.52,99.23) 99.52,99.34 99.39,99.47 C628.1 ; v1(100.99,99.24) 100.96,99.26 C1520.1 ; C1480.1 v1(108.73,99.25) ; v1(127.28,33.86) 127.89,33.86 128.65,33.1 C1516.1 ; v1(117.17,109.79) 118.25,109.79 C903.1 118.61,108.36 v1(117.17,108.36) ; v1(98.02,99.24) 98.12,99.34 C1547.1 ; v1(109.98,33.17) 109.98,32.81 C622.1 ; v1(117.38,127.69) 118.5,127.69 C1740.1 118.51,125.91 v1(117.47,125.91) ; v1(118.11,31.91) C618.1
  vias: v1(94.77,32.86) v1(95.87,32.86) v1(97.35,32.91) v1(98.67,33.02) v1(125.98,137.21) v1(125.98,135.69) v1(127.51,137.21) v1(127.51,135.69) v1(129.03,141.78) v1(129.03,140.26) v1(129.03,138.73) v1(129.03,137.21) v1(129.03,135.69) v1(130.56,141.78) v1(130.56,140.26) v1(130.56,138.73) v1(130.56,137.21) v1(132.08,141.78) v1(132.08,140.26) v1(133.6,141.78) v1(133.6,140.26)
MGTAVCC_FPGA_SNS_N: length 63.3
  TOP w0.104: v1(170.59,132.03) 170.56,132.03 170.56,132.01 170.21,132.36 168.15,132.36 167.32,133.19 167.32,133.43 167.19,133.57 U166.35
  07_SIG3 w0.135: v1(170.59,132.03) 170.56,132.03 170.43,132.16 170.43,132.21 170.29,132.34 168.49,132.34 166.6,130.45 166.6,117.6 165.39,116.39 163.82,116.39 160.34,112.91 158.45,112.91 153.22,107.68 144.47,107.68 142.95,106.16 139.37,106.16 134.87,101.67 134.54,101.67 v1(134.22,101.34)
  BOTTOM w0.104: v1(134.22,101.34) 133.87,101.69 133.6,101.69 133.09,101.18 Z133.1
MGTAVCC_FPGA_SNS_P: length 141
  TOP w0.104: U166.36 167.69,133.57 167.55,133.43 167.55,133.28 168.25,132.59 170.21,132.59 v1(170.56,132.94) ; U37.8 132.83,129.53 v1(132.34,130.01) 131.6,130.76 131.6,132.07 131.6,132.1 131.6,133.27 130.12,134.75 125.55,134.75 124.87,135.43 124.87,137.57 125.42,138.12 127.43,138.12 128.51,139.19 128.51,142.45 129.29,143.23 137.15,143.23 138.17,144.25 141.93,144.25 144.69,147.01 166.4,147.01 v1(167.34,146.08)
  03_SIG1 w0.135: v1(170.56,132.94) 170.56,138.73 170.97,139.14 170.97,142.44 v1(167.34,146.08)
  07_SIG3 w0.135: v1(170.56,132.94) 170.43,132.8 170.43,132.76 170.29,132.62 168.38,132.62 166.32,130.56 166.32,117.72 165.27,116.67 163.7,116.67 160.23,113.19 158.33,113.19 153.1,107.96 144.35,107.96 142.84,106.44 139.25,106.44 134.76,101.95 134.54,101.95 v1(134.22,102.27)
  BOTTOM w0.104: v1(134.22,102.27) 133.87,101.92 133.58,101.92 Z132.1
MGTAVCC_FPGA_VIN: length 2.8
  TOP w0.14: C158.1 134.47,129.79 134.23,130.03 U37.9
  TOP w0.152: C158.1 135.35,130.09 135.84,130.09 R113.1
MGTAVCC_ISENSE2: length 20.6
  TOP w0.152: v1(149.72,135.97) 148.86,136.83 148.55,136.83 148.26,137.12 U163.15
  07_SIG3 w0.173: v1(161.76,134.66) 151.33,134.66 150.02,135.97 v1(149.72,135.97)
  BOTTOM w0.152: v1(161.76,134.66) 162.76,135.67 R1227.2 163.37,136.04 163.54,136.22 163.54,138.18 163.27,138.46 R1271.2
MGTAVCC_PGOOD: length 86.5
  TOP w0.254: U166.24 v1(160.32,136.69)
  TOP w0.381: D11.1 v1(197.79,171.56)
  03_SIG1 w0.381: v1(197.79,171.56) 197.79,170.28 198.63,169.44 198.63,156.91 204.79,150.74 v1(205.59,150.74)
  07_SIG3 w0.381: v1(160.32,136.69) 160.95,136.69 164.91,140.64 164.91,141.67 170.22,146.99 191.69,146.99 192.84,145.85 194.87,145.85 195.25,145.47 201.09,145.47 203.7,148.08 203.7,148.86 v1(205.59,150.74)
  BOTTOM w0.254: RP3.8 201.62,152.65 202.17,152.1 202.17,151.71 203.13,150.74 U51.7
  BOTTOM w0.381: U51.7 v1(205.59,150.74)
MGTAVCC_PWM2: length 24.6
  TOP w0.152: v1(145.5,138.27) 145.66,138.43 147.05,138.43 147.26,138.22 U163.13 ; U166.17 v1(164.19,141.31)
  07_SIG3 w0.173: v1(164.19,141.31) 162.21,141.31 160.98,142.53 157.01,142.53 156.17,141.7 151.85,141.7 149.65,139.5 146.73,139.5 v1(145.5,138.27)
MGTAVCC_SLAVE_1V8: length 37.4
  TOP w0.381: C1620.1 158.63,128.23 157.83,129.04 C1675.1 157.84,129.89 R1232.1 157.88,131.49 C1676.1 157.88,135.1 L98.1 157.82,136.61 v1(157.91,136.7) ; C1681.1 144.21,138.97 v2(144.56,138.62) 144.58,138.61 144.58,138 145.11,137.46 145.67,137.46 145.89,137.69 U163.11
  14_SIG4 w0.381: v2(144.56,138.62) 144.56,137.4 149.06,132.9 154.11,132.9 v1(157.91,136.7)
  BOTTOM w0.152: R1212.1 144.56,137.63 v2(144.56,138.62)
MGTAVCC_TS_FAULTB: length 15.1
  TOP w0.152: v1(162.76,140.36) 162.76,139.22 U166.19
  03_SIG1 w0.173: v1(153.39,135.87) 153.39,137.41 154.46,138.48 156.94,138.48 158.36,139.9 160.26,139.9 160.72,140.36 v1(162.76,140.36)
  BOTTOM w0.152: C1718.1 v1(162.76,140.36) ; R1279.1 v1(153.39,135.87)
MGTAVCC_VDD_MASTER: length 26.5
  TOP w0.254: U166.8 169.33,138.69 169.63,138.98 v1(169.99,138.98)
  TOP w0.381: v1(156.09,131.71) 156.34,131.45 R1232.2 156.84,132.43 C1676.2
  14_SIG4 w0.381: v1(169.99,138.98) 169.34,138.98 168.12,137.76 168.12,135.4 166.32,133.6 163.11,133.6 161.21,131.71 v1(156.09,131.71)
  BOTTOM w0.254: C1603.1 169.22,139.75 v1(169.99,138.98)
  BOTTOM w0.381: C1603.1 169.22,140.46 C1674.1 169.85,141.18 R1200.1
MGTAVCC_VIN: length 2.8
  TOP w0.14: C158.2 134.45,130.79 134.19,130.53 U37.10
  TOP w0.152: R114.1 135.84,130.49 135.35,130.49 C158.2
MGTAVCC_VIN_UV: length 3.8
  TOP w0.152: v1(165.67,141.14) 165.69,141.12 U166.14
  BOTTOM w0.152: C1717.1 R1221.1 165.69,141.12 v1(165.67,141.14) 165.69,141.16 R1218.2
MGTAVTT: length 22.1
  TOP w0.152: v1(180.6,76.27) 180.42,76.08 180.42,75.02 180.57,74.87 R1203.2 ; R112.2 172.61,72 172.61,72.24 v1(172.44,72.42)
  03_SIG1 w0.152: v1(180.6,76.27) 180.55,76.22 180.55,70.02 178.23,67.69 175.98,67.69 175.35,68.33 174.17,68.33 172.5,70 172.5,72.35 v1(172.44,72.42)
MGTAVTT_A3_IN: length 12.4
  TOP w0.152: R1273.2 171.84,48.21 171.84,48.23 C1694.1 172.85,48.73 173.18,48.4 v1(173.18,48.36) 173.18,47.78 173.53,47.42 174.18,47.42 174.43,47.67 U165.30
  BOTTOM w0.152: R1226.1 175.03,51.03 176.15,49.91 176.15,49.28 175.56,48.69 173.51,48.69 v1(173.18,48.36) 172.81,48.73 C1694.1
MGTAVTT_FPGA: length 388.7
  TOP w0.152: v1(173.2,72.42) 173.02,72.24 173.02,72 R111.2 ; v1(179.84,76.27) 179.99,76.12 179.99,75.02 179.84,74.87 R1203.1 ; Z130.2 v1(138.56,30.91)
  TOP w0.381: v1(143.64,32.82) C1475.1 ; R1326.2 82.94,42.24 v4(81.96,42.24) ; v1(127.38,30.4) 127.78,30 127.78,28.78 ; U1.AV4 132.74,46.34 v2(133.24,45.84) ; U1.AY5 v2(135.24,46.84) ; 172.16,74.73 J108.1 ; J108.1 172.42,75.53 ; J108.1 174.29,74.73 ; J108.1 172.42,73.92 ; J108.1 174.03,75.53 ; J108.1 174.03,73.92 ; J108.1 173.23,75.79 ; J108.1 173.23,73.66 ; v1(106.18,33.47) 106.23,33.47 106.64,33.06 106.64,31.95 C1751.1 107.76,32.01 v1(107.76,32.76) ; v2(128.24,84.84) 127.74,84.34 U1.AN42 ; U1.BB4 136.74,46.34 v2(137.24,45.84) ; U1.L40 105.74,82.34 v2(105.24,82.84) ; U1.AJ6 v2(124.24,47.84) ; U1.U6 v2(111.24,47.84) ; U1.B5 v2(96.24,46.84) ; C619.1 96.84,101.57 v1(97,101.72) ; U1.BF42 140.74,84.34 v2(141.24,84.84) ; U1.AM5 v2(127.24,46.84) ; v2(111.24,84.84) 111.74,84.34 U1.U42 ; U1.E42 v2(99.24,84.84) ; v2(106.24,45.84) 106.74,46.34 U1.M4 ; 127.78,28.78 127.67,28.78 126.81,29.65 126.81,29.78 v1(126.85,29.82) ; 127.78,28.78 C1750.1 ; v1(84.25,44.26) 84.85,44.86 84.85,45.37 C1519.1 ; v2(138.24,85.84) U1.BC43 ; v2(102.24,45.84) 102.74,46.34 U1.H4 ; U1.AU6 v2(132.24,47.84) ; U1.R7 v2(109.24,48.84) ; U1.Y41 v2(114.24,83.84) ; U1.AF40 120.74,82.34 v2(121.24,82.84) ; U1.A42 95.74,84.34 v2(95.24,84.84) ; v2(132.24,84.84) 131.74,84.34 U1.AU42 ; U1.AM41 126.74,83.34 v2(127.24,83.84) ; U1.BA42 135.74,84.34 v2(136.24,84.84) ; v2(115.24,47.84) U1.AA6 ; v2(117.24,48.84) U1.AC7 ; v2(119.24,83.84) 118.74,83.34 U1.AD41 ; v2(101.24,85.84) U1.G43 ; v1(150.62,83.48) 151.4,82.7 153.47,82.7 154.74,81.43 167.69,81.43 168.38,80.74 168.38,70.54 168.74,70.18 168.74,68.13 168.25,67.64 168.25,58.86 167.5,58.1 160.24,58.1 155.76,53.62 150.88,53.62 146.12,48.86 146.12,41.14 136.98,32 136.98,30.33 137.39,29.92 139.24,29.92 139.58,30.26 Z130.2 ; U1.N5 v2(107.24,46.84) ; U1.B44 v2(96.24,86.84) ; U1.AH41 122.74,83.34 v2(123.24,83.84) ; U1.AB40 v2(116.24,82.84) ; v1(126.89,102.47) 126.89,103.06 C1748.1 126.09,103.82 125.36,103.1 125.36,102.1 125.71,101.75 v1(126.82,101.75) ; v2(96.24,44.84) 96.74,45.34 U1.B3 ; U1.N6 v2(107.24,47.84) ; U1.BE3 v2(140.24,44.84) ; U1.AL4 v2(126.24,45.84) ; C1506.1 134.75,32.61 134.95,32.82 v1(135.56,32.82) 135.79,32.82 136.02,32.59 C1515.1 ; v2(98.24,45.84) 98.74,46.34 U1.D4 ; U1.AP4 v2(129.24,45.84) ; U1.J42 v2(103.24,84.84) ; U1.AK40 124.74,82.34 v2(125.24,82.84) ; v2(126.24,85.84) U1.AL43 ; U1.V40 v2(112.24,82.84) ; U1.N42 107.74,84.34 v2(107.24,84.84) ; v1(94.41,99.24) 94.31,99.34 C589.1 C1479.1 93.04,99.36 93.01,99.34 v1(93.01,99.24) ; U1.AJ42 123.74,84.34 v2(124.24,84.84) ; U1.BD5 v2(139.24,46.84) ; v2(100.24,46.84) U1.F5 ; U1.C45 v2(97.24,87.84) ; v2(101.24,48.84) U1.G7 ; U1.T41 110.74,83.34 v2(110.24,83.84) ; U1.BF4 v2(141.24,45.84) ; U1.AT5 v2(131.24,46.84) ; U1.AR43 v2(130.24,85.84) ; C1518.1 v1(85.34,84.89) ; v2(140.24,86.84) U1.BE44 ; v2(126.24,48.84) U1.AL7 ; U1.K5 v2(104.24,46.84) ; U1.BD3 v2(139.24,44.84) ; U1.C43 v2(97.24,85.84) ; U1.L43 v2(105.24,85.84) ; U1.AE6 v2(120.24,47.84) ; U1.AR7 v2(130.24,48.84) ; v2(128.24,47.84) U1.AN6 ; U1.A5 v2(95.24,46.84) ; v2(103.24,47.84) U1.J6 ; U1.AG7 v2(122.24,48.84) ; v2(112.24,85.84) U1.V43 ; U1.AW43 v2(134.24,85.84) ; C1481.1 v1(142.37,32.82) ; U1.L7 v2(105.24,48.84) ; v2(113.24,48.84) U1.W7 ; U1.R43 v2(109.24,85.84) ; U1.AH43 v2(123.24,85.84) ; U1.BE42 139.74,84.34 v2(140.24,84.84)
  03_SIG1 w0.152: v1(173.2,72.42) 173.16,72.38 173.16,70.27 174.44,68.99 175.62,68.99 176.25,68.35 177.95,68.35 179.89,70.29 179.89,76.22 v1(179.84,76.27)
  12_PWR3 w0.152: 107.03,65.87 106.75,65.59 106.75,60.54 106.52,60.31 105.99,60.31 105.77,60.09 105.77,59.52 105.56,59.31 105.06,59.31 104.75,59 104.75,51.61 104.5,51.36 104.01,51.36 103.76,51.1 103.76,50.67 103.43,50.34 100.94,50.34 100.71,50.11 100.71,49.56 100.51,49.35 100.05,49.35 99.76,49.06 99.76,48.59 99.5,48.34 94.36,48.34 94.21,48.49 92.73,48.49 91.64,47.4 85.24,47.4 83.03,45.19 83.03,44.21 83.11,44.12 83.11,31.92 84.53,30.51 108.64,30.51 110.47,28.68 116.33,28.68 117.6,29.95 119.65,29.95 120.64,28.96 128.71,28.96 131.44,31.69 137.78,31.69 v1(138.56,30.91)
  12_PWR3 w0.381: J108.1 173.23,75.79 ; J108.1 172.42,73.92 ; J108.1 174.03,75.53 ; J108.1 174.29,74.73 ; J108.1 172.42,75.53 ; J108.1 173.23,73.66 ; J108.1 172.16,74.73 ; J108.1 174.03,73.92
  18_SIG6 w0.381: v1(84.25,44.26) 83.01,43.02 82.74,43.02 v4(81.96,42.24)
  BOTTOM w0.191: v2(136.24,84.84) 136.51,84.84 137.01,85.34 137.57,85.34 137.74,85.51 137.74,86.1 137.98,86.34 144.05,86.34 146.91,83.48 v1(150.62,83.48)
  BOTTOM w0.381: v1(94.41,99.24) 94.31,99.34 C589.1 ; v1(121.13,99.25) C623.1 ; v1(126.89,102.47) 126.89,103.06 C1748.1 126.09,103.82 125.4,103.13 125.4,102.11 125.74,101.76 126.68,101.76 126.7,101.75 v1(126.82,101.75) ; C1750.1 127.78,28.67 126.81,29.65 126.81,29.78 v1(126.85,29.82) ; R1088.2 136.02,32.36 v1(135.56,32.82) ; v2(141.24,84.84) 143.21,84.84 145.56,82.5 152.04,82.5 152.39,82.85 R175.2 ; v1(106.18,33.47) 106.23,33.47 106.64,33.06 106.64,31.95 C1751.1 107.76,32.01 v1(107.76,32.76) ; C1475.1 v1(143.64,32.82) ; C1747.1 v1(167.28,109.54) ; v2(95.24,84.84) 95.19,84.89 v1(85.34,84.89) ; v1(168.28,84.38) 169.27,84.38 C1745.1 169.06,85.39 v1(168.28,85.39) ; C1481.1 v1(142.37,32.82) ; v1(97,101.72) 96.85,101.57 R176.2 ; v1(173.48,77.77) 173.48,79.41 C1749.1 174.75,79.19 v1(174.75,77.77) ; C615.1 v1(122.68,99.25) ; C1742.1 v1(167.28,115.39)
  vias: v1(172.21,77.77) v1(172.21,76.5) v1(173.48,76.5) v1(174.75,76.5) v1(176.02,77.77) v1(176.02,76.5) v1(177.29,77.77) v1(177.29,76.5) v1(178.56,77.77) v1(178.56,76.5)
MGTAVTT_FPGA_SNS_N: length 43.2
  TOP w0.104: Z131.1 141.09,31.67 141.28,31.67 141.4,31.79 141.4,34.15 146.82,39.57 149.5,39.57 150.08,38.99 153.85,38.99 156.95,42.09 166.37,42.09 166.64,42.35 170.38,42.35 171,42.98 173.1,42.98 173.37,43.25 173.37,43.5 v1(173.08,43.79) 173.38,44.09 173.38,44.42 174,45.04 174.45,45.04 174.58,45.17 U165.35
MGTAVTT_FPGA_SNS_P: length 73.4
  TOP w0.104: U36.8 173.32,67.79 v1(173.25,67.72) ; U165.36 174.58,44.67 174.45,44.81 174.09,44.81 173.6,44.32 173.6,44.06 v1(173.88,43.79) 173.6,43.51 173.6,43.16 173.19,42.75 171.1,42.75 170.47,42.13 166.73,42.13 166.46,41.86 157.05,41.86 153.95,38.76 149.99,38.76 149.4,39.34 146.92,39.34 141.63,34.06 141.63,31.7 141.38,31.45 141.11,31.45 Z130.1
  03_SIG1 w0.135: v1(173.25,67.72) 171.47,65.94 171.47,65.22 169.24,62.99 169.24,50.6 171.25,48.59 171.25,44.42 172.54,43.13 173.22,43.13 v1(173.88,43.79)
MGTAVTT_FPGA_VIN: length 2.9
  TOP w0.152: U36.9 172.82,69.37 173.32,69.86 C155.1 173.02,70.57 173.02,71.06 R111.1
MGTAVTT_ISENSE2: length 24.1
  TOP w0.152: v1(183.04,61.02) 183.45,61.02 183.79,61.37 183.79,61.85 183.87,61.92 183.87,62.11 184.23,62.47 U162.15
  03_SIG1 w0.173: v1(183.04,61.02) 181.57,61.02 179.09,58.53 176.31,58.53 176.29,58.51 176.29,58.5 175.86,58.07 175.86,57.48 175.86,57.26 176.76,56.36 v1(176.76,52.59)
  BOTTOM w0.152: v1(176.76,52.59) 176.24,52.59 176.03,52.38 R1226.2 176.03,50.66 177.87,48.82 178.92,48.82 179.31,49.21 R1270.2
MGTAVTT_PGOOD: length 324.1
  TOP w0.254: U165.24 v1(177.54,52.04)
  TOP w0.381: U167.7 137.06,109.2 136.97,109.11 136.97,109.11 136.71,108.85 136.71,108.85 136.58,108.73 v1(135.95,108.73)
  03_SIG1 w0.381: v1(198.63,170.37) 199.08,170.37 199.54,169.9 199.54,160.42 201.35,158.61 201.35,156.08 203.92,153.51 203.92,152.85 v1(205.33,151.43)
  05_SIG2 w0.381: v1(135.95,108.73) 138.83,108.73 143.64,113.54 144.62,113.54 145.23,114.15 147.16,114.15 151.37,118.36 151.37,121.07 152.48,122.17 156.64,122.17 157.84,123.37 159.94,123.37 162.92,126.35 v1(171.82,126.35)
  14_SIG4 w0.381: v1(135.95,108.73) 135.95,110.88 136.81,111.74 138.53,111.74 139.45,112.65 143,112.65 144.68,110.97 144.68,109.1 145.92,107.86 146.86,107.86 147.55,108.55 148.02,109.02 153.94,109.02 155.54,110.62 165.03,110.62 165.47,110.17 170,105.64 170,104.09 170.42,103.66 173.05,103.66 173.24,103.48 175.41,103.48 178.36,100.53 178.36,83.95 185.38,76.93 185.38,74.79 178.56,67.97 178.56,52.64 177.96,52.04 v1(177.54,52.04) 177.54,52.69 176.93,53.3 174.92,53.3 172.41,50.79 172.41,43.44 174.1,41.74 176.63,41.74 177.57,40.81 179.39,40.81 180.33,39.87 180.33,32.61 172.94,25.22 170.87,25.22 168.95,23.3 167.21,23.3 167.12,23.21 160.03,23.21 157.3,20.47 143.48,20.47 141.75,22.2 141.75,23.75 141.37,24.13 v1(140.89,24.13) ; v1(171.82,126.35) 171.82,127.71 176.73,132.62 176.73,147.29 183.83,154.39 188.35,154.39 189.99,156.03 198.63,156.03 203.23,151.43 v1(205.33,151.43)
  BOTTOM w0.254: U51.8 203.2,151.39 202.7,151.89 202.7,152.32 202.27,152.75 202.27,153.25 202.07,153.45 RP3.7
  BOTTOM w0.381: U5.7 140.53,24.9 140.62,24.8 140.62,24.73 140.89,24.46 v1(140.89,24.13) ; U51.8 205.05,151.39 205.09,151.43 v1(205.33,151.43) ; D14.1 v1(198.63,170.37)
MGTAVTT_PWM2: length 22.3
  TOP w0.152: U165.17 v1(182.17,48.17) ; U162.13 185.29,63.47 185.52,63.7 185.52,65.06 v1(185.35,65.23)
  03_SIG1 w0.173: v1(182.17,48.17) 181.87,48.48 181.87,49.79 183.2,51.12 183.2,56.76 184.91,58.47 184.91,63.91 185.35,64.35 v1(185.35,65.23)
MGTAVTT_SLAVE_1V8: length 30.3
  TOP w0.305: v2(184.69,65.72) 184.69,65.19 184.76,65.13 184.76,64.48 U162.11
  TOP w0.381: L97.1 174.66,56.35 C1670.1 R1231.1 C1669.1 173.33,59.26 172.5,58.43 C1617.1 v1(172.01,59.82) ; v2(184.69,65.72) 184.58,65.84 C1680.1
  05_SIG2 w0.381: v1(172.01,59.82) 175.64,59.82 175.87,60.05 177.6,60.05 179.07,61.52 179.07,64.7 180.09,65.72 v2(184.69,65.72)
  BOTTOM w0.152: v2(184.69,65.72) 184.62,65.8 R1211.1
MGTAVTT_TS_FAULTB: length 13.2
  TOP w0.152: v1(181.22,49.6) 180.07,49.6 U165.19
  03_SIG1 w0.173: v1(181.37,59.37) 181.37,56.69 181.06,56.39 181.06,52.82 181.56,52.32 181.56,50.42 181.22,50.08 v1(181.22,49.6)
  BOTTOM w0.152: C1716.1 v1(181.22,49.6) ; R1278.1 v1(181.37,59.37)
MGTAVTT_VDD_MASTER: length 27.3
  TOP w0.254: U165.8 179.54,42.96 179.84,42.67 v1(179.84,42.38)
  TOP w0.381: R1231.2 v1(176.4,57.86) 176.4,56.74 C1670.2
  03_SIG1 w0.381: v1(176.4,57.86) 179.25,55.02 179.25,53.7 180.9,52.04 180.9,50.8 178.46,48.36 178.46,47.65 178.87,47.24 178.87,46.1 178.33,45.57 178.33,44.7 179.84,43.2 v1(179.84,42.38)
  BOTTOM w0.254: C1598.1 180.61,43.15 v1(179.84,42.38)
  BOTTOM w0.381: C1598.1 181.32,43.15 C1668.1 183.23,42.47 R1199.1
MGTAVTT_VIN: length 2.7
  TOP w0.152: U36.10 172.32,70.26 C155.2 172.62,70.57 172.62,71.06 R112.1
MGTAVTT_VIN_UV: length 4.1
  TOP w0.152: v1(182,46.69) 181.98,46.67 U165.14
  BOTTOM w0.152: C1715.1 R1220.1 181.98,46.67 v1(182,46.69) 182.19,46.88 R1217.2
MGTRREF_121: length 12.2
  TOP w0.152: v2(141.24,85.84) U1.BF43
  BOTTOM w0.152: R175.1 151.1,82.97 146.43,82.97 143.56,85.84 v2(141.24,85.84)
MGTRREF_126: length 20.8
  TOP w0.152: U1.L41 105.74,83.34 v2(105.24,83.84)
  BOTTOM w0.152: R176.1 96.85,98.32 103.74,91.43 103.74,84.63 104.02,84.34 104.74,84.34 v2(105.24,83.84)
MGTRREF_226: length 15.2
  TOP w0.152: U1.BD2 v2(139.24,43.84)
  BOTTOM w0.152: v2(139.24,43.84) 138.72,43.33 138.72,42.07 136.88,40.23 136.88,31.27 136.66,31.05 R1088.1
MGTRREF_231: length 13.4
  TOP w0.152: U1.A4 95.74,46.34 v2(95.24,45.84) 88.64,45.84 84.94,42.14 R1326.1
MGTVCCAUX_L: length 59.3
  TOP w0.381: U1.AG39 121.74,81.34 v2(122.24,81.84) ; C1483.1 C1476.1 v1(111.83,99.36) ; U1.AA38 v2(115.24,80.84) ; R1290.1 135.52,101.36 v1(135.51,101.35) ; v2(120.24,80.84) 119.74,80.34 U1.AE38 ; C1484.1 v1(104.09,99.3) ; C713.1 C1485.1 120.83,100.01 120.43,99.61 120.43,98.67 v1(121.13,97.98) ; U1.W39 v2(113.24,81.84)
  05_SIG2 w0.089: v2(115.24,80.84) 115.74,80.34 115.74,79.56 115.95,79.34 117.62,79.34 118.62,78.34 123.54,78.34 123.74,78.54 123.74,79.04 124.04,79.34 129.43,79.34 129.74,79.65 129.74,79.97 130.11,80.34 130.39,80.34 130.74,80.69 130.74,81.12 130.96,81.34 131.39,81.34 131.74,81.69 131.74,83.14 131.94,83.34 132.51,83.34 132.7,83.53 132.7,86.14 132.93,86.37 135.41,86.37 135.74,86.7 135.74,89.36 134.77,90.33 134.77,98.5 134.97,98.71 134.97,100.81 v1(135.51,101.35)
  BOTTOM w0.381: D39.1 136.33,100.57 135.66,99.89 v1(134.41,99.89) ; v1(111.83,99.36) C1476.1 ; C1483.1 110.28,99.25
  vias: v1(134.41,99.12)
MGTVCCAUX_PGOOD: length 288.7
  TOP w0.381: v1(137.5,111.1) 137.71,110.89 U167.6
  05_SIG2 w0.381: v1(171.05,127.22) 164.56,127.22 162.74,129.03 152.53,129.03 152,128.51 152,127.8 150.01,125.81 150.01,118.14 146.88,115.01 143.69,115.01 142.14,113.46 139.86,113.46 v1(137.5,111.1)
  14_SIG4 w0.381: v1(140.18,27.23) 145,22.4 147.19,22.4 147.78,21.82 157.56,21.82 159.78,24.03 166.76,24.03 169.28,26.55 169.8,26.55 170.16,26.19 172.79,26.19 178.57,31.97 178.57,35.88 176.96,37.49 176.96,38.49 176.18,39.28 173.21,39.28 171.57,40.92 171.57,51.03 174.6,54.06 177.31,54.06 177.8,54.55 177.8,68.29 184.62,75.11 184.62,76.61 184.55,76.61 177.6,83.56 177.6,100.22 175.1,102.72 172.92,102.72 172.74,102.9 170.11,102.9 169.24,103.77 169.24,105.32 164.71,109.85 155.85,109.85 154.25,108.25 150.31,108.25 147.46,105.41 144.43,105.41 143.92,105.93 143.92,110.62 142.68,111.86 142.06,111.86 140.54,110.34 138.26,110.34 v1(137.5,111.1) ; v1(202.28,154.25) 201.49,154.25 198.94,156.79 193.41,156.79 189.68,156.79 188.03,155.15 183.52,155.15 175.95,147.58 175.95,132.92 171.05,128.02 v1(171.05,127.22)
  BOTTOM w0.381: RP3.6 v1(202.28,154.25) ; U51.9 205.06,152.04 205.07,152.06 205.89,152.06 v1(206.05,152.22) ; U5.6 139.88,26.94 v1(140.18,27.23) ; D12.1 v1(201.17,170.37)
MGTVCCAUX_R: length 92.5
  TOP w0.381: v1(142.19,17.06) 141.35,17.89 141.35,18.34 140.93,18.76 D9.1 ; C177.1 111.25,32.4 v1(111.76,32.91) ; C180.1 112.65,32.46 v1(113.11,32.91) ; v2(112.24,50.84) U1.V9 ; U1.AD8 v2(119.24,49.84) ; C176.1 C181.1 v1(114.05,32.96) ; U1.AF9 v2(121.24,50.84) ; U1.T8 v2(110.24,49.84)
  18_SIG6 w0.089: v2(121.24,50.84) 121.74,51.34 123.44,51.34 123.74,51.05 123.74,44.61 124.01,44.34 128.45,44.34 128.74,44.06 128.74,41.06 130.58,39.22 130.58,29.92 130.12,29.46 130.12,28.42 125.12,23.42 124.7,23.42 121.41,20.14 117.78,20.14 117.1,19.46 117.1,17.77 117.71,17.16 119.66,17.16 120.45,16.37 121.8,16.37 122.9,17.47 126.19,17.47 126.49,17.17 129.21,17.17 130,17.96 133.54,17.96 136.18,20.59 140.9,20.59 141.58,19.92 141.58,17.67 v1(142.19,17.06)
  BOTTOM w0.254: R160.1 v1(142.19,17.06)
  BOTTOM w0.381: v1(113.11,32.91) 113.11,32.76 C180.1 ; C178.1 111.25,32.4 v1(111.76,32.91) ; v1(114.05,32.96) C181.1
  vias: v1(142.47,16) v1(142.47,15.19)
PCIE_CLK1_C_N: length 2.5
  BOTTOM w0.104: U20.2 62.19,42.67 62.71,43.19 63.07,43.19 C102.1
PCIE_CLK1_C_P: length 2.5
  BOTTOM w0.104: C67.1 63.07,43.42 62.73,43.42 62.21,43.94 U20.1
PCIE_CLK1_N: length 117.4
  TOP w0.104: v2(126.24,49.84) U1.AL8
  20_SIG7 w0.076: v2(126.24,49.84) 126.24,50.17 126.31,50.24 126.54,50.24 126.62,50.17 126.62,41.29 126.58,41.25 126.58,41.23
  20_SIG7 w0.089: v1(65.58,42.11) 65.25,42.44 64.74,42.44 64.36,42.06 64.36,41.53 64.5,41.39 64.81,41.39 64.95,41.26 64.95,40.99 64.81,40.85 64.5,40.85 64.36,40.72 64.36,40.45 64.5,40.31 64.81,40.31 64.95,40.18 64.95,39.91 64.81,39.78 64.5,39.78 64.36,39.64 64.36,32.25 67.4,29.21 67.4,27.87 62.14,22.61 62.14,20.62 63.2,19.57 72.12,19.57 73.78,21.23 88.14,21.23 90.46,23.54 92.09,23.54 96.16,27.61 107.37,27.61 108.74,28.98 108.74,33.99 113.18,38.43 124.41,38.43 126.58,40.6 126.58,41.23
  BOTTOM w0.104: v1(65.58,42.11) 65.07,42.62 65.07,42.82 64.91,42.99 64.73,42.99 64.59,42.85 C102.2
PCIE_CLK1_P: length 117.4
  TOP w0.104: v2(126.24,50.84) U1.AL9
  20_SIG7 w0.076: 126.86,41.23 126.86,41.25 126.82,41.29 126.82,50.25 126.62,50.44 126.31,50.44 126.24,50.52 v2(126.24,50.84)
  20_SIG7 w0.089: 126.86,41.23 126.86,40.48 124.53,38.15 113.3,38.15 109.02,33.87 109.02,28.86 107.49,27.33 96.27,27.33 92.2,23.26 90.57,23.26 88.26,20.95 73.9,20.95 72.24,19.29 63.08,19.29 61.86,20.51 61.86,22.72 67.12,27.98 67.12,29.09 64.08,32.13 64.08,42.18 64.63,42.72 65.43,42.72 v1(65.56,42.85)
  BOTTOM w0.104: v1(65.56,42.85) 65.37,42.85 65,43.22 64.66,43.22 64.59,43.29 C67.2
PCIE_CLK2_C_N: length 2.5
  BOTTOM w0.104: C119.1 63.07,40.65 62.77,40.65 62.25,40.13 U20.4
PCIE_CLK2_C_P: length 2.5
  BOTTOM w0.104: U20.3 62.25,41.4 62.77,40.88 63.07,40.88 C118.1
PCIE_CLK2_N: length 135.4
  TOP w0.104: v2(117.24,49.84) U1.AC8
  18_SIG6 w0.089: v1(63.04,21.03) 62.75,21.33 62.47,21.33 62.22,21.58 62.22,23.22 63.84,24.84 65.55,24.84 66.33,24.06 66.33,23.4 67.02,22.71 76.01,22.71 77.26,23.96 80.94,23.96 83.3,26.31 102.91,26.31 107.21,22.02 119.53,22.02 124.24,26.73 124.24,30.34 125.3,31.41 126.29,31.41 127.97,33.08 127.97,37.24 125.6,39.6 119.74,39.6 118.16,41.17 118.16,49.83 117.79,50.2 117.6,50.2 v2(117.24,49.84)
  20_SIG7 w0.089: v1(63.04,21.03) 63.98,21.97 67.86,21.97 69.01,23.12 69.01,29.12 65.76,32.37 65.76,40.34 65.96,40.54 66.55,40.54 v1(66.67,40.41)
  BOTTOM w0.104: C119.2 64.59,40.13 65.12,40.67 66.42,40.67 v1(66.67,40.41)
PCIE_CLK2_P: length 135.3
  TOP w0.104: v2(117.24,50.84) U1.AC9
  18_SIG6 w0.089: v2(117.24,50.84) 117.6,50.48 117.9,50.48 118.44,49.95 118.44,41.29 119.85,39.88 125.72,39.88 128.24,37.35 128.24,32.97 126.41,31.13 125.42,31.13 124.52,30.23 124.52,26.61 119.64,21.74 107.09,21.74 102.8,26.03 83.41,26.03 81.06,23.68 77.37,23.68 76.12,22.43 66.9,22.43 66.05,23.28 66.05,23.94 65.43,24.56 63.96,24.56 62.5,23.1 62.5,21.69 62.59,21.6 62.75,21.6 v1(63.04,21.89)
  20_SIG7 w0.089: v1(66.67,41.15) 66.34,40.82 65.85,40.82 65.48,40.45 65.48,32.25 68.73,29 68.73,23.23 67.75,22.25 63.86,22.25 63.36,21.74 63.2,21.74 v1(63.04,21.89)
  BOTTOM w0.104: C118.2 64.62,41.4 65.12,40.89 66.42,40.89 v1(66.67,41.15)
PCIE_CLK_Q0_N: length 52.2
  07_SIG3 w0.135: v1(61.16,14.23) 61.15,14.23 60.77,14.61 60.77,19.78 62.33,21.34 62.33,24.94 65.84,28.45 65.84,37.94 60.15,43.62 57.66,43.62 57.11,43.07 57.11,42.26 57.47,41.9 57.91,41.9 58.06,41.74 v1(58.06,41.4)
  10_GND w0.114: v1(61.16,14.23) 60.77,13.84 60.77,13 60.43,12.67 60.43,6.14 60.65,5.92 U2.A14
  BOTTOM w0.104: U20.6 v1(58.06,41.4)
PCIE_CLK_Q0_P: length 52.1
  07_SIG3 w0.135: v1(58.06,42.67) 58.06,42.36 57.89,42.18 57.59,42.18 57.39,42.38 57.39,42.95 57.78,43.34 58.68,43.34 58.82,43.21 58.82,42.68 58.95,42.55 59.22,42.55 59.36,42.68 59.36,43.21 59.49,43.34 60.04,43.34 65.56,37.82 65.56,28.56 62.05,25.06 62.05,21.46 60.49,19.9 60.49,14.56 v1(60.16,14.23)
  10_GND w0.114: v1(60.16,14.23) 60.55,13.83 60.55,13.09 60.22,12.75 60.22,6.16 59.65,5.6 U2.A13
  BOTTOM w0.104: U20.7 v1(58.06,42.67)
PCIE_PERST: length 67.9
  20_SIG7 w0.089: v1(66.87,53.53) 66.23,53.53 64.64,51.94 64.64,51.11 63.42,49.89 63.42,49.89 61.92,48.38 61.92,47.46 59.58,45.12 59.07,45.12 54.89,40.94 53.96,40.94 45.88,32.87 44.14,32.87 43.72,32.45 43.72,20.03 45.47,18.29 46.86,18.29 47.14,18.57 52.69,18.57 53.04,18.92 54.47,18.92 v1(54.98,18.41)
  BOTTOM w0.152: v1(66.87,53.53) 66.05,54.34 62.96,54.34 62.35,53.73 U3.11 ; v1(54.98,18.41) 55.63,17.76 R11.2 R12.1 58.04,16.68 R10.2
PCIE_PERST_LS: length 126
  TOP w0.152: v1(54.29,43.1) 56.67,43.1 57.81,41.96 63.63,41.96 67.14,38.45 84,38.45 86.75,41.19 123.58,41.19 v2(124.24,41.84) ; U1.AM17 v2(127.24,58.84)
  07_SIG3 w0.173: v1(54.29,43.1) 56.11,43.1 57.94,44.93 60.17,44.93 67.5,52.26 67.5,56.63 67.36,56.77 67.36,59.97 66.9,60.42 66.9,61.59 v1(66.32,62.18)
  14_SIG4 w0.089: v2(124.24,41.84) 124.73,42.34 124.73,44.03 125.03,44.33 125.57,44.33 125.74,44.5 125.74,46.09 125.85,46.2 125.85,47.19 125.99,47.34 126.42,47.34 126.72,47.64 126.72,50.11 126.84,50.23 126.84,58.44 v2(127.24,58.84)
  BOTTOM w0.152: U3.10 62.35,59.96 64.57,62.18 v1(66.32,62.18)
PCIE_PERST_R: length 14.3
  03_SIG1 w0.173: v6(54.71,7.19) 54.36,7.54 54.36,11.1 v1(58.06,14.81)
  10_GND w0.089: U2.A11 55.65,6.33 54.79,7.19 v6(54.71,7.19)
  BOTTOM w0.152: R10.1 v1(58.06,14.81)
PCIE_PRSNT_B: length 47.4
  03_SIG1 w0.173: J7.8 J7.6 J7.4 J7.2 61.49,26.47 59.29,24.27 59.29,20.2 53.51,14.42 46.14,14.42 v1(45.38,13.66)
  10_GND w0.089: v1(45.38,13.66) 45.76,13.29 45.76,4.1 U2.A1
PCIE_PRSNT_X1: length 21.8
  TOP w0.152: J7.1 66.78,23.14 66.78,13.44 63.4,10.06 63.4,6.2 63.65,5.95 U2.B17
PCIE_PRSNT_X4: length 24.2
  TOP w0.152: v1(77.84,13.89) 77.84,6.09 77.65,5.9 U2.B31
  BOTTOM w0.152: v1(77.84,13.89) 77.11,14.63 75.39,14.63 74.18,15.83 74.18,19.85 J7.3
PCIE_PRSNT_X8: length 43.6
  TOP w0.152: U2.B48 94.65,5.78 94.23,6.2 94.23,12.42 97.05,15.24 97.05,17.57 v1(97.64,18.15)
  BOTTOM w0.152: J7.5 75.38,21.19 78.81,21.19 80.09,19.92 91.24,19.92 93.02,18.15 v1(97.64,18.15)
PCIE_PRSNT_X16: length 66.8
  TOP w0.152: v1(112.14,18.97) 112.93,18.97 113.36,18.54 113.36,17.55 113.06,17.25 113.06,15.04 114.93,13.16 123.8,13.16 126.97,9.98 126.97,6.55 127.65,5.88 U2.B81
  BOTTOM w0.152: v1(112.14,18.97) 110.54,20.57 81.2,20.57 77.84,23.93 J7.7
PCIE_RX0_N: length 80.4
  TOP w0.147: v6(62.15,9.41) 61.82,9.73 arc(61.77,9.77) 61.71,9.78 61.56,9.78 arc(61.36,9.7) 61.28,9.5 61.28,6.39 arc(61.33,6.16) 61.45,5.97 61.48,5.95 arc(61.6,5.75) 61.65,5.52 U2.B15 ; U1.AA3 115.74,45.34 v2(115.24,44.84)
  05_SIG2 w0.183: v6(62.15,9.41) 62.44,9.7 arc(62.5,9.74) 62.57,9.75 63.09,9.75 arc(63.83,9.9) 64.45,10.32 64.65,10.52 arc(64.79,10.58) 64.93,10.52 arc(65.07,10.46) 65.21,10.52 65.45,10.76 arc(65.51,10.9) 65.45,11.04 arc(65.39,11.18) 65.45,11.31 65.69,11.55 arc(65.83,11.61) 65.97,11.55 arc(66.11,11.5) 66.25,11.55 66.48,11.79 arc(66.54,11.93) 66.48,12.07 arc(66.43,12.21) 66.48,12.35 68.24,14.11 arc(69.31,14.82) 70.56,15.07 80.05,15.07 arc(82.41,15.54) 84.41,16.87 arc(84.96,17.23) 85.59,17.36 85.9,17.36 arc(87.19,17.62) 88.29,18.35 89.85,19.92 arc(90.15,20.12) 90.51,20.19 91.02,20.19 arc(91.34,20.25) 91.62,20.44 94.1,22.92 arc(94.86,23.43) 95.75,23.6 95.98,23.6 arc(96.29,23.67) 96.54,23.84 100.26,27.56 arc(101.05,28.08) 101.98,28.27 105.02,28.27 arc(105.44,28.35) 105.8,28.59 106.94,29.73 arc(107.12,29.85) 107.34,29.89 107.99,29.89 arc(108.52,30) 108.97,30.3 109.59,30.91 arc(109.8,31.24) 109.88,31.62 arc(109.92,31.83) 110.04,32.01 110.52,32.49 arc(110.65,32.62) 110.78,32.76 arc(111.01,33.05) 111.23,33.35 arc(111.23,33.35) 111.23,33.35 arc(111.68,33.93) 112.17,34.48 112.18,34.48 113.36,35.66 arc(114.88,37.93) 115.41,40.62 115.41,42.01 arc(115.46,42.27) 115.61,42.49
  05_SIG2 w0.237: v2(115.24,44.84) 115.25,44.84 arc(115.59,44.7) 115.74,44.35 115.74,42.72 arc(115.72,42.63) 115.66,42.54 115.61,42.49
PCIE_RX0_P: length 80.3
  TOP w0.147: v6(62.15,10.41) 61.83,10.09 arc(61.78,10.05) 61.71,10.04 61.56,10.04 arc(61.18,9.88) 61.02,9.5 61.02,6.39 arc(60.97,6.16) 60.84,5.97 60.82,5.95 arc(60.7,5.75) 60.65,5.52 U2.B14 ; v2(115.24,45.84) 115.74,46.34 U1.AA4
  05_SIG2 w0.183: v6(62.15,10.41) 62.44,10.11 arc(62.5,10.07) 62.57,10.06 63.09,10.06 arc(63.71,10.18) 64.24,10.54 68.02,14.32 arc(69.19,15.1) 70.56,15.37 80.05,15.37 arc(82.3,15.82) 84.2,17.09 arc(84.84,17.52) 85.59,17.67 85.9,17.67 arc(87.08,17.9) 88.07,18.57 89.64,20.13 arc(90.04,20.4) 90.51,20.49 91.02,20.49 arc(91.23,20.53) 91.4,20.65 93.89,23.14 arc(94.74,23.71) 95.75,23.91 95.98,23.91 arc(96.17,23.95) 96.33,24.05 96.74,24.47 100.05,27.77 arc(100.93,28.36) 101.98,28.57 105.02,28.57 arc(105.33,28.63) 105.58,28.8 106.72,29.94 arc(107.01,30.13) 107.34,30.2 107.99,30.2 arc(108.41,30.28) 108.76,30.52 109.37,31.13 arc(109.52,31.35) 109.57,31.62 arc(109.64,31.94) 109.82,32.22 110.3,32.7 arc(110.43,32.83) 110.55,32.96 arc(110.77,33.24) 110.98,33.52 110.98,33.53 arc(111.44,34.13) 111.96,34.69 111.96,34.69 113.14,35.87 arc(114.6,38.05) 115.11,40.62 115.11,42.16 arc(115.09,42.25) 115.04,42.33
  05_SIG2 w0.237: v2(115.24,45.84) 114.93,45.53 arc(114.79,45.32) 114.74,45.08 114.74,42.79 arc(114.77,42.64) 114.85,42.51 115.04,42.33
PCIE_RX1_N: length 79.8
  TOP w0.147: v6(67.15,9.41) 66.82,9.73 arc(66.77,9.77) 66.71,9.78 66.56,9.78 arc(66.36,9.7) 66.28,9.5 66.28,6.39 arc(66.33,6.16) 66.46,5.97 66.48,5.95 arc(66.6,5.75) 66.65,5.52 U2.B20 ; v2(116.24,42.84) 116.74,43.34 U1.AB1
  03_SIG1 w0.183: v6(67.15,9.41) 67.44,9.7 arc(67.5,9.74) 67.57,9.75 67.76,9.75 arc(68.17,9.93) 68.34,10.34 68.34,11.12 arc(68.45,11.37) 68.71,11.48 68.8,11.48 arc(69.16,11.85) 68.8,12.21 68.71,12.21 arc(68.45,12.32) 68.34,12.58 68.34,13.79 arc(68.29,14.07) 68.13,14.31 67.17,15.27 arc(67.05,15.44) 67.01,15.65 67.01,16.3 67.01,21.38 arc(67.28,22.03) 67.92,22.29 75.5,22.29 arc(76,22.39) 76.43,22.67 79.22,25.46 arc(80.72,26.47) 82.49,26.82 82.95,26.82 arc(83.95,27.02) 84.8,27.58 85.55,28.33 arc(85.81,28.51) 86.13,28.57 89.34,28.57 arc(90.77,28.86) 91.99,29.67 92.65,30.34 arc(94.55,31.6) 96.78,32.05 104.04,32.05 arc(106.11,32.46) 107.85,33.62 115.65,41.42 arc(115.75,41.53) 115.84,41.65 arc(115.87,41.7) 115.89,41.75 arc(115.92,41.8) 115.94,41.84 arc(115.94,41.85) 115.95,41.87 arc(116.03,42.13) 116.05,42.4 116.05,42.51 arc(116.08,42.65) 116.16,42.77
  03_SIG1 w0.237: 116.16,42.77 v2(116.24,42.84)
PCIE_RX1_P: length 79.9
  TOP w0.147: v2(116.24,43.84) 116.74,44.34 U1.AB2 ; v6(67.15,10.41) 66.83,10.09 arc(66.78,10.05) 66.71,10.04 66.56,10.04 arc(66.18,9.88) 66.02,9.5 66.02,6.39 arc(65.97,6.16) 65.85,5.97 65.82,5.95 arc(65.7,5.75) 65.65,5.52 U2.B19
  03_SIG1 w0.183: v6(67.15,10.41) 67.44,10.11 arc(67.5,10.07) 67.57,10.06 67.76,10.06 arc(67.96,10.14) 68.04,10.34 68.04,13.79 arc(68.01,13.95) 67.91,14.09 66.96,15.05 arc(66.77,15.33) 66.71,15.65 66.71,21.38 arc(67.06,22.24) 67.92,22.6 75.5,22.6 arc(75.89,22.67) 76.21,22.89 79,25.68 arc(80.6,26.75) 82.49,27.12 82.95,27.12 arc(83.83,27.3) 84.58,27.8 85.33,28.55 arc(85.7,28.79) 86.13,28.88 89.34,28.88 arc(90.65,29.14) 91.77,29.88 92.44,30.55 arc(94.43,31.88) 96.78,32.35 104.04,32.35 arc(105.99,32.74) 107.64,33.84 115.43,41.63 arc(115.51,41.72) 115.58,41.82 arc(115.6,41.86) 115.62,41.89 arc(115.64,41.93) 115.66,41.97 arc(115.66,41.97) 115.67,41.98 arc(115.73,42.19) 115.75,42.4 115.75,42.67
  03_SIG1 w0.237: 115.75,42.67 115.75,42.96 arc(115.82,43.32) 116.02,43.63 v2(116.24,43.84)
