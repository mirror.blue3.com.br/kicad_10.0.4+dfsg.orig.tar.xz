# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UTIL_3V3_SNS_N: length 258.3
  TOP w0.104: Z116.1 v1(39.34,98.56)
  07_SIG3 w0.135: v1(39.34,98.56) 39.6,98.3 39.6,97.18 30.71,88.29 30.71,78.11 27.29,74.69 27.29,40.3 32.11,35.48 32.11,29.03 40.77,20.37 42.56,20.37 50.44,12.49 75.22,12.49 77.47,10.25 77.47,8.25 78.4,7.31 125.12,7.31 127.39,9.58 127.39,12.18 128.65,13.43 184.08,13.43 190.02,19.37 190.02,20.81 v1(190.25,21.04)
  BOTTOM w0.104: v1(190.25,21.04) C1449.1 190.96,21.51 190.7,21.77 C1538.2 190.25,22.77 190.25,23.18 189.87,23.57 189.87,23.72 189.93,23.77 U156.26
UTIL_3V3_SNS_P: length 258.2
  TOP w0.104: Z115.1 v1(40.39,98.53)
  07_SIG3 w0.135: v1(189.31,21.03) 189.53,21.03 189.74,20.82 189.74,19.49 189.48,19.23 189.31,19.23 188.99,19.55 188.83,19.55 188.71,19.43 188.71,19.27 189.03,18.94 189.03,18.78 183.96,13.71 128.53,13.71 127.11,12.29 127.11,9.7 125.01,7.59 78.52,7.59 77.75,8.37 77.75,10.37 75.34,12.77 50.61,12.77 42.69,20.69 42.42,20.69 40.9,20.69 32.42,29.16 32.42,35.62 27.61,40.43 27.61,74.56 31.01,77.96 31.01,88.19 39.88,97.06 39.88,98.43 39.99,98.53 v1(40.39,98.53)
  BOTTOM w0.104: v1(189.31,21.03) 189.7,21.42 C1538.1 189.98,22.6 189.98,23.07 189.57,23.48 189.57,23.59 189.43,23.73 U156.27
UTIL_3V3_TEMPX: length 34.5
  BOTTOM w0.178: C1542.1 183.79,30.12 183.79,32.15 183.11,32.84 183.11,37.9 184.56,39.35 184.56,43.59 187.68,46.7 187.68,49.25 188.66,50.23 193.65,50.23 194.59,49.28 194.59,48.95 Q51.1 194.4,47.95 Q51.2
  BOTTOM w0.254: C1542.1 184.74,29.17 184.74,29.04 185.77,28.02 U156.7
VAD_1V8_TEMPX: length 23.1
  BOTTOM w0.254: U30.7 178.23,138.77 177.67,139.33 177.67,139.84 176.94,140.56 C740.1 176.28,140.81 176.28,141.74 181.48,146.94 189.9,146.94 190.41,146.42 Q25.1 190.41,145.06 Q25.2
VADJ_1V8: length 16.8
  TOP w0.14: R102.2 190.64,151.76 191.39,151.76 191.64,151.51 191.64,149.68 191.35,149.38 R87.1
  TOP w0.152: v1(195.12,143.76) 194.82,143.46 192.48,143.46 192.18,143.76 L3.2
  BOTTOM w0.152: v1(195.12,143.76) 195.05,143.69 Z65.2
  BOTTOM w0.381: R434.1 187.06,145.71 v1(187.05,145.72)
  vias: v1(183.04,150.04) v1(184.18,150.04) v1(184.18,148.77) v1(185.45,150.04) v1(185.45,148.77) v1(186.72,150.04) v1(186.72,148.77) v1(187.99,150.04) v1(187.99,148.77) v1(189.26,150.04) v1(189.26,148.77)
VADJ_1V8_EN: length 68.6
  TOP w0.381: U25.4 v1(126.02,138.66)
  07_SIG3 w0.381: v1(150.59,134.37) 150.99,133.97 159.69,133.97 160.44,133.22 162.72,133.22 163.67,134.16 166.34,134.16 167.72,135.53 167.72,139.57 169.54,141.4 v1(177.94,141.4)
  BOTTOM w0.203: U30.12 180.91,141.11 180.39,141.63 178.17,141.63 v1(177.94,141.4)
  BOTTOM w0.381: v1(126.02,138.66) 126.64,138.03 131.04,138.03 131.63,137.45 133.45,137.45 135.78,139.78 145.48,139.78 147.31,137.95 147.31,136.13 148.3,135.14 149.82,135.14 v1(150.59,134.37)
VADJ_1V8_FET_SWITCH: length 27.6
  TOP w0.152: v1(195.12,142.72) 194.84,143 192.48,143 192.18,142.71 L3.1
  TOP w0.381: R231.1 181.55,144.05 v1(181.17,143.67)
  BOTTOM w0.152: v1(195.12,142.72) 194.79,143.05 R712.2
  BOTTOM w0.254: C406.2 183.68,143.1 183.5,142.91 183.5,141.21 182.91,140.62 U30.16
  BOTTOM w0.381: R464.2 181.67,143.16 v1(181.17,143.67) 181.17,144.21 181.79,144.83 183.85,144.83 184.34,144.35 C406.2 184.44,143.1 185.68,141.86 187.05,141.86 187.21,141.71 190.03,141.71
  vias: v1(193.8,141.53) v1(193.8,139.75) v1(193.8,138.48) v1(193.8,137.21) v1(194.31,140.64) v1(194.82,141.53) v1(194.82,139.75) v1(194.82,138.48) v1(194.82,137.21)
VADJ_1V8_FPGA: length 238.7
  TOP w0.14: R101.2 190.64,152.1 191.53,152.1 191.94,151.7 191.94,149.55 192.11,149.38 R87.2
  TOP w0.381: v2(131.24,80.84) 130.74,80.34 U1.AT38 ; v2(129.24,76.84) U1.AP34 ; 196.89,144.09 J58.1 ; J58.1 196.89,142.48 ; J58.1 197.7,144.35 ; J58.1 197.7,142.22 ; J58.1 198.5,144.09 ; J58.1 196.63,143.28 ; J58.1 198.76,143.28 ; J58.1 198.5,142.48 ; v2(127.24,72.84) U1.AM30 ; v2(132.24,56.84) 131.74,57.34 U1.AU15 ; U1.L37 v2(105.24,79.84) ; U1.T32 v2(110.24,74.84) ; v2(109.24,56.84) 109.74,57.34 U1.R15 ; J22.H40 v1(57.4,167.13) ; v2(103.24,54.84) 103.74,55.34 U1.J13 ; U1.AW9 v2(134.24,50.84) ; U1.AP14 v2(129.24,55.84) ; v1(165.62,98.22) 165.62,99.32 C170.1 166.5,99.56 v1(166.5,98.22) ; U1.M14 106.74,56.34 v2(106.24,55.84) ; v2(141.24,49.84) U1.BF8 ; U1.AL13 v2(126.24,54.84) ; v2(113.24,75.84) 113.74,75.34 ; J22.G39 v1(58.67,165.86) ; U1.W13 113.74,55.34 v2(113.24,54.84) ; U1.N11 v2(107.24,52.84) ; U1.P38 108.74,80.34 v2(108.24,80.84) ; U1.BA13 135.74,55.34 v2(136.24,54.84) ; J22.E39 v1(58.67,163.32) ; J2.F40 v1(127.41,164.59) ; J22.F40 v1(57.4,164.59) ; U1.M34 v2(106.24,76.84) ; v2(126.24,75.84) 125.74,75.34 ; U1.R35 v2(109.24,77.84) ; J2.G39 v1(128.68,165.86) ; U1.AY16 134.74,58.34 v2(135.24,57.84) ; v2(125.24,78.84) U1.AK36 ; U1.BD14 v2(139.24,55.84) ; v1(128.02,99.11) 128.59,99.11 C169.1 128.84,100.38 v1(128.07,100.38) ; U1.AV12 v2(133.24,53.84) ; U1.T12 v2(110.24,53.84) ; J2.H40 v1(127.41,167.13) ; U1.AH32 v2(123.24,74.84) ; J2.E39 v1(128.68,163.32) ; v2(140.24,52.84) U1.BE11 ; v2(138.24,48.84) U1.BC7 ; U1.BB10 v2(137.24,51.84)
  03_SIG1 w0.381: 196.89,144.09 J58.1 ; J58.1 198.76,143.28 ; J58.1 197.7,144.35 ; J58.1 197.7,142.22 ; J58.1 198.5,144.09 ; J58.1 196.89,142.48 ; J58.1 198.5,142.48 ; J58.1 196.63,143.28 ; v1(40.12,74.48) 39.07,75.54 39.07,80.18 40.21,81.32 40.21,84.96 41.81,86.56 41.81,95.66 45.85,99.69 51.16,99.69 52.15,100.69 52.15,118.66 52.63,119.14 52.63,127.58 51.8,128.41 51.8,133.85 53.42,135.46 53.42,138.28 54,138.87 54,141.1 55.65,142.74 55.65,148.03 54.23,149.45 53.17,149.45 52.3,150.32 52.3,157.45 50.97,158.78 49.7,158.78 48.87,159.61 48.87,172.36 50.65,174.14 56.21,174.14
  11_PWR2 w0.381: 197.7,142.22 J58.1 ; J58.1 198.5,142.48 ; J58.1 198.76,143.28 ; J58.1 196.63,143.28 ; J58.1 196.89,142.48 ; J58.1 196.89,144.09 ; J58.1 197.7,144.35 ; J58.1 198.5,144.09
  BOTTOM w0.191: v2(129.24,76.84) 129.74,77.34 129.74,84.07 130,84.33 130.45,84.33 130.71,84.59 130.71,85.04 131.01,85.34 132.46,85.34 132.69,85.57 132.69,86.02 133.03,86.36 133.48,86.36 133.73,86.61 133.73,87.05 134.01,87.33 135.45,87.33 135.69,87.57 135.69,88.09 135.94,88.34 136.48,88.34 136.75,88.62 136.75,89.1 137.03,89.38 137.34,89.38 137.96,90 145.77,90 147.3,88.48 151.27,88.48 Z16.2
  BOTTOM w0.381: C1649.1 v1(125.55,171.21) ; C1467.1 v1(150.62,40.18) ; C1012.1 v1(123.89,158.19) ; C1569.1 v1(150.62,44.63) ; C1573.1 v1(150.62,43.1) ; C1650.1 v1(125.9,168.08) ; C1641.1 v1(53.77,160.69) ; C1568.1 v1(150.62,41.58) ; 56.13,170.55 56.13,172.6 55.53,173.21 v1(55.4,173.21) v1(54.6,173.21) ; C1627.1 v1(125.39,163.11) ; U44.2 v1(40.12,74.48) 40,74.36 C99.1 ; C289.1 v1(53.98,158.93) ; C1651.1 v1(123.89,159.95) ; 56.13,168.77 v1(56.13,167.78)
  vias: v1(194.22,147.88) v1(194.22,146.48) v1(194.22,145.21) v1(195.46,149.96) v1(195.46,148.69) v1(195.46,147.42) v1(195.54,146.2) v1(196.73,149.96) v1(196.73,148.69) v1(196.73,147.42) v1(196.68,146.2)
VADJ_1V8_FPGA_SNS_N: length 113.9
  BOTTOM w0.104: C369.2 181.57,132.7 181.57,132.36 v1(181.87,132.06) 181.41,131.6 181.41,127.91 188.61,120.71 188.61,118.47 191.9,115.19 191.9,84.97 185.82,78.9 181.24,78.9 179.37,77.02 171.74,77.02 171.37,77.39 171.37,85.34 170.81,85.9 169.02,85.9 168.07,86.85 168.07,90.1 167.75,90.42 161.45,90.42 160.61,91.26 155.26,91.26 154.05,90.05 154.05,89.34 152.9,88.18 152.32,88.18 Z14.1 ; C369.2 181.59,133.32 181.59,133.58 182.41,134.4 U30.26 ; C369.2 C370.1
VADJ_1V8_FPGA_SNS_P: length 147.6
  05_SIG2 w0.135: v1(187.07,152.32) 185.61,152.32 183.59,150.3 183.59,149.54 176.81,142.76 176.81,131.91 177.55,131.17 180.34,131.17 180.75,131.58 v1(180.75,132.13)
  BOTTOM w0.104: U30.27 181.91,134.29 181.25,133.63 181.02,133.63 180.89,133.5 C369.1 181.01,132.9 181.01,132.39 v1(180.75,132.13) 181.18,131.7 181.18,131.38 181.08,131.28 180.93,131.28 180.82,131.17 180.82,130.86 180.93,130.76 181.08,130.76 181.18,130.65 181.18,127.81 188.38,120.61 188.38,118.38 191.67,115.09 191.67,85.06 185.73,79.13 181.15,79.13 179.27,77.25 171.84,77.25 171.6,77.49 171.6,85.44 170.91,86.13 169.11,86.13 168.3,86.94 168.3,90.2 167.84,90.65 161.54,90.65 160.71,91.49 155.17,91.49 153.82,90.14 153.82,89.43 152.8,88.41 152.31,88.41 Z16.1 ; v1(187.07,152.32) 189.6,152.32 189.84,152.57 189.84,153.05 189.67,153.23 U27.8
VADJ_1V8_FPGA_VIN: length 4.2
  TOP w0.14: R101.1 189.74,152.25 189.59,152.1 189.17,152.1 189.06,152.21 189.06,152.61 v1(189.29,152.83)
  TOP w0.152: v1(189.29,152.83) 189.73,153.27 C97.1
  BOTTOM w0.152: v1(189.29,152.83) 189.1,153.02 189.1,153.83 U27.9
VADJ_1V8_PGOOD: length 308.7
  TOP w0.381: J22.D1 v1(106.93,162.05) ; J2.D1 v1(176.94,162.05)
  05_SIG2 w0.381: v1(205.21,149.44) 203.84,149.44 203,150.29 197.83,150.29 197.19,150.93 193.45,150.93 189.56,147.04 183.18,147.04 180.35,144.2 180.35,142.21 180.89,141.67 180.89,140.35 178.75,138.21 v1(178.75,134.34)
  07_SIG3 w0.381: v1(176.94,162.05) 176.3,161.42 176.3,157.05 169.58,150.32 139.14,150.32 v1(137.2,152.26)
  14_SIG4 w0.381: v1(56.27,126.87) 54.87,128.27 54.87,130.9 55.47,131.5 55.47,142.94 57.6,145.07 57.6,146.58 58.74,147.72 58.74,149.01 v1(59.16,149.43)
  16_SIG5 w0.381: v1(178.75,134.34) 178.75,136.16 181.42,138.83 181.42,142.27 180.43,143.26 180.43,152.38 177.85,154.96 177.85,161.14 v1(176.94,162.05)
  18_SIG6 w0.381: v1(45.96,75.13) 44.37,76.72 44.37,80.75 41.7,83.42 41.7,91.97 46.33,96.6 49.58,96.6 53.31,100.33 53.31,122 55.13,123.81 55.13,125.74 v1(56.27,126.87)
  BOTTOM w0.254: U51.5 202.91,149.44 201.67,150.69 RP2.6 ; v1(178.75,134.34) 178.87,134.34 179.41,134.88 U30.32
  BOTTOM w0.381: v1(137.2,152.26) 136.89,151.94 112.52,151.94 107.76,156.71 107.76,161.23 v1(106.93,162.05) 106.31,161.43 106.31,152.82 105.54,152.05 70.34,152.05 68.07,149.78 64.14,149.78 63.32,150.6 62.03,150.6 61.21,149.78 59.5,149.78 v1(59.16,149.43) ; U51.5 v1(205.21,149.44) ; U44.18 v1(45.96,75.13)
VADJ_1V8_PGOOD_LS: length 136.7
  TOP w0.152: v2(125.24,77.84) U1.AK35
  03_SIG1 w0.173: v1(42.53,75.13) 43.51,75.13 44.39,76.01 44.39,78.39 42.97,79.82 42.97,84.27 43.34,84.65 47.86,84.65 59.72,96.5 59.72,102.74 61.66,104.69 v1(62.79,104.69)
  BOTTOM w0.152: v1(62.79,104.69) 60.87,104.69 60.05,105.51 60.05,106.96 60.35,107.26 63.73,107.26 64.8,106.2 71.98,106.2 72.82,105.36 88.62,105.36 90.04,103.94 100.13,103.94 101.88,102.18 101.88,96.62 106.74,91.76 106.74,85.64 107.09,85.29 107.54,85.29 107.77,85.06 107.77,84.61 108.04,84.34 108.39,84.34 108.74,84 108.74,83.64 109.04,83.34 109.47,83.34 109.74,83.07 109.74,82.64 110.04,82.34 110.49,82.34 110.74,82.1 110.74,81.64 111.04,81.34 111.54,81.34 111.74,81.15 111.74,80.64 112.09,80.29 118.14,80.29 119.08,79.34 119.54,79.34 119.74,79.15 119.74,78.64 120.04,78.34 120.49,78.34 120.75,78.08 120.75,77.63 121.04,77.34 121.44,77.34 121.69,77.6 121.69,78 122.03,78.33 124.75,78.33 v2(125.24,77.84) ; U44.3 v1(42.53,75.13)
VADJ_1V8_VIN: length 4.6
  TOP w0.14: R102.1 189.77,151.76 189.03,151.76 188.72,152.07 188.72,152.66 v1(188.55,152.83)
  TOP w0.152: v1(188.55,152.83) 188.73,153.01 C97.2
  BOTTOM w0.152: v1(188.55,152.83) 188.75,153.03 188.75,153.82 U27.10
VADJ_DH_R: length 32.7
  TOP w0.381: v1(194.08,135.45) 193.8,135.73 Q9.1
  05_SIG2 w0.381: v1(182.25,143.69) 182.25,143.6 183.07,144.43 187.74,144.43 188.25,143.92 194.03,143.92 194.69,144.58 195.66,144.58 196.24,143.99 196.24,138.15 197.79,136.6 197.79,134.42 197.15,133.78 195.25,133.78 194.08,134.95 v1(194.08,135.45)
  BOTTOM w0.381: R98.2 182.52,143.13 182.52,143.41 v1(182.25,143.69)
VADJ_DL: length 7.6
  TOP w0.254: Q9.7 189.33,136.38 189.01,136.7 v1(189.01,136.83)
  03_SIG1 w0.381: v1(189.01,136.83) 187.28,136.83 185.46,138.66 v1(184.87,138.66)
  BOTTOM w0.254: U30.19 184.25,138.27 184.64,138.66 v1(184.87,138.66)
VREF_43: length 1.4
  TOP w0.152: U1.AJ29 123.74,71.34 v2(124.24,71.84)
  BOTTOM w0.152: R798.2 123.75,71.35 v2(124.24,71.84)
VREF_45: length 1.4
  TOP w0.152: U1.U30 v2(111.24,72.84)
  BOTTOM w0.152: v2(111.24,72.84) 111.73,72.35 R796.2
VREF_66: length 1.4
  TOP w0.152: U1.BA11 v2(136.24,52.84)
  BOTTOM w0.152: R1024.2 136.74,52.33 v2(136.24,52.84)
VREF_67: length 1.4
  TOP w0.152: U1.AL16 v2(126.24,57.84)
  BOTTOM w0.152: R1023.2 125.74,57.35 v2(126.24,57.84)
VREF_70: length 1.4
  TOP w0.381: U1.AB13 116.74,55.34 v2(116.24,54.84)
  BOTTOM w0.381: v2(116.24,54.84) 116.73,54.35 R3.2
VRP_40: length 14.5
  TOP w0.152: v2(138.24,72.84) U1.BC30
  BOTTOM w0.152: v2(138.24,72.84) 138.74,73.34 147.54,73.34 148.55,74.35 R378.1
VRP_41: length 17.5
  TOP w0.152: v2(138.24,71.84) 137.74,71.34 U1.BC29
  BOTTOM w0.152: R384.1 153.69,73.74 149.38,73.74 147.99,72.34 138.73,72.34 v2(138.24,71.84)
VRP_42: length 19.2
  TOP w0.152: U1.BB34 v2(137.24,76.84)
  BOTTOM w0.152: v2(137.24,76.84) 137.74,77.34 148.09,77.34 149.37,76.06 152.76,76.06 152.95,76.25 153.12,76.25 153.67,76.8 153.67,77.26 153.8,77.39 R377.1
VRP_43: length 24.1
  TOP w0.152: U1.AR34 v2(130.24,76.84)
  BOTTOM w0.152: R383.1 147.18,75.49 147.03,75.34 137.04,75.34 136.74,75.04 136.74,74.64 136.44,74.34 133.04,74.34 132.74,74.64 132.74,75.04 132.42,75.36 132.02,75.36 131.74,75.64 131.74,76.14 131.53,76.34 131.04,76.34 130.54,76.84 v2(130.24,76.84)
VRP_45: length 39.9
  TOP w0.14: R700.1 v1(102.54,99.3)
  TOP w0.152: v2(114.24,75.84) 114.74,75.34
  03_SIG1 w0.173: v2(114.24,75.84) 113.74,75.34 113.74,74.54 113.54,74.34 110.94,74.34 110.74,74.14 110.74,73.66 110.44,73.36 107.98,73.36 107.74,73.59 107.74,79.14 107.53,79.34 104.88,79.34 104.74,79.49 104.74,89.63 101.67,92.7 101.67,98.43 v1(102.54,99.3)
VRP_46: length 29
  TOP w0.152: U1.K38 104.74,80.34 v2(104.24,80.84)
  BOTTOM w0.152: R1001.1 85.94,92.12 87.07,90.98 100.76,90.98 101.74,90.01 101.74,83.64 102.04,83.34 102.44,83.34 102.74,83.04 102.74,82.64 103.04,82.34 103.44,82.34 103.74,82.04 103.74,81.63 104.24,81.13 v2(104.24,80.84)
VRP_47: length 38.2
  TOP w0.152: v1(82.93,65.84) 84,65.84 84.57,66.41 R379.1 ; U1.T29 110.74,71.34 v2(110.24,71.84)
  20_SIG7 w0.089: v1(82.93,65.84) 84,65.84 86.49,63.34 89.2,63.34 90.79,64.93 94.68,64.93 95.05,65.31 108.88,65.31 109.74,66.16 109.74,71.34 v2(110.24,71.84)
VRP_48: length 33
  TOP w0.152: U1.M26 106.74,68.34 v2(106.24,68.84)
  BOTTOM w0.152: v2(106.24,68.84) 105.75,68.35 93.65,68.35 92.32,69.68 87.03,69.68 86.03,68.68 85.01,68.68 84.38,69.32 84.38,77.45 R1002.1
VRP_65: length 13.7
  TOP w0.152: U1.BF21 v2(141.24,62.84) 150.09,62.84 150.5,63.25 v1(153.11,63.25)
  BOTTOM w0.152: v1(153.11,63.25) 152.93,63.43 R108.1
VRP_66: length 15.9
  TOP w0.152: U1.BD16 v2(139.24,57.84)
  BOTTOM w0.152: v2(139.24,57.84) 139.74,57.34 143.11,57.34 149.86,50.6 R4.1
VRP_67: length 18.1
  TOP w0.152: U1.BA12 v2(136.24,53.84)
  BOTTOM w0.152: v2(136.24,53.84) 136.47,53.84 136.97,54.34 143.64,54.34 148.53,49.45 R380.1
VRP_70: length 52.2
  TOP w0.152: R5.1 131.06,32.63 128.51,35.18 v1(127.48,35.18) ; U1.W15 113.74,57.34 v2(113.24,56.84)
  07_SIG3 w0.173: v1(127.48,35.18) 128.24,35.93 128.24,36.47 129.15,37.38 129.15,41.81 128.71,42.25 128.71,61.11 128.45,61.37 114.05,61.37 113.73,61.05 113.73,57.33 v2(113.24,56.84)
VRP_71: length 18.6
  TOP w0.152: U1.D8 v2(98.24,49.84) ; R1072.1 84.85,43.3 88.84,47.28 v2(94.63,47.28)
  20_SIG7 w0.173: v2(94.63,47.28) 94.47,47.44 94.47,47.85 94.96,48.34 97.51,48.34 97.74,48.57 97.74,49.34 v2(98.24,49.84)
VRP_72: length 28.2
  TOP w0.152: U1.T21 v2(110.24,62.84) ; R1073.1 v1(85.29,59.49)
  14_SIG4 w0.089: v1(85.29,59.49) 86,60.2 93.07,60.2 93.98,61.11 94.77,61.11 94.92,61.26 109.37,61.26 109.83,61.72 109.83,62.44 v2(110.24,62.84)
VRP_73: length 28.4
  TOP w0.152: U1.T18 v2(110.24,59.84) ; R1071.1 v1(85.29,58.34)
  14_SIG4 w0.089: v1(85.29,58.34) 86.44,58.34 86.92,58.83 94.26,58.83 94.74,59.31 107.42,59.31 107.67,59.05 107.67,58.6 107.9,58.37 109.45,58.37 109.78,58.7 109.78,59.38 v2(110.24,59.84)

## Copper pours and planes (outline as drawn)
AGND1 on 21_GND: 230.81,100.99 240.21,100.99 240.66,101.45 240.66,118.08 240.31,118.44 227.84,118.44 227.18,117.78 227.18,104.62
AGND2 on 21_GND: 156.81,107.59 163.53,107.59 165.4,109.47 165.4,113.23 165.96,113.79 165.96,120.37 165.1,121.23 162.32,121.23 160.53,119.44 160.53,118.39 159.05,116.92 158.06,116.92 156.13,114.99 156.13,109.95 155.71,109.53 155.71,108.7
AGND5 on 21_GND: 181.28,140.34 186.91,134.7 186.91,132.19 187.58,131.52 187.58,129.97 187.1,129.49 175.77,129.49 173.48,131.78 173.48,140.94 173.81,141.27 177.06,141.27 178,140.34
AGND6 on 21_GND: 205.38,73.48 218.8,73.48 219.35,72.92 219.35,61.54 218.8,60.99 215.6,60.99 214.88,61.7 209.65,61.7 208.71,62.64 208.71,66.22 204.7,70.23 204.7,72.8
AGND8 on 21_GND: 209.09,51.41 216.76,51.41 218.44,49.73 218.44,47.93 220.93,45.44 220.93,41.05 220.62,40.74 216.23,40.74 214.99,41.99 209.85,41.99 208.48,43.36 208.48,50.8
AGND12 on 21_GND: 45.97,122.3 49.57,122.3 50.37,123.1 50.37,128.42 49.18,129.62 46.38,129.62 45.85,130.15 41.61,130.15 36.93,125.47 36.93,119.2 37.49,118.64 42.32,118.64
AGND13 on 21_GND: 193.04,33.76 193.65,33.15 193.65,18.08 193.34,17.78 188.87,17.78 187.91,18.75 187.91,21.44 187.1,22.25 182.3,22.25 180.59,23.95 180.59,32.33 182.02,33.76
GND on TOP (solid shape): 17.36,66.59 14.95,66.59 14.95,69 17.36,69
GND on TOP (solid shape): 64.75,117.28 61.83,117.28 61.83,119.31 64.75,119.31
GND on TOP (solid shape): 83.74,27.94 82.41,27.94 82.41,29.32 83.74,29.32
GND on TOP (solid shape): 106.98,23.28 105.81,23.28 105.81,24.45 106.98,24.45
GND on TOP (solid shape): 165.57,18.46 163.5,18.46 163.5,20.54 165.57,20.54
GND on TOP (solid shape): 175.7,15.73 174.53,15.73 174.53,16.9 175.7,16.9
GND on TOP (solid shape): 189.36,96.24 187.01,96.24 187.01,97.41 189.36,97.41
GND on TOP (solid shape): 189.36,90.73 186.96,90.73 186.96,92.13 189.36,92.13
GND on TOP (solid shape): 226.15,112.14 223.73,112.14 223.73,119.25 226.15,119.25
GND on TOP (solid shape): 226.15,101.72 223.73,101.72 223.73,108.84 226.15,108.84
GND on TOP (solid shape): 226.15,91.31 223.73,91.31 223.73,98.42 226.15,98.42
GND on TOP (solid shape): 226.15,80.9 223.73,80.9 223.73,88.01 226.15,88.01
GND on TOP (solid shape): 149.97,139.65 147.68,139.65 147.68,143.84 145.53,143.84 145.53,145.49 149.97,145.49
GND on TOP (solid shape): 192.57,60.77 186.72,60.77 186.72,63.05 190.92,63.05 190.92,65.21 192.57,65.21
GND on TOP (solid shape): 37.77,104.97 37.77,102.26 35.46,102.26 35.25,102.46 35.25,105.06 35.42,105.23 37.51,105.23
GND on TOP (solid shape): 187.06,49.27 186.86,49.07 182.12,49.07 182,49.2 182,51.26 182.24,51.5 187.06,51.5
GND on TOP (solid shape): 197.92,153.77 197.92,151.82 195.45,151.82 195.07,152.2 195.07,153.7 195.45,154.08 197.61,154.08
GND on TOP (solid shape): 3.27,127.36 3.27,124.56 3.18,124.47 1.87,124.47 1.77,124.57 1.77,127.37 1.95,127.55 3.08,127.55
GND on TOP (solid shape): 26.16,150.29 26.16,148.64 25.91,148.39 21.21,148.39 20.95,148.64 20.95,150.16 21.21,150.42 26.04,150.42
GND on TOP (solid shape): 90.87,31.17 90.87,27.91 90.57,27.61 88.66,27.61 88.52,27.75 88.52,31.43 88.54,31.45 90.6,31.45
GND on TOP (solid shape): 195.47,55.17 195.47,53.9 195.31,53.73 193.26,53.73 193.04,53.95 193.04,55.17 193.17,55.3 195.34,55.3
GND on TOP (solid shape): 215.86,100.71 217.1,100.71 217.1,97.53 216.24,97.53 216.24,95.63 214.21,95.63 214.21,99.18 211.54,99.18 211.54,101.34 215.86,101.34
GND on TOP (solid shape): 217.1,118.36 216.24,118.36 216.24,116.46 214.21,116.46 214.21,120.14 214.08,120.14 214.08,120.39 211.29,120.39 211.29,122.17 217.1,122.17
GND on TOP (solid shape): 177.19,71.52 177.19,70.35 176.97,70.12 174.92,70.12 174.87,70.16 174.82,70.2 174.65,70.36 174.65,71.83 174.88,72.06 176.66,72.06
GND on TOP (solid shape): 215.86,111.12 217.23,111.12 217.23,107.95 216.24,107.95 216.24,106.05 214.21,106.05 214.21,109.34 214.08,109.34 214.08,109.6 211.54,109.6 211.54,111.76 215.86,111.76
GND on TOP (solid shape): 131.17,132.44 131.16,132.08 131.16,131.11 131.01,130.96 130.42,130.96 130.4,130.98 129.25,130.98 129.03,131.2 129.03,132.66 129.26,132.89 130.71,132.89
GND on TOP (solid shape): 139.38,112.17 139.15,111.93 137.37,111.93 137.37,111.93 137.13,111.93 136.97,112.09 136.97,112.2 136.86,112.2 136.75,112.31 136.08,112.31 136.08,113.09 136.3,113.31 139.38,113.31
GND on TOP (solid shape): 176.73,82.15 174.02,82.15 174.02,86.23 171.97,86.23 171.97,92.84 174.02,92.84 174.02,99.19 171.97,99.19 171.97,105.51 174.02,105.51 174.02,111.48 171.97,111.48 171.97,115.07 176.73,115.07
GND on TOP (solid shape): 160.28,137.46 160.03,137.21 158.16,137.21 157.92,137.27 157.67,137.22 157.66,137.21 157.49,137.21 157.23,137.46 157.23,142.59 160.28,142.59
GND on TOP (solid shape): 160.59,133.15 160.59,132.41 160.42,132.25 160.42,132.25 160.24,132.08 160.18,132.08 159.94,131.84 159.94,128.98 159.89,128.93 158.8,128.93 158.68,129.05 158.68,132.22 158.68,132.22 158.68,133.01 158.94,133.27 160.48,133.27
GND on TOP (solid shape): 173.95,53.78 173.95,53.05 173.99,53.01 173.99,52.93 174.61,52.93 174.7,52.84 174.7,52.03 174.7,52.03 174.05,52.03 174.02,52.06 174.02,52.41 173.78,52.65 169.83,52.65 169.72,52.76 169.72,53.75 169.91,53.93 173.8,53.93
GND on TOP (solid shape): 215.86,90.29 217.1,90.29 217.1,87.12 216.24,87.12 216.24,85.21 214.21,85.21 214.21,88.77 211.81,88.77 211.73,88.81 211.71,88.9 211.7,89.19 211.56,89.44 211.54,89.45 211.54,90.93 215.86,90.93
GND on TOP (solid shape): 69.17,6.23 69.3,6.17 69.38,6.05 69.38,5.97 69.32,5.83 69.18,5.76 69.01,5.76 69.01,3.49 67.29,3.49 67.29,5.76 67.11,5.76 66.99,5.82 66.92,5.94 66.92,6.04 66.98,6.16 67.09,6.23
GND on TOP (solid shape): 73.17,6.23 73.3,6.17 73.38,6.05 73.38,5.97 73.32,5.83 73.18,5.76 73.01,5.76 73.01,3.49 71.29,3.49 71.29,5.76 71.11,5.76 70.99,5.82 70.92,5.94 70.92,6.04 70.98,6.16 71.09,6.23
GND on TOP (solid shape): 83.17,6.23 83.3,6.17 83.38,6.05 83.38,5.97 83.32,5.83 83.18,5.76 83.01,5.76 83.01,3.49 81.29,3.49 81.29,5.76 81.11,5.76 80.99,5.82 80.92,5.94 80.92,6.04 80.98,6.16 81.09,6.23
GND on TOP (solid shape): 87.17,6.23 87.3,6.17 87.38,6.05 87.38,5.97 87.32,5.83 87.18,5.76 87.01,5.76 87.01,3.49 85.29,3.49 85.29,5.76 85.11,5.76 84.99,5.82 84.92,5.94 84.92,6.04 84.98,6.16 85.09,6.23
GND on TOP (solid shape): 91.17,6.23 91.3,6.17 91.38,6.05 91.38,5.97 91.32,5.83 91.18,5.76 91.01,5.76 91.01,3.49 89.29,3.49 89.29,5.76 89.11,5.76 88.99,5.82 88.92,5.94 88.92,6.04 88.98,6.16 89.09,6.23
GND on TOP (solid shape): 100.17,6.23 100.3,6.17 100.38,6.05 100.38,5.97 100.32,5.83 100.18,5.76 100.01,5.76 100.01,3.49 98.29,3.49 98.29,5.76 98.11,5.76 97.99,5.82 97.92,5.94 97.92,6.04 97.98,6.16 98.09,6.23
GND on TOP (solid shape): 104.17,6.23 104.3,6.17 104.38,6.05 104.38,5.97 104.32,5.83 104.18,5.76 104.01,5.76 104.01,3.49 102.29,3.49 102.29,5.76 102.11,5.76 101.99,5.82 101.92,5.94 101.92,6.04 101.98,6.16 102.09,6.23
GND on TOP (solid shape): 108.17,6.23 108.3,6.17 108.38,6.05 108.38,5.97 108.32,5.83 108.18,5.76 108.01,5.76 108.01,3.49 106.29,3.49 106.29,5.76 106.11,5.76 105.99,5.82 105.92,5.94 105.92,6.04 105.98,6.16 106.09,6.23
GND on TOP (solid shape): 112.17,6.23 112.3,6.17 112.38,6.05 112.38,5.97 112.32,5.83 112.18,5.76 112.01,5.76 112.01,3.49 110.29,3.49 110.29,5.76 110.11,5.76 109.99,5.82 109.92,5.94 109.92,6.04 109.98,6.16 110.09,6.23
GND on TOP (solid shape): 116.17,6.23 116.3,6.17 116.38,6.05 116.38,5.97 116.32,5.83 116.18,5.76 116.01,5.76 116.01,3.49 114.29,3.49 114.29,5.76 114.11,5.76 113.99,5.82 113.92,5.94 113.92,6.04 113.98,6.16 114.09,6.23
GND on TOP (solid shape): 120.17,6.23 120.3,6.17 120.38,6.05 120.38,5.97 120.32,5.83 120.18,5.76 120.01,5.76 120.01,3.49 118.29,3.49 118.29,5.76 118.11,5.76 117.99,5.82 117.92,5.94 117.92,6.04 117.98,6.16 118.09,6.23
GND on TOP (solid shape): 124.17,6.23 124.3,6.17 124.38,6.05 124.38,5.97 124.32,5.83 124.18,5.76 124.01,5.76 124.01,3.49 122.29,3.49 122.29,5.76 122.11,5.76 121.99,5.82 121.92,5.94 121.92,6.04 121.98,6.16 122.09,6.23
GND on TOP (solid shape): 126.22,35.52 126.23,35.45 126.25,35.39 126.24,35.3 126.17,35.25 125.61,34.79 125.77,34.08 125.8,34.05 125.8,33.06 125.19,33.06 125.19,32.03 120.61,32.03 120.61,32.27 120.59,32.47 120.52,32.66 120.5,32.69 123.37,35.56 126.21,35.56
GND on TOP (solid shape): 135.7,31.41 135.87,31.36 136.05,31.35 136.13,31.32 136.16,31.25 136.16,29.99 137.05,29.1 139.58,29.1 140.41,29.92 140.41,30.09 141.34,30.09 141.34,30.7 141.4,30.76 141.66,30.76 142.26,31.36 142.28,31.35 142.49,31.36 142.68,31.41 143.32,31.41 143.41,31.38 143.51,31.36 143.56,31.35 143.56,30.69 143.49,30.63 142.69,30.63 140.55,28.49 135.33,28.49 134.69,29.13 134.69,31.3 134.71,31.33 134.74,31.35 134.91,31.36 135.06,31.41
GND on TOP (solid shape): 57.43,41.34 57.43,41.32 58.01,40.76 58.67,41.21 58.68,41.25 63.33,41.25 64.49,40.09 64.51,39.98 64.42,39.92 54.4,39.92 54.38,40 54.39,40.09 54.47,40.13 55.59,40.13 55.59,42.39 56.38,42.39
GND on TOP (solid shape): 70.75,35.17 70.79,35.15 70.8,35.11 70.79,35.04 70.79,32.88 70.75,32.87 70.69,32.86 70.62,32.83 70.22,32.83 70.22,32.43 70.22,32.43 70.16,32.13 70.22,31.84 70.19,31.76 70.17,31.68 70.1,31.6 70,31.63 69.81,31.81 69.81,34.37 69.87,34.37 70.41,34.54 70.63,35.06 70.66,35.14 70.73,35.17
GND on TOP (solid shape): 119.19,30.4 119.33,30.35 119.47,30.33 119.47,28.05 119.39,27.96 119.39,27.46 119.41,27.27 119.49,27.09 119.5,27.01 119.44,26.95 119.19,26.75 119.07,26.44 118.92,26.4 118.8,26.32 118.51,26.41 118.2,26.36 115,26.36 115,25.43 114.49,24.92 114.46,24.88 114.28,24.92 114.11,24.91 114.02,24.93 113.99,25.01 113.99,26.56 115.65,26.56 115.65,28.85 117.44,28.85 118.19,29.6 118.19,30.33 118.23,30.34 118.33,30.36 118.43,30.4
GND on TOP (solid shape): 21.23,100.48 19.48,100.48 16.23,99.78 19.48,99.08 21.23,99.08 21.23,96.48 14.63,96.48 14.63,103.08 21.23,103.08
GND on TOP (solid shape): 33.17,96.48 26.57,96.48 26.57,99.08 28.32,99.08 31.57,99.78 28.32,100.48 26.57,100.48 26.57,103.08 33.17,103.08
GND on TOP (solid shape): 58.25,101.33 58.95,98.08 59.65,101.33 59.65,103.08 62.25,103.08 62.25,96.48 55.65,96.48 55.65,103.08 58.25,103.08
GND on TOP (solid shape): 62.25,108.41 59.65,108.41 59.65,110.16 58.95,113.41 58.25,110.16 58.25,108.41 55.65,108.41 55.65,115.01 62.25,115.01
GND on TOP (solid shape): 75.21,132.73 73.46,132.73 70.21,132.03 73.46,131.33 75.21,131.33 75.21,128.73 68.61,128.73 68.61,135.33 75.21,135.33
GND on TOP (solid shape): 87.15,128.73 80.55,128.73 80.55,131.33 82.3,131.33 85.55,132.03 82.3,132.73 80.55,132.73 80.55,135.33 87.15,135.33
GND on TOP (solid shape): 180.27,74.16 180.27,67.78 180.82,67.24 183.81,67.24 183.81,67.08 183.81,67.07 183.77,66.92 183.75,66.76 183.75,65.85 182.45,65.85 182.45,65.9 180.8,65.9 180.8,64.81 177.61,64.81 177.61,68 174.99,68 174.99,68.37 174.99,68.38 175.06,68.56 175.09,68.75 175.09,69.18 175.12,69.21 175.19,70.2 174.23,70.43 174.13,70.43 174.08,70.52 174.08,71.1 174.01,71.1 173.94,71.13 173.91,71.2 173.91,71.28 173.9,71.37 173.9,71.69 173.91,71.82 173.9,71.96 173.9,72.28 173.91,72.46 173.88,72.63 173.89,72.72 173.97,72.76 180.06,72.76 180.06,74.16 180.14,74.16 180.21,74.23
GND on TOP (solid shape): 190.63,55.93 190.69,56.02 190.8,56 191.25,55.55 195.22,55.55 195.22,52.32 194.95,52.27 194.71,52.11 194.64,52.04 194.58,52.11 193.57,52.11 193.57,51.1 193.74,50.94 193.74,50.32 191.67,50.32 191.67,50.57 191.55,50.7 191.55,50.83 191.42,50.83 191.29,50.96 190.05,50.96 189.96,51.02 189.98,51.13 190.14,51.57 189.95,52.01 189.94,52.04 190.14,52.53 189.95,52.99 190.63,53.66
GND on TOP (solid shape): 16.61,87.8 18.01,87.8 18.01,87.26 17.97,87.18 17.88,87.16 16.66,86.25 17.88,85.33 17.97,85.32 18.01,85.24 18.01,77.26 17.97,77.18 17.88,77.16 16.66,76.25 17.88,75.33 17.97,75.32 18.01,75.24 18.01,74.09 14.48,74.09 14.1,74.47 14.1,87.42 14.66,87.98 16.44,87.98
GND on TOP (solid shape): outline of 121 points within 180.12,56.34 184.31,64.43
GND on TOP (solid shape): outline of 122 points within 160.51,67.69 167.91,72.26
GND on TOP (solid shape): 72.9,36.82 73.06,36.78 73.11,36.77 73.11,36.51 73.06,36.51 72.9,36.46 72.76,36.38 72.36,36.51 71.96,36.38 71.56,36.51 71.16,36.38 70.76,36.51 70.36,36.38 69.96,36.51 69.56,36.38 69.16,36.51 68.76,36.38 68.6,36.47 68.43,36.51 68.39,36.52 68.39,36.77 68.43,36.77 68.6,36.82 68.76,36.9 69.16,36.77 69.56,36.9 69.96,36.77 70.36,36.9 70.76,36.77 71.16,36.9 71.56,36.77 71.96,36.9 72.36,36.77 72.76,36.9
GND on TOP (solid shape): outline of 171 points within 155.55,31.08 172.7,42.06
GND on TOP (solid shape): 88.22,40.48 88.32,40.42 88.3,40.3 82.3,34.31 82.19,34.28 82.12,34.38 82.12,35.2 82.06,35.2 82.06,35.22 81.7,35.58 81.25,35.8 80.76,35.69 80.55,35.78 80.33,35.8 80.26,35.83 80.23,35.9 79.56,36.51 78.89,35.9 78.85,35.83 78.78,35.8 78.73,35.8 78.66,35.83 78.63,35.9 78.24,36.45 77.56,36.38 77.16,36.51 76.76,36.38 76.36,36.51 75.96,36.38 75.56,36.51 75.16,36.38 75.03,36.45 74.9,36.5 74.89,36.5 74.76,36.63 74.76,36.77 74.97,36.8 75.16,36.9 75.56,36.77 75.96,36.9 76.36,36.77 76.76,36.9 77.53,36.88 77.81,37.61 77.83,37.7 77.91,37.74 78.01,37.74 78.09,37.7 78.1,37.61 78.38,36.88 79.16,36.9 79.56,36.77 79.96,36.9 80.36,36.77 80.76,36.9 81.53,36.88 81.81,37.61 81.83,37.7 81.91,37.74 84.3,37.74 87.04,40.48
GND on TOP (solid shape): outline of 344 points within 144.42,40.76 157.11,62.54
GND on TOP (solid shape): outline of 354 points within 118.18,22.65 124.96,29.82
GND on TOP (solid shape): outline of 95 points within 74.27,95.53 84,101.14
GND on TOP (solid shape): outline of 751 points within 34.98,111.27 50.4,126.97
GND on TOP (solid shape): outline of 856 points within 200.75,59.31 217.34,74.47
GND on TOP (solid shape): outline of 860 points within 210.9,38.02 226.98,53.37
GND on TOP (solid shape): outline of 864 points within 153.67,109.62 168.83,125.63
GND on TOP (solid shape): outline of 874 points within 175.6,128.45 191.93,142.72
GND on TOP (solid shape): outline of 1191 points within 182.68,17.42 202.14,44.5
GND on BOTTOM (solid shape): 226.15,112.65 225.64,112.14 223.73,112.14 223.73,119.25 226.15,119.25
GND on BOTTOM (solid shape): 160.28,137.59 159.9,137.21 157.49,137.21 157.23,137.46 157.23,142.59 160.28,142.59
GND on BOTTOM (solid shape): 187.39,50.42 186.71,49.74 186.71,49.07 181.83,49.07 181.83,51.67 187.39,51.67
GND on BOTTOM (solid shape): 61.17,123.08 60.97,122.88 58.37,122.88 57.48,123.77 57.48,128.07 57.71,128.3 61.17,128.3
GND on BOTTOM (solid shape): 150.34,130.1 150.34,128.63 150.06,128.35 147.56,128.35 147.28,128.63 147.28,130.19 150.25,130.19
GND on BOTTOM (solid shape): 225.81,108.76 225.81,108.18 226.15,107.84 226.15,101.88 223.73,101.88 223.73,108.84 225.73,108.84
GND on BOTTOM (solid shape): 46.62,103 46.62,100.77 46.48,100.63 44.83,100.63 44.56,100.9 44.56,103 44.82,103.25 46.36,103.25
GND on BOTTOM (solid shape): 154.04,72.76 154.04,72.75 153.99,72.6 153.98,72.44 153.98,71.12 153.49,70.64 152.28,70.64 152.28,73.02 154.04,73.02
GND on BOTTOM (solid shape): 219.16,97.28 216.6,97.28 215.46,96.14 214.02,96.14 214.02,98.84 214.62,99.44 217.39,99.44 218.35,100.4 218.35,100.59 218.59,100.59 218.59,102.36 219.16,102.36
GND on BOTTOM (solid shape): 219.16,87.43 217.16,87.43 215.66,85.93 214.02,85.93 214.02,88.33 214.67,88.98 217.19,88.98 218.35,90.14 218.35,90.17 218.59,90.17 218.59,91.95 219.16,91.95
GND on BOTTOM (solid shape): 148.24,103.21 144.92,103.21 144.92,103.25 144.87,103.44 144.77,103.61 144.74,103.65 145.05,103.95 145.05,104.02 148.24,104.02
GND on BOTTOM (solid shape): 177.68,82.15 173.95,82.15 173.95,86.23 171.97,86.23 171.97,92.84 173.95,92.84 173.95,99.19 171.97,99.19 171.97,105.5 173.98,105.5 173.98,111.48 171.97,111.48 171.97,115.07 177.68,115.07
GND on BOTTOM (solid shape): 141.51,29.47 141.51,28 140.69,28 140.66,27.98 140.38,27.98 140.2,27.8 140.18,27.8 140,27.77 139.83,27.69 138.98,27.69 138.98,27.98 138.97,27.98 138.97,29.43 139.21,29.66 141.32,29.66
GND on BOTTOM (solid shape): 84.01,91.23 85.82,91.23 85.85,91.2 85.86,91.14 85.82,91.11 83.06,91.11 82.97,91.17 82.99,91.28 83.76,92.05 84.01,92.05
GND on BOTTOM (solid shape): 65.65,85.38 65.71,85.48 65.82,85.46 66.57,84.71 67.39,84.71 67.39,82.07 67.32,81.98 67.21,82 67,82.22 65.65,82.22
GND on BOTTOM (solid shape): 150.53,59.5 150.53,59.37 151.67,59.37 151.67,57.97 150.4,57.97 150.4,57.76 150.36,57.75 150.21,57.7 150.08,57.62 150.04,57.59 147.98,59.65 147.96,59.76 148.05,59.82 150.2,59.82
GND on BOTTOM (solid shape): 153.94,85.23 154.01,85.23 154.01,83.1 153.87,83.1 153.87,83.49 153.72,83.93 153.32,84.18 153.28,84.19 153.28,84.21 152.28,84.21 152.28,85.66 152.86,85.66 152.86,86.05 153.11,86.05
GND on BOTTOM (solid shape): 199.77,36.49 199.3,35.88 199.39,35.12 199.39,22.47 198.61,21.69 196.45,21.69 195.63,22.5 195.63,42.03 194.78,42.89 194.78,44.63 195.56,45.41 199.77,45.41
GND on BOTTOM (solid shape): 41.31,58.68 41.96,58.4 42.66,58.52 42.89,58.29 42.89,57.76 42.76,57.63 42.05,57.63 41.75,57.34 41.75,45.37 41.95,45.18 42.77,45.18 43.22,44.72 43.22,44.31 42.94,44.03 40.31,44.03 40.11,44.23 40.11,58.63 40.16,58.68
GND on BOTTOM (solid shape): 60.15,73.66 60.19,73.75 60.28,73.76 61.27,73.56 62.28,73.62 62.37,73.6 62.4,73.52 62.4,73.35 61.01,73.35 61.01,71.39 60.18,71.39 60.15,71.43
GND on BOTTOM (solid shape): 61.12,92.78 61.06,92.69 60.95,92.71 60.75,92.91 58.28,92.91 58.11,93.09 57.89,93.24 57.63,93.29 57.6,93.31 57.58,93.34 57.58,93.54 56.83,94.29 56.81,94.4 56.9,94.46 61.12,94.46
GND on BOTTOM (solid shape): 41.27,95.07 40.41,94.21 40.04,94.21 40.04,93.85 40.01,93.78 39.94,93.75 39.61,93.68 39.36,93.45 39.29,93.4 39.2,93.43 37.43,95.2 35.69,95.2 35.6,95.26 35.62,95.37 36.34,96.09 41.27,96.09
GND on BOTTOM (solid shape): 147.83,57.29 147.9,57.38 148.01,57.36 149.59,55.78 149.83,55.78 150.01,55.6 150.17,55.48 150.36,55.41 150.4,55.4 150.4,55.19 151.57,55.19 151.57,54.85 151.5,54.85 151.5,53.8 150.5,53.8 150.5,52.62 150.44,52.62 149.91,52.09 149.83,52 149.76,51.89 149.69,51.84 149.6,51.86 147.83,53.63
GND on BOTTOM (solid shape): 119.03,32.39 119.12,32.37 119.15,32.29 119.28,31.89 119.64,31.66 119.68,31.65 119.68,31.34 119.29,30.95 119.29,28.68 118.8,28.19 118.23,28.19 118.19,28.24 118.19,30.27 119.06,30.27 119.06,32.05 118.93,32.05 118.92,32.09 118.9,32.16 118.87,32.23 118.87,32.32 118.94,32.37
GND on BOTTOM (solid shape): 64.45,88.84 64.45,88.83 64.39,88.62 64.45,88.42 64.45,87.32 64.44,87.31 63.45,87.31 63.26,87.13 63.26,85.3 63.11,85.14 61.37,85.14 60.69,84.46 60.69,82.32 60.34,81.97 59.33,81.97 58.95,82.35 58.95,85.12 60.25,86.41 60.25,86.54 60.26,86.56 60.3,86.75 60.25,86.94 60.25,87.58 60.33,87.81 60.25,88.03 60.25,89.13 60.58,89.46 63.83,89.46
GND on BOTTOM (solid shape): 41.31,33.1 41.94,32.82 42.63,32.93 42.66,32.95 42.89,32.72 42.89,32.18 42.76,32.05 42.05,32.05 41.75,31.76 41.75,19.8 41.83,19.8 42.01,19.61 42.81,19.61 43.02,19.4 43.02,19.38 43.04,19.38 43.22,19.2 43.22,18.59 42.94,18.3 42.68,18.3 42.67,18.31 42.09,18.45 41.52,18.3 40.2,18.3 40.11,18.39 40.11,33.06 40.16,33.1
GND on BOTTOM (solid shape): 45.33,103.68 48.62,103.68 48.71,103.62 48.69,103.51 48.47,103.29 48.47,100.84 40.99,100.84 40.98,100.87 40.39,101.27 39.8,100.87 39.78,100.84 37.33,100.84 36.59,101.58 36.56,101.69 36.66,101.75 42.48,101.75 44.87,104.14
GND on BOTTOM (solid shape): 221.5,56.64 221.59,56.6 221.6,56.5 221.55,56.03 221.78,55.6 222.03,55.35 222.22,55.35 222.22,55.29 224.21,55.29 224.21,55.18 224.29,55.18 224.29,54.97 224.16,54.97 224.16,54.98 222.52,54.98 222.52,55.03 220.62,55.03 220.62,54.95 220.53,54.92 220.47,54.92 220.47,55.16 219.3,56.33 217.44,56.33 217.34,56.39 217.37,56.5 217.51,56.64
GND on BOTTOM (solid shape): 33.23,106.76 33.29,106.85 33.4,106.84 33.63,106.71 33.89,106.66 33.89,106.54 34.89,106.54 34.89,105.88 34.75,105.88 34.04,105.17 34.75,104.46 37.03,104.46 37.03,104.38 37.17,104.38 37.17,103.17 35.55,103.17 33.23,105.49
GND on BOTTOM (solid shape): 62.38,57.61 62.47,57.55 62.45,57.44 60.83,55.82 60.62,56.03 60,56.22 59.4,55.76 59.31,55.79 58.58,56.53 58.45,56.63 58.3,56.7 58.28,56.94 58.19,57.16 58.27,57.35 58.3,57.56 58.3,57.61
GND on BOTTOM (solid shape): 187.05,20.52 189.71,20.52 190.12,20.11 190.26,20.11 190.26,19.41 191.66,19.41 191.66,19.47 191.96,19.47 192.03,19.48 192.1,19.49 192.19,19.47 192.23,19.39 192.23,18.82 192.55,18.82 192.55,18.69 192.85,18.19 193.53,18.21 193.58,18.12 193.58,16.34 193.53,16.29 190.35,16.29 189.72,16.91 187.99,16.91 187.35,16.94 183.03,16.94 182.38,17.59 182.38,18.1 182.38,18.11 182.38,20.88 182.88,21.39 186.18,21.39
GND on BOTTOM (solid shape): 178.23,51.95 178.33,51.93 178.37,51.89 178.69,51.89 178.77,51.85 178.79,51.75 178.76,51.65 178.75,51.54 178.75,51.49 178.36,51.49 178.36,50.66 178.2,50.49 177.35,50.49 177.35,50.47 177.31,50.42 177.26,50.43 176.92,50.78 176.92,51.52 176.98,51.62 177.09,51.59 177.71,51.42 178.16,51.88
GND on BOTTOM (solid shape): 207.78,57.34 208.74,56.37 210.15,56.37 210.24,56.31 210.22,56.2 209.88,55.85 206.74,55.85 206.66,55.9 206.65,55.99 206.69,56.47 206.47,56.89 206.22,57.14 206.02,57.14 206.02,57.21 204.12,57.21 204.12,55.85 203.97,55.85 203.9,55.92 203.9,57.44 203.83,57.44 203.83,57.67 203.8,57.7 203.79,57.75 203.83,57.78 204.03,57.78 204.03,57.77 205.57,57.77 205.62,57.76 205.67,57.76 205.71,57.74 205.72,57.71 205.72,57.47 207.62,57.47 207.62,58.05 207.78,58.05
GND on BOTTOM (solid shape): 216.68,103.42 216.68,103.15 216.51,103.07 216.37,102.94 216.28,102.9 216.2,102.97 214.98,102.86 216.06,102.3 216.16,102.33 216.24,102.26 216.26,102.2 216.29,102.14 216.28,102.04 216.2,101.99 214.96,101.99 213.89,103.06 213.89,103.5 216.6,103.5
GND on BOTTOM (solid shape): 162.3,87.76 162.52,87.62 162.78,87.58 162.86,87.55 162.89,87.47 163.07,86.99 163.54,86.78 163.61,86.75 163.64,86.68 163.64,85.91 163.76,85.91 163.76,84.93 164.39,84.93 164.39,84.34 164.52,84.34 164.52,83.72 164.45,83.62 164.34,83.64 161.34,86.65 161.31,86.74 161.38,86.81 161.75,87.14 161.81,87.63 161.82,87.72 161.91,87.76
GND on BOTTOM (solid shape): 147.33,19.13 147.39,19.22 147.49,19.21 147.78,19.1 148.09,19.15 148.1,19.15 148.39,19.15 148.48,19.09 148.47,18.98 148.31,18.5 148.56,18.06 148.6,17.97 148.56,17.89 148.5,17.85 148.44,17.8 148.32,17.68 148.25,17.65 148.17,17.69 147.85,17.91 147.47,17.9 147.38,17.91 147.33,17.99 147.33,18.25 144.46,18.25 144.46,18.74 144.6,18.88 147.33,18.88
GND on BOTTOM (solid shape): 92.66,74.63 89.76,74.63 85.83,70.7 85.54,70.88 85.21,70.89 85.13,70.91 85.09,70.99 85.09,71.75 85.13,71.83 85.21,71.85 85.98,72.47 85.21,73.09 85.13,73.11 85.09,73.19 85.09,73.95 85.13,74.03 85.21,74.05 85.7,74.14 86,74.52 86.01,74.56 88.48,74.56 88.95,75.03 92.66,75.03
GND on BOTTOM (solid shape): 167.29,87.04 167.35,87.06 167.38,87.01 167.38,86.56 167.76,86.19 167.79,86.11 167.75,86.04 167.45,85.49 167.62,84.89 167.49,84.12 168.06,83.58 168.1,83.57 168.1,83.32 170.69,83.32 170.69,80.27 168.19,80.27 168.19,80.33 168.21,80.39 168.65,80.39 168.65,81.91 165.86,81.91 165.86,81.22 165.77,81.2 165.68,81.21 165.63,81.3 165.63,82.35 164.92,83.07 164.9,83.18 164.99,83.24 166.04,83.24 166.04,84.39 166.46,85.15 165.83,85.75 165.79,85.75 165.79,85.91 167.27,85.91 167.27,87.01
GND on BOTTOM (solid shape): 167.25,89.25 167.35,89.21 167.38,89.2 167.38,88.9 167.35,88.89 167.25,88.85 167.16,88.79 166.76,88.92 166.36,88.79 165.96,88.92 165.56,88.79 165.16,88.92 164.76,88.79 164.36,88.92 163.96,88.79 163.56,88.92 163.16,88.79 163.01,88.87 162.85,88.92 162.81,88.92 162.81,89.18 162.85,89.18 163.01,89.23 163.16,89.31 163.56,89.18 163.96,89.31 164.36,89.18 164.76,89.31 165.16,89.18 165.56,89.31 165.96,89.18 166.36,89.31 166.76,89.18 167.16,89.31
GND on BOTTOM (solid shape): 163.32,82.4 163.34,82.29 163.24,82.23 162.36,82.23 162.36,81.09 162.15,80.84 162.09,80.53 162.06,80.46 161.98,80.43 161.93,80.43 161.88,80.42 161.84,80.44 161.83,80.48 161.83,80.57 161.94,80.57 161.94,82.22 160.42,82.22 160.42,80.57 160.48,80.57 160.49,80.48 160.47,80.44 160.43,80.42 160.38,80.43 160.34,80.43 160.26,80.46 160.23,80.53 160.17,80.84 159.97,81.09 159.97,82.23 158.44,82.23 158.44,82.22 157.46,82.22 157.46,81.3 157.42,81.22 157.33,81.2 156.74,81.08 156.49,80.53 156.46,80.46 156.38,80.43 156.34,80.43 156.26,80.46 156.23,80.53 156.16,80.85 155.95,81.1 155.95,81.93 155.99,82.01 156.07,82.03 156.79,82.31 156.83,83.07 156.83,83.64 156.67,83.8 156.67,85.23 160.49,85.23
GND on BOTTOM (solid shape): 188.74,51.89 188.82,51.85 188.84,51.76 188.81,51.66 188.8,51.56 188.8,51.51 188.13,51.51 186.46,49.84 186.46,47.36 183.23,44.14 183.23,43.65 181.98,43.65 181.68,43.96 181.68,44.04 180.65,44.04 180.65,45.14 180.52,45.14 180.52,45.36 180.44,45.45 180.71,45.72 181.28,45.72 181.38,45.66 181.37,45.56 181.42,44.73 182.25,44.66 182.92,44.61 183.27,45.18 183.66,45.43 183.77,45.88 183.8,45.96 183.87,46 183.94,46 183.94,47.06 183.98,47.07 184.69,47.88 183.98,48.7 183.94,48.71 183.94,48.77 182.38,48.77 182.37,48.78 182.05,48.8 181.77,48.66 181.28,48.66 181.28,48.89 181.33,48.9 181.93,49.6 181.33,50.31 181.28,50.31 181.28,50.49 180.27,50.49 180.27,51.49 180.17,51.49 180.17,51.54 180.16,51.65 180.13,51.75 180.14,51.85 180.23,51.89
GND on BOTTOM (solid shape): outline of 195 points within 173.43,45.14 179.21,48.19
GND on BOTTOM (solid shape): 59.58,65.45 59.58,65.2 59.3,64.92 59.3,64.68 59.12,64.68 59.12,63.32 57.9,62.1 57.79,62.08 57.73,62.17 57.73,62.42 57.66,62.42 57.65,62.47 56.84,63.16 56.02,62.47 56.02,62.42 55.95,62.42 55.95,60.52 56.01,60.52 56.01,60.47 56.31,60.17 56.31,57.61 56.78,57.61 56.78,57.56 56.8,57.35 56.89,57.16 56.82,57.02 56.78,56.88 56.76,56.85 56.73,56.84 56.47,56.83 56.24,56.74 56.16,56.73 56.09,56.78 53.56,56.24 56.07,55.58 56.07,55.59 56.11,55.63 56.21,55.53 56.21,55.5 56.19,55.2 56.3,54.92 56.23,54.77 56.19,54.61 56.18,54.56 55.66,54.56 55.66,54.48 55.63,54.4 55.55,54.38 55.02,54.19 54.85,53.65 54.82,53.57 54.75,53.54 53.34,53.54 53.34,52.03 53.3,52.02 53.21,52 53.12,51.98 53.02,51.98 53.02,52.04 51.4,52.04 51.4,54.33 52.87,54.33 52.87,55.68 51.4,55.68 51.4,56.73 52.87,56.73 52.87,58.08 51.4,58.08 51.4,59.06 58.07,65.74 59.29,65.74
GND on BOTTOM (solid shape): outline of 215 points within 56.77,82.08 64.57,90.98
GND on BOTTOM (solid shape): 217.53,80.26 217.53,79.74 220.61,76.66 221.36,76.66 221.36,76.29 221.33,76.28 220.84,75.72 221.11,75.04 221.15,74.95 220.83,74.3 221.15,73.65 220.83,73 221.15,72.35 221.11,72.27 220.83,71.79 220.99,71.25 220.93,71.09 220.9,70.92 220.9,70.54 220.96,70.26 221.11,70.03 221.36,69.78 221.36,69.65 221.35,69.64 221.19,69.28 221.21,68.9 221.2,68.81 221.12,68.77 220.87,68.7 220.66,68.57 218.85,68.57 218.78,68.6 218.75,68.68 218.58,69.26 218.06,69.57 218.02,69.58 218.02,69.71 216.08,69.71 216.08,70.22 218.31,70.22 218.31,70.27 218.88,71.05 218.31,71.84 218.31,77.09 217.37,77.09 217.29,77.13 217.26,77.2 217.27,77.28 217.27,78.02 217,78.58 216.39,78.71 216.35,78.71 216.33,78.74 215.54,79.24 214.93,78.54 214.93,78.19 214.59,77.93 214.46,77.52 214.46,77.35 214.38,77.31 214.31,77.26 213.82,77.47 213.32,77.27 213.24,77.25 213.17,77.29 212.96,77.49 212.68,77.59 212.63,77.59 212.63,77.86 214.09,79.32 214.26,79.59 214.3,79.9 214.32,79.98 214.4,80.01 216.86,80.01 217.11,80.27 217.52,80.27
GND on BOTTOM (solid shape): outline of 359 points within 109.38,24.7 119.12,38.02
GND on BOTTOM (solid shape): 154.43,81.14 154.11,80.37 154.78,79.88 154.86,79.85 154.89,79.78 155.24,79.16 155.96,79.21 156.67,79.16 157.03,79.78 157.06,79.85 157.14,79.88 157.62,80.06 157.83,80.52 157.83,80.57 157.95,80.57 158.1,80.42 158.1,80.41 158.15,80.27 158.22,80.15 158.56,79.11 159.43,79.78 159.46,79.85 159.54,79.88 159.58,79.88 159.66,79.85 159.69,79.78 160.04,79.16 160.76,79.21 161.16,79.08 161.56,79.21 161.96,79.08 162.36,79.21 162.76,79.08 163.16,79.21 163.33,79.12 163.53,79.08 163.6,79.05 163.63,78.98 163.63,78.93 163.6,78.86 163.53,78.83 163.33,78.79 163.16,78.69 162.76,78.83 162.36,78.69 161.96,78.83 161.56,78.69 161.16,78.83 160.76,78.69 160.36,78.83 159.96,78.69 159.56,78.83 159.16,78.69 158.76,78.83 158.36,78.69 157.96,78.83 157.56,78.69 157.16,78.83 156.76,78.69 156.36,78.83 155.96,78.69 155.56,78.83 155.16,78.69 154.47,78.76 154.09,78.2 154.08,78.15 153.35,78.15 153.35,77.95 153.17,77.76 153.04,77.58 152.97,77.37 152.96,77.33 152.28,77.33 152.28,80.95 153.1,80.95 153.68,81.52 153.72,81.58 154.43,81.58
GND on BOTTOM (solid shape): outline of 102 points within 136.16,89.21 161.65,98.03
GND on BOTTOM (solid shape): outline of 631 points within 152.28,73.89 167,77.61
GND on 10_GND (solid shape): 71.17,6.23 71.3,6.17 71.38,6.05 71.38,5.97 71.32,5.83 71.18,5.76 71.01,5.76 71.01,3.49 69.29,3.49 69.29,5.76 69.11,5.76 68.99,5.82 68.92,5.94 68.92,6.04 68.98,6.16 69.09,6.23
GND on 10_GND (solid shape): 75.17,6.23 75.3,6.17 75.38,6.05 75.38,5.97 75.32,5.83 75.18,5.76 75.01,5.76 75.01,3.49 73.29,3.49 73.29,5.76 73.11,5.76 72.99,5.82 72.92,5.94 72.92,6.04 72.98,6.16 73.09,6.23
GND on 10_GND (solid shape): 85.17,6.23 85.3,6.17 85.38,6.05 85.38,5.97 85.32,5.83 85.18,5.76 85.01,5.76 85.01,3.49 83.29,3.49 83.29,5.76 83.11,5.76 82.99,5.82 82.92,5.94 82.92,6.04 82.98,6.16 83.09,6.23
GND on 10_GND (solid shape): 89.17,6.23 89.3,6.17 89.38,6.05 89.38,5.97 89.32,5.83 89.18,5.76 89.01,5.76 89.01,3.49 87.29,3.49 87.29,5.76 87.11,5.76 86.99,5.82 86.92,5.94 86.92,6.04 86.98,6.16 87.09,6.23
GND on 10_GND (solid shape): 93.17,6.23 93.3,6.17 93.38,6.05 93.38,5.97 93.32,5.83 93.18,5.76 93.01,5.76 93.01,3.49 91.29,3.49 91.29,5.76 91.11,5.76 90.99,5.82 90.92,5.94 90.92,6.04 90.98,6.16 91.09,6.23
GND on 10_GND (solid shape): 102.17,6.23 102.3,6.17 102.38,6.05 102.38,5.97 102.32,5.83 102.18,5.76 102.01,5.76 102.01,3.49 100.29,3.49 100.29,5.76 100.11,5.76 99.99,5.82 99.92,5.94 99.92,6.04 99.98,6.16 100.09,6.23
GND on 10_GND (solid shape): 106.17,6.23 106.3,6.17 106.38,6.05 106.38,5.97 106.32,5.83 106.18,5.76 106.01,5.76 106.01,3.49 104.29,3.49 104.29,5.76 104.11,5.76 103.99,5.82 103.92,5.94 103.92,6.04 103.98,6.16 104.09,6.23
GND on 10_GND (solid shape): 110.17,6.23 110.3,6.17 110.38,6.05 110.38,5.97 110.32,5.83 110.18,5.76 110.01,5.76 110.01,3.49 108.29,3.49 108.29,5.76 108.11,5.76 107.99,5.82 107.92,5.94 107.92,6.04 107.98,6.16 108.09,6.23
GND on 10_GND (solid shape): 114.17,6.23 114.3,6.17 114.38,6.05 114.38,5.97 114.32,5.83 114.18,5.76 114.01,5.76 114.01,3.49 112.29,3.49 112.29,5.76 112.11,5.76 111.99,5.82 111.92,5.94 111.92,6.04 111.98,6.16 112.09,6.23
GND on 10_GND (solid shape): 118.17,6.23 118.3,6.17 118.38,6.05 118.38,5.97 118.32,5.83 118.18,5.76 118.01,5.76 118.01,3.49 116.29,3.49 116.29,5.76 116.11,5.76 115.99,5.82 115.92,5.94 115.92,6.04 115.98,6.16 116.09,6.23
GND on 10_GND (solid shape): 122.17,6.23 122.3,6.17 122.38,6.05 122.38,5.97 122.32,5.83 122.18,5.76 122.01,5.76 122.01,3.49 120.29,3.49 120.29,5.76 120.11,5.76 119.99,5.82 119.92,5.94 119.92,6.04 119.98,6.16 120.09,6.23
GND on 10_GND (solid shape): 126.17,6.23 126.3,6.17 126.38,6.05 126.38,5.97 126.32,5.83 126.18,5.76 126.01,5.76 126.01,3.49 124.29,3.49 124.29,5.76 124.11,5.76 123.99,5.82 123.92,5.94 123.92,6.04 123.98,6.16 124.09,6.23
GND on TOP: 177.06,60.31 175.16,60.31 175.07,60.4 175.07,63 175.2,63.13 177.01,63.13 177.35,62.79 177.35,60.6
GND on TOP: 194.14,66.63 197.28,66.63 197.28,69.64 194.07,69.64 193.84,69.41 193.84,66.94
GND on TOP: 162.28,104.04 162.28,102.46 161.67,101.85 159.07,101.85 159.07,104.39 161.92,104.39
GND on TOP: 234.82,55.27 236.12,55.27 236.22,55.37 236.22,57.58 236.07,57.73 234.72,57.73 234.57,57.58 234.57,55.52
GND on TOP: 134.03,122.8 132.46,122.8 132.4,122.73 132.4,120.16 132.54,120.01 133.56,120.01 134.11,119.46 134.74,119.46 134.88,119.6 134.88,120.67 134.75,120.8 134.35,120.8 134.09,121.07 134.09,122.74
GND on TOP: 184.49,46.34 187.1,46.34 187.2,46.44 187.2,48.35 186.94,48.6 184.63,48.6 184.4,48.38 184.4,46.43
GND on TOP: 26.95,134.98 27.08,134.85 27.08,133.45 27.05,133.45 27.05,132.38 26.92,132.26 25.4,132.26 25.4,132.21 25.02,132.21 24.51,132.72 24.51,134.95 24.54,134.98
GND on TOP: 64.98,144.27 65.59,143.66 73.53,143.66 74.04,144.17 74.04,145.97 73.72,146.29 65.27,146.29 64.98,146
GND on TOP, BOTTOM: 104.72,30.4 104.72,32.31 104.95,32.54 104.95,33.3 104.83,33.43 100.43,33.43 100.33,33.32 100.33,32.56 100.51,32.38 100.51,30.4
GND on BOTTOM: 168.12,34.04 170.33,34.04 170.56,33.81 170.56,31.85 170.1,31.39 168.61,31.39 168.07,31.93 168.07,33.99
GND on BOTTOM: 227.02,92.08 230.1,92.08 230.55,92.52 230.55,95.49 230.1,95.94 227.18,95.94 226.76,95.52 226.76,92.34
GND on BOTTOM: 151.3,92.7 155.55,92.7 155.83,92.98 155.83,93.23 155.71,93.35 155.33,93.35 155.12,93.55 155.12,93.98 154.99,94.12 154.36,94.12 154.05,94.43 154.05,94.48 153.71,94.81 151.7,94.81 151.25,94.37 151.25,92.75
GND on BOTTOM: 24.56,135 26.54,135 27.18,134.37 27.18,132.56 26.42,131.8 24.61,131.8 24.56,131.85
GND on BOTTOM: 36.71,91.72 36.71,90.57 36.71,90.56 36.71,90.45 37,90.16 37.22,90.16 37.22,89.5 37.19,89.47 35.18,89.47 34.9,89.75 34.9,91.47 35.14,91.72
GND on 02_GND, 04_GND, 06_GND, 08_GND: 45.64,5.69 45.64,10.92 43.18,13.39 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31 240.66,175.31 240.66,13.36 128.68,13.36 128.68,5.69 58.74,5.69 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.69
GND on 03_SIG1: 45.78,0.63 45.64,0.77 45.64,10.92 43.18,13.39 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31 240.66,175.31 240.66,13.36 128.68,13.36 128.68,11.07 53.44,11.07 53.44,1.14 45.64,1.14 45.64,0.77 45.78,0.64 53.44,0.64 ; 22 cut-outs
GND on 05_SIG2: 0.64,5.11 0.64,175.31 240.66,175.31 240.66,13.36 143.56,13.36 143.56,13.49 42.93,13.49 42.93,13.37 41.35,12.57 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.36 14.38,13.36 14.38,5.11 ; 37 cut-outs
GND on 07_SIG3: 45.78,0.63 45.64,0.77 45.64,10.92 43.18,13.39 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31 240.66,175.31 240.66,13.36 128.68,13.36 128.68,11.2 55.12,11.2 55.12,1.14 45.64,1.14 45.64,0.77 45.78,0.64 55.12,0.64 ; 36 cut-outs
GND on 09_PWR1: 45.9,6.58 45.64,6.83 45.64,10.92 45.64,11.1 45.62,11.27 45.62,13.61 56.36,13.61 58.45,15.7 64.59,15.7 67.67,18.77 77.32,18.77 79.35,16.74 126.14,16.74 127.86,15.01 127.86,7.7 126.75,6.58 58.74,6.58 58.74,7.45 57.15,9.04 55.56,7.45 55.56,6.58
GND on 10_GND: 0.64,5.11 0.64,175.31 240.66,175.31 240.66,13.36 128.68,13.36 128.68,6.25 126.84,6.25 126.84,6.63 60.5,6.63 60.5,5.69 58.74,5.69 58.74,7.45 57.3,9.03 55.59,7.76 48.8,7.76 48.19,7.15 48.19,5.69 45.64,5.69 45.64,10.92 43.18,13.39 40.72,10.92 40.72,5.13 33.99,5.13 33.99,13.36 14.38,13.36 14.38,5.11
