# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Nets (continued)
MGTVCCAUX_R: C176.1(CAP2) C177.1(CAP2) C178.1(CAP2) C179.1(CAP2) C180.1(CAP2) C181.1(CAP2) C182.1(CAP2) D9.1(CATHODE) R160.1 R173.2 U1.AD8(MGTVCCAUX_RS_AD8) U1.AF9(MGTVCCAUX_RS_AF9) U1.T8(MGTVCCAUX_RN_T8) U1.V9(MGTVCCAUX_RN_V9)
PCIE_CLK1_C_N: C102.1(CAP2) U20.2(NQ0)
PCIE_CLK1_C_P: C67.1(CAP2) U20.1(Q0)
PCIE_CLK1_N: C102.2(CAP1) U1.AL8(MGTREFCLK0N_225_AL8)
PCIE_CLK1_P: C67.2(CAP1) U1.AL9(MGTREFCLK0P_225_AL9)
PCIE_CLK2_C_N: C119.1(CAP2) U20.4(NQ1)
PCIE_CLK2_C_P: C118.1(CAP2) U20.3(Q1)
PCIE_CLK2_N: C119.2(CAP1) U1.AC8(MGTREFCLK0N_227_AC8)
PCIE_CLK2_P: C118.2(CAP1) U1.AC9(MGTREFCLK0P_227_AC9)
PCIE_CLK_Q0_N: U2.A14(REFCLKN) U20.6(NCLK)
PCIE_CLK_Q0_P: U2.A13(REFCLKP) U20.7(CLK)
PCIE_PERST: R10.2 R11.2 R12.1 U3.11(B8)
PCIE_PERST_LS: U1.AM17(IO_T3U_N12_PERSTN0_65_AM17) U3.10(A8)
PCIE_PERST_R: R10.1 U2.A11(PERSTN)
PCIE_PRSNT_B: J7.2(P2) J7.4(P4) J7.6(P6) J7.8(P8) U2.A1(PRSNT1N)
PCIE_PRSNT_X1: J7.1(P1) U2.B17(PRSNTNX1)
PCIE_PRSNT_X4: J7.3(P3) U2.B31(PRSNTNX4)
PCIE_PRSNT_X8: J7.5(P5) U2.B48(PRSNTNX8)
PCIE_PRSNT_X16: J7.7(P7) U2.B81(PRSNTNX16)
PCIE_RX0_N: U1.AA3(MGTYRXN3_227_AA3) U2.B15(HSON0)
PCIE_RX0_P: U1.AA4(MGTYRXP3_227_AA4) U2.B14(HSOP0)
PCIE_RX1_N: U1.AB1(MGTYRXN2_227_AB1) U2.B20(HSON1)
PCIE_RX1_P: U1.AB2(MGTYRXP2_227_AB2) U2.B19(HSOP1)
PCIE_RX2_N: U1.AC3(MGTYRXN1_227_AC3) U2.B24(HSON2)
PCIE_RX2_P: U1.AC4(MGTYRXP1_227_AC4) U2.B23(HSOP2)
PCIE_RX3_N: U1.AD1(MGTYRXN0_227_AD1) U2.B28(HSON3)
PCIE_RX3_P: U1.AD2(MGTYRXP0_227_AD2) U2.B27(HSOP3)
PCIE_RX4_N: U1.AE3(MGTYRXN3_226_AE3) U2.B34(HSON4)
PCIE_RX4_P: U1.AE4(MGTYRXP3_226_AE4) U2.B33(HSOP4)
PCIE_RX5_N: U1.AF1(MGTYRXN2_226_AF1) U2.B38(HSON5)
PCIE_RX5_P: U1.AF2(MGTYRXP2_226_AF2) U2.B37(HSOP5)
PCIE_RX6_N: U1.AG3(MGTYRXN1_226_AG3) U2.B42(HSON6)
PCIE_RX6_P: U1.AG4(MGTYRXP1_226_AG4) U2.B41(HSOP6)
PCIE_RX7_N: U1.AH1(MGTYRXN0_226_AH1) U2.B46(HSON7)
PCIE_RX7_P: U1.AH2(MGTYRXP0_226_AH2) U2.B45(HSOP7)
PCIE_RX8_N: U1.AJ3(MGTYRXN3_225_AJ3) U2.B51(HSON8)
PCIE_RX8_P: U1.AJ4(MGTYRXP3_225_AJ4) U2.B50(HSOP8)
PCIE_RX9_N: U1.AK1(MGTYRXN2_225_AK1) U2.B55(HSON9)
PCIE_RX9_P: U1.AK2(MGTYRXP2_225_AK2) U2.B54(HSOP9)
PCIE_RX10_N: U1.AM1(MGTYRXN1_225_AM1) U2.B59(HSON10)
PCIE_RX10_P: U1.AM2(MGTYRXP1_225_AM2) U2.B58(HSOP10)
PCIE_RX11_N: U1.AP1(MGTYRXN0_225_AP1) U2.B63(HSON11)
PCIE_RX11_P: U1.AP2(MGTYRXP0_225_AP2) U2.B62(HSOP11)
PCIE_RX12_N: U1.AT1(MGTYRXN3_224_AT1) U2.B67(HSON12)
PCIE_RX12_P: U1.AT2(MGTYRXP3_224_AT2) U2.B66(HSOP12)
PCIE_RX13_N: U1.AV1(MGTYRXN2_224_AV1) U2.B71(HSON13)
PCIE_RX13_P: U1.AV2(MGTYRXP2_224_AV2) U2.B70(HSOP13)
PCIE_RX14_N: U1.AY1(MGTYRXN1_224_AY1) U2.B75(HSON14)
PCIE_RX14_P: U1.AY2(MGTYRXP1_224_AY2) U2.B74(HSOP14)
PCIE_RX15_N: U1.BB1(MGTYRXN0_224_BB1) U2.B79(HSON15)
PCIE_RX15_P: U1.BB2(MGTYRXP0_224_BB2) U2.B78(HSOP15)
PCIE_TX0_C_N: C61.1(CAP2) U2.A17(HSIN0)
PCIE_TX0_C_P: C60.1(CAP2) U2.A16(HSIP0)
PCIE_TX0_N: C61.2(CAP1) U1.Y6(MGTYTXN3_227_Y6)
PCIE_TX0_P: C60.2(CAP1) U1.Y7(MGTYTXP3_227_Y7)
PCIE_TX1_C_N: C59.1(CAP2) U2.A22(HSIN1)
PCIE_TX1_C_P: C58.1(CAP2) U2.A21(HSIP1)
PCIE_TX1_N: C59.2(CAP1) U1.AB6(MGTYTXN2_227_AB6)
PCIE_TX1_P: C58.2(CAP1) U1.AB7(MGTYTXP2_227_AB7)
PCIE_TX2_C_N: C56.1(CAP2) U2.A26(HSIN2)
PCIE_TX2_C_P: C52.1(CAP2) U2.A25(HSIP2)
PCIE_TX2_N: C56.2(CAP1) U1.AD6(MGTYTXN1_227_AD6)
PCIE_TX2_P: C52.2(CAP1) U1.AD7(MGTYTXP1_227_AD7)
PCIE_TX3_C_N: C51.1(CAP2) U2.A30(HSIN3)
PCIE_TX3_C_P: C50.1(CAP2) U2.A29(HSIP3)
PCIE_TX3_N: C51.2(CAP1) U1.AF6(MGTYTXN0_227_AF6)
PCIE_TX3_P: C50.2(CAP1) U1.AF7(MGTYTXP0_227_AF7)
PCIE_TX4_C_N: C29.1(CAP2) U2.A36(HSIN4)
PCIE_TX4_C_P: C30.1(CAP2) U2.A35(HSIP4)
PCIE_TX4_N: C29.2(CAP1) U1.AH6(MGTYTXN3_226_AH6)
PCIE_TX4_P: C30.2(CAP1) U1.AH7(MGTYTXP3_226_AH7)
PCIE_TX5_C_N: C21.1(CAP2) U2.A40(HSIN5)
PCIE_TX5_C_P: C22.1(CAP2) U2.A39(HSIP5)
PCIE_TX5_N: C21.2(CAP1) U1.AK6(MGTYTXN2_226_AK6)
PCIE_TX5_P: C22.2(CAP1) U1.AK7(MGTYTXP2_226_AK7)
PCIE_TX6_C_N: C19.1(CAP2) U2.A44(HSIN6)
PCIE_TX6_C_P: C20.1(CAP2) U2.A43(HSIP6)
PCIE_TX6_N: C19.2(CAP1) U1.AM6(MGTYTXN1_226_AM6)
PCIE_TX6_P: C20.2(CAP1) U1.AM7(MGTYTXP1_226_AM7)
PCIE_TX7_C_N: C17.1(CAP2) U2.A48(HSIN7)
PCIE_TX7_C_P: C18.1(CAP2) U2.A47(HSIP7)
PCIE_TX7_N: C17.2(CAP1) U1.AN4(MGTYTXN0_226_AN4)
PCIE_TX7_P: C18.2(CAP1) U1.AN5(MGTYTXP0_226_AN5)
PCIE_TX8_C_N: C31.1(CAP2) U2.A53(HSIN8)
PCIE_TX8_C_P: C32.1(CAP2) U2.A52(HSIP8)
PCIE_TX8_N: C31.2(CAP1) U1.AP6(MGTYTXN3_225_AP6)
PCIE_TX8_P: C32.2(CAP1) U1.AP7(MGTYTXP3_225_AP7)
PCIE_TX9_C_N: C34.1(CAP2) U2.A57(HSIN9)
PCIE_TX9_C_P: C33.1(CAP2) U2.A56(HSIP9)
PCIE_TX9_N: C34.2(CAP1) U1.AR4(MGTYTXN2_225_AR4)
PCIE_TX9_P: C33.2(CAP1) U1.AR5(MGTYTXP2_225_AR5)
PCIE_TX10_C_N: C36.1(CAP2) U2.A61(HSIN10)
PCIE_TX10_C_P: C35.1(CAP2) U2.A60(HSIP10)
PCIE_TX10_N: C36.2(CAP1) U1.AT6(MGTYTXN1_225_AT6)
PCIE_TX10_P: C35.2(CAP1) U1.AT7(MGTYTXP1_225_AT7)
PCIE_TX11_C_N: C38.1(CAP2) U2.A65(HSIN11)
PCIE_TX11_C_P: C37.1(CAP2) U2.A64(HSIP11)
PCIE_TX11_N: C38.2(CAP1) U1.AU4(MGTYTXN0_225_AU4)
PCIE_TX11_P: C37.2(CAP1) U1.AU5(MGTYTXP0_225_AU5)
PCIE_TX12_C_N: C43.1(CAP2) U2.A69(HSIN12)
PCIE_TX12_C_P: C42.1(CAP2) U2.A68(HSIP12)
PCIE_TX12_N: C43.2(CAP1) U1.AW4(MGTYTXN3_224_AW4)
PCIE_TX12_P: C42.2(CAP1) U1.AW5(MGTYTXP3_224_AW5)
PCIE_TX13_C_N: C45.1(CAP2) U2.A73(HSIN13)
PCIE_TX13_C_P: C44.1(CAP2) U2.A72(HSIP13)
PCIE_TX13_N: C45.2(CAP1) U1.BA4(MGTYTXN2_224_BA4)
PCIE_TX13_P: C44.2(CAP1) U1.BA5(MGTYTXP2_224_BA5)
PCIE_TX14_C_N: C47.1(CAP2) U2.A77(HSIN14)
PCIE_TX14_C_P: C46.1(CAP2) U2.A76(HSIP14)
PCIE_TX14_N: C47.2(CAP1) U1.BC4(MGTYTXN1_224_BC4)
PCIE_TX14_P: C46.2(CAP1) U1.BC5(MGTYTXP1_224_BC5)
PCIE_TX15_C_N: C49.1(CAP2) U2.A81(HSIN15)
PCIE_TX15_C_P: C48.1(CAP2) U2.A80(HSIP15)
PCIE_TX15_N: C49.2(CAP1) U1.BE4(MGTYTXN0_224_BE4)
PCIE_TX15_P: C48.2(CAP1) U1.BE5(MGTYTXP0_224_BE5)
PCIE_WAKE_B: U2.B11(WAKEN) U3.12(B7)
PCIE_WAKE_B_LS: U1.BC24(IO_T0U_N12_VRP_64_BC24) U3.9(A7)
PHY1_CLKOUT: R32.2 U1.AU23(IO_L14P_T2L_N2_GC_64_AU23)
PHY1_GPIO_0: U1.AR22(IO_L17N_T2U_N9_AD10N_64_AR22) U7.39(GPIO_2)
PHY1_MDC: J13.1(P1) R27.2 U1.AV23(IO_L14N_T2L_N3_GC_64_AV23) U7.16(MDC)
PHY1_MDIO: J16.1(P1) R26.2 U1.AR23(IO_L17P_T2U_N8_AD10P_64_AR23) U7.17(MDIO)
PHY1_PDWN_B_I_INT_B_O: R34.2 U1.AR24(IO_L18P_T2U_N10_AD2P_64_AR24) U7.44(INT_PWDN)
PHY1_RESET_B: J11.1(P1) R39.2 U1.BA21(IO_T1U_N12_64_BA21) U7.43(RESET_B)
PHY1_SGMII_CLK_C_N: C90.2(CAP1) R60.2 R66.1 R205.1 U7.34(RX_D1_SGMII_CON)
PHY1_SGMII_CLK_C_P: C93.2(CAP1) R61.2 R67.1 R206.1 U7.33(RX_D0_SGMII_COP)
PHY1_SGMII_CLK_N: C90.1(CAP2) U1.AU22(IO_L13N_T2L_N1_GC_QBC_64_AU22)
PHY1_SGMII_CLK_P: C93.1(CAP2) U1.AT22(IO_L13P_T2L_N0_GC_QBC_64_AT22)
PHY1_SGMII_IN_C_N: C85.2(CAP1) U7.28(TX_D0_SGMII_SIN)
PHY1_SGMII_IN_C_P: C77.2(CAP1) U7.27(TX_D1_SGMII_SIP)
PHY1_SGMII_IN_N: C85.1(CAP2) U1.AV21(IO_L15N_T2L_N5_AD11N_64_AV21)
PHY1_SGMII_IN_P: C77.1(CAP2) U1.AU21(IO_L15P_T2L_N4_AD11P_64_AU21)
PHY1_SGMII_OUT_C_N: C86.2(CAP1) R68.2 R69.1 U7.36(RX_D3_SGMII_SON)
PHY1_SGMII_OUT_C_P: C87.2(CAP1) R70.2 R71.1 U7.35(RX_D2_SGMII_SOP)
PHY1_SGMII_OUT_N: C86.1(CAP2) U1.AV24(IO_L16N_T2U_N7_QBC_AD3N_64_AV24)
PHY1_SGMII_OUT_P: C87.1(CAP2) U1.AU24(IO_L16P_T2U_N6_QBC_AD3P_64_AU24)
PMBUS_ALERT: J39.7(P7) Q21.3(DRAIN) Q23.3(DRAIN) R500.2 U4.9(SALRT) U6.9(SALRT) U9.9(SALRT) U30.9(SALRT) U150.9(SALRT) U156.9(SALRT) U164.13(PMALERTB) U165.13(PMALERTB) U166.13(PMALERTB)
PMBUS_ALERT_FPGA: Q21.2(SOURCE) R324.2 U1.BB23(IO_L5N_T0U_N9_AD14N_64_BB23)
PMBUS_ALERT_SYSCTLR: Q23.2(SOURCE) R820.2 U111.P11(IO_L16P_T2_34_P11)
PMBUS_SCL: J39.1(P1) R501.2 R622.2 U4.10(SCLK) U6.10(SCLK) U9.10(SCLK) U30.10(SCLK) U80.5(SC0) U150.10(SCLK) U156.10(SCLK) U164.12(PMCLOCK) U165.12(PMCLOCK) U166.12(PMCLOCK)
PMBUS_SDA: J39.3(P3) R502.2 R621.2 U4.11(SDAT) U6.11(SDAT) U9.11(SDAT) U30.11(SDAT) U80.4(SD0) U150.11(SDAT) U156.11(SDAT) U164.11(PMDATA) U165.11(PMDATA) U166.11(PMDATA)
PMOD0_0: J52.1(P1) U41.18(B1)
PMOD0_0_LS: U1.AY14(IO_L10N_T1U_N7_QBC_AD4N_67_AY14) U41.3(A1)
PMOD0_1: J52.3(P3) U41.17(B2)
PMOD0_1_LS: U1.AY15(IO_L10P_T1U_N6_QBC_AD4P_67_AY15) U41.4(A2)
PMOD0_2: J52.5(P5) U41.16(B3)
PMOD0_2_LS: U1.AW15(IO_L9N_T1L_N5_AD12N_67_AW15) U41.5(A3)
PMOD0_3: J52.7(P7) U41.15(B4)
PMOD0_3_LS: U1.AV15(IO_L9P_T1L_N4_AD12P_67_AV15) U41.6(A4)
PMOD0_4: J52.2(P2) U41.14(B5)
PMOD0_4_LS: U1.AV16(IO_L8N_T1L_N3_AD5N_67_AV16) U41.7(A5)
PMOD0_5: J52.4(P4) U41.13(B6)
PMOD0_5_LS: U1.AU16(IO_L8P_T1L_N2_AD5P_67_AU16) U41.8(A6)
PMOD0_6: J52.6(P6) U41.12(B7)
PMOD0_6_LS: U1.AT15(IO_L7N_T1L_N1_QBC_AD13N_67_AT15) U41.9(A7)
PMOD0_7: J52.8(P8) U41.11(B8)
PMOD0_7_LS: U1.AT16(IO_L7P_T1L_N0_QBC_AD13P_67_AT16) U41.10(A8)
PMOD1_0: J53.1(P1) U42.18(B1)
PMOD1_0_LS: U1.N28(IO_L5P_T0U_N8_AD14P_47_N28) U42.3(A1)
PMOD1_1: J53.3(P3) U42.17(B2)
PMOD1_1_LS: U1.M30(IO_L4N_T0U_N7_DBC_AD7N_47_M30) U42.4(A2)
PMOD1_2: J53.5(P5) U42.16(B3)
PMOD1_2_LS: U1.N30(IO_L4P_T0U_N6_DBC_AD7P_47_N30) U42.5(A3)
PMOD1_3: J53.7(P7) U42.15(B4)
PMOD1_3_LS: U1.P30(IO_L3N_T0L_N5_AD15N_47_P30) U42.6(A4)
PMOD1_4: J53.2(P2) U42.14(B5)
PMOD1_4_LS: U1.P29(IO_L3P_T0L_N4_AD15P_47_P29) U42.7(A5)
PMOD1_5: J53.4(P4) U42.13(B6)
PMOD1_5_LS: U1.L31(IO_L2N_T0L_N3_47_L31) U42.8(A6)
PMOD1_6: J53.6(P6) U42.12(B7)
PMOD1_6_LS: U1.M31(IO_L2P_T0L_N2_47_M31) U42.9(A7)
PMOD1_7: J53.8(P8) U42.11(B8)
PMOD1_7_LS: U1.R29(IO_L1N_T0L_N1_DBC_47_R29) U42.10(A8)
POR_OVERRIDE_PIN: J5.2(P2) R116.1 U1.AG12(POR_OVERRIDE_AG12)
PUDC_B_PIN: R418.1 R1291.2 U1.AD12(PUDC_B_0_AD12)
QSFP1_IIC_SCL: R608.2 U28.9(SC2) U145.11(SCL)
QSFP1_IIC_SDA: R607.2 U28.8(SD2) U145.12(SDA)
QSFP1_INTL: R1095.2 U17.15(B4) U145.28(INTL)
QSFP1_INTL_LS: U1.AP21(IO_L21N_T3L_N5_AD8N_64_AP21) U17.6(A4)
QSFP1_LPMODE: U17.14(B5) U145.31(LPMODE)
QSFP1_LPMODE_LS: U1.AN21(IO_L21P_T3L_N4_AD8P_64_AN21) U17.7(A5)
QSFP1_MODPRSL: R1094.2 U17.16(B3) U145.27(MODPRSL)
QSFP1_MODPRSL_LS: U1.AL21(IO_L23P_T3U_N8_64_AL21) U17.5(A3)
QSFP1_MODSELL: U17.18(B1) U145.8(MODSELL)
QSFP1_MODSELL_LS: R1190.1 U1.AM21(IO_L23N_T3U_N9_64_AM21) U17.3(A1)
QSFP1_RECCLK_C_N: C28.2(CAP1) U57.17(CKIN1_N)
QSFP1_RECCLK_C_P: C25.2(CAP1) U57.16(CKIN1_P)
QSFP1_RECCLK_N: C28.1(CAP2) R266.2 U1.AM22(IO_L22N_T3U_N7_DBC_AD0N_64_AM22)
QSFP1_RECCLK_P: C25.1(CAP2) R266.1 U1.AM23(IO_L22P_T3U_N6_DBC_AD0P_64_AM23)
QSFP1_RESETL: U17.17(B2) U145.9(RESETL)
QSFP1_RESETL_LS: U1.BA22(IO_L10N_T1U_N7_QBC_AD4N_64_BA22) U17.4(A2)
QSFP1_RX1_N: U1.Y1(MGTYRXN0_231_Y1) U145.18(RX1N)
QSFP1_RX1_P: U1.Y2(MGTYRXP0_231_Y2) U145.17(RX1P)
QSFP1_RX2_N: U1.W3(MGTYRXN1_231_W3) U145.21(RX2N)
QSFP1_RX2_P: U1.W4(MGTYRXP1_231_W4) U145.22(RX2P)
QSFP1_RX3_N: U1.V1(MGTYRXN2_231_V1) U145.15(RX3N)
QSFP1_RX3_P: U1.V2(MGTYRXP2_231_V2) U145.14(RX3P)
QSFP1_RX4_N: U1.U3(MGTYRXN3_231_U3) U145.24(RX4N)
QSFP1_RX4_P: U1.U4(MGTYRXP3_231_U4) U145.25(RX4P)
QSFP1_TX1_N: U1.V6(MGTYTXN0_231_V6) U145.37(TX1N)
QSFP1_TX1_P: U1.V7(MGTYTXP0_231_V7) U145.36(TX1P)
QSFP1_TX2_N: U1.T6(MGTYTXN1_231_T6) U145.2(TX2N)
QSFP1_TX2_P: U1.T7(MGTYTXP1_231_T7) U145.3(TX2P)
QSFP1_TX3_N: U1.P6(MGTYTXN2_231_P6) U145.34(TX3N)
QSFP1_TX3_P: U1.P7(MGTYTXP2_231_P7) U145.33(TX3P)
QSFP1_TX4_N: U1.M6(MGTYTXN3_231_M6) U145.5(TX4N)
QSFP1_TX4_P: U1.M7(MGTYTXP3_231_M7) U145.6(TX4P)
QSFP1_VCC1_FILT: C1345.1(CAP2) C1350.1(CAP2) L72.2 U145.30(VCC1)
QSFP1_VCCRX_FILT: C1347.1(CAP2) C1352.1(CAP2) L70.2 U145.10(VCCRX)
QSFP1_VCCTX_FILT: C1346.1(CAP2) C1351.1(CAP2) L71.2 U145.29(VCCTX)
QSFP2_IIC_SCL: R92.2 U28.11(SC3) U123.11(SCL)
QSFP2_IIC_SDA: R91.2 U28.10(SD3) U123.12(SDA)
QSFP2_INTL: R2.2 U3.15(B4) U123.28(INTL)
QSFP2_INTL_LS: U1.AT21(IO_T2U_N12_64_AT21) U3.6(A4)
QSFP2_LPMODE: U3.14(B5) U123.31(LPMODE)
QSFP2_LPMODE_LS: U1.AT24(IO_L18N_T2U_N11_AD2N_64_AT24) U3.7(A5)
QSFP2_MODPRSL: R1.2 U3.16(B3) U123.27(MODPRSL)
QSFP2_MODPRSL_LS: U1.AN24(IO_L20P_T3L_N2_AD1P_64_AN24) U3.5(A3)
QSFP2_MODSELL: U3.18(B1) U123.8(MODSELL)
QSFP2_MODSELL_LS: R43.1 U1.AN23(IO_L20N_T3L_N3_AD1N_64_AN23) U3.3(A1)
QSFP2_RECCLK_C_N: C1581.2(CAP1) U57.13(CKIN2_N)
QSFP2_RECCLK_C_P: C1580.2(CAP1) U57.12(CKIN2_P)
QSFP2_RECCLK_N: C1581.1(CAP2) R1198.2 U1.AP22(IO_L19N_T3L_N1_DBC_AD9N_64_AP22)
QSFP2_RECCLK_P: C1580.1(CAP2) R1198.1 U1.AP23(IO_L19P_T3L_N0_DBC_AD9P_64_AP23)
QSFP2_RESETL: U3.17(B2) U123.9(RESETL)
QSFP2_RESETL_LS: U1.AY22(IO_L10P_T1U_N6_QBC_AD4P_64_AY22) U3.4(A2)
QSFP2_RX1_N: U1.T1(MGTYRXN0_232_T1) U123.18(RX1N)
QSFP2_RX1_P: U1.T2(MGTYRXP0_232_T2) U123.17(RX1P)
QSFP2_RX2_N: U1.R3(MGTYRXN1_232_R3) U123.21(RX2N)
QSFP2_RX2_P: U1.R4(MGTYRXP1_232_R4) U123.22(RX2P)
QSFP2_RX3_N: U1.P1(MGTYRXN2_232_P1) U123.15(RX3N)
QSFP2_RX3_P: U1.P2(MGTYRXP2_232_P2) U123.14(RX3P)
QSFP2_RX4_N: U1.M1(MGTYRXN3_232_M1) U123.24(RX4N)
QSFP2_RX4_P: U1.M2(MGTYRXP3_232_M2) U123.25(RX4P)
QSFP2_TX1_N: U1.L4(MGTYTXN0_232_L4) U123.37(TX1N)
QSFP2_TX1_P: U1.L5(MGTYTXP0_232_L5) U123.36(TX1P)
QSFP2_TX2_N: U1.K6(MGTYTXN1_232_K6) U123.2(TX2N)
QSFP2_TX2_P: U1.K7(MGTYTXP1_232_K7) U123.3(TX2P)
QSFP2_TX3_N: U1.J4(MGTYTXN2_232_J4) U123.34(TX3N)
QSFP2_TX3_P: U1.J5(MGTYTXP2_232_J5) U123.33(TX3P)
QSFP2_TX4_N: U1.H6(MGTYTXN3_232_H6) U123.5(TX4N)
QSFP2_TX4_P: U1.H7(MGTYTXP3_232_H7) U123.6(TX4P)
QSFP2_VCC1_FILT: C1.1(CAP2) C3.1(CAP2) L2.2 U123.30(VCC1)
QSFP2_VCCRX_FILT: C1553.1(CAP2) C1556.1(CAP2) L86.2 U123.10(VCCRX)
QSFP2_VCCTX_FILT: C1552.1(CAP2) C1555.1(CAP2) L1.2 U123.29(VCCTX)
QSFP_SI570_CLOCK_C_N: C95.1(CAP2) U1.W8(MGTREFCLK0N_231_W8)
QSFP_SI570_CLOCK_C_P: C94.1(CAP2) U1.W9(MGTREFCLK0P_231_W9)
QSFP_SI570_CLOCK_N: C95.2(CAP1) U38.5(OUT_B)
QSFP_SI570_CLOCK_P: C94.2(CAP1) U38.4(OUT)
QSPI0_CS_B: R1015.2 U1.AJ11(RDWR_FCS_B_0_AJ11) U133.7(S_B)
QSPI0_DQ0: U1.AP11(D00_MOSI_0_AP11) U133.15(DQ0)
QSPI0_DQ1: U1.AN11(D01_DIN_0_AN11) U133.8(DQ1)
QSPI0_DQ2: R1018.2 U1.AM11(D02_0_AM11) U133.9(DQ2_VPP_WP_B)
QSPI0_DQ3: R1016.2 U1.AL11(D03_0_AL11) U133.1(DQ3_HOLD_B)
QSPI1_CS_B: R1293.2 U1.BF16(IO_L2N_T0L_N3_FWE_FCS2_B_65_BF16) U43.7(S_B)
QSPI1_DQ0: U1.AM19(IO_L22P_T3U_N6_DBC_AD0P_D04_65_AM19) U43.15(DQ0)
QSPI1_DQ1: U1.AM18(IO_L22N_T3U_N7_DBC_AD0N_D05_65_AM18) U43.8(DQ1)
QSPI1_DQ2: R1019.2 U1.AN20(IO_L21P_T3L_N4_AD8P_D06_65_AN20) U43.9(DQ2_VPP_WP_B)
QSPI1_DQ3: R191.2 U1.AP20(IO_L21N_T3L_N5_AD8N_D07_65_AP20) U43.1(DQ3_HOLD_B)
QSPI_CLK: U1.AF13(CCLK_0_AF13) U43.16(C) U133.16(C)
QSPI_RESET_B: R1328.2 U43.3(RESET_B) U133.3(RESET_B)
REG_EN: R499.2 U4.12(EN) U6.12(EN) U9.12(EN) U15.4(OUT) U25.1(A) U164.9(VR_ON) U165.9(VR_ON) U166.9(VR_ON)
REG_SYNC: R141.1 R362.1 R1070.1 R1143.1 R1144.1
RJ45_LGRN_PWR: J10.16(LEFT_GREEN_AN) R82.2
RJ45_RGRN_PWR: J10.14(RIGHT_GREEN_AN) R81.2
RLD3_C3_72B_0_VREF: C1233.1(CAP2) R988.1 R989.2 U141.A7(VREF1) U141.N7(VREF2)
RLD3_C3_72B_0_ZQ: R1145.1 U141.F7(ZQ)
RLD3_C3_72B_1_VREF: C1236.1(CAP2) R1141.1 R1142.2 U142.A7(VREF1) U142.N7(VREF2)
RLD3_C3_72B_1_ZQ: R1007.1 U142.F7(ZQ)
RLD3_C3_72B_A0: R964.2 U1.A29(IO_T3U_N12_47_A29) U141.E2(A0) U142.E2(A0)
RLD3_C3_72B_A1: R965.2 U1.C29(IO_L24N_T3U_N11_47_C29) U141.F5(A1) U142.F5(A1)
RLD3_C3_72B_A2: R966.2 U1.D29(IO_L24P_T3U_N10_47_D29) U141.F4(A2) U142.F4(A2)
RLD3_C3_72B_A3: R967.2 U1.B30(IO_L23N_T3U_N9_47_B30) U141.F9(A3) U142.F9(A3)
RLD3_C3_72B_A4: R968.2 U1.C30(IO_L23P_T3U_N8_47_C30) U141.F10(A4) U142.F10(A4)
RLD3_C3_72B_A5: R969.2 U1.A31(IO_L22N_T3U_N7_DBC_AD0N_47_A31) U141.F12(A5) U142.F12(A5)
RLD3_C3_72B_A6: R970.2 U1.A30(IO_L22P_T3U_N6_DBC_AD0P_47_A30) U141.G3(A6) U142.G3(A6)
RLD3_C3_72B_A7: R971.2 U1.A33(IO_L21N_T3L_N5_AD8N_47_A33) U141.F1(A7) U142.F1(A7)
RLD3_C3_72B_A8: R972.2 U1.B33(IO_L21P_T3L_N4_AD8P_47_B33) U141.G11(A8) U142.G11(A8)
RLD3_C3_72B_A9: R973.2 U1.B32(IO_L20N_T3L_N3_AD1N_47_B32) U141.F13(A9) U142.F13(A9)
RLD3_C3_72B_A10: R974.2 U1.B31(IO_L20P_T3L_N2_AD1P_47_B31) U141.H13(A10) U142.H13(A10)
RLD3_C3_72B_A11: R955.2 U1.C33(IO_L19N_T3L_N1_DBC_AD9N_47_C33) U141.D1(A11) U142.D1(A11)
RLD3_C3_72B_A12: R956.2 U1.C32(IO_L19P_T3L_N0_DBC_AD9P_47_C32) U141.H11(A12) U142.H11(A12)
RLD3_C3_72B_A13: R957.2 U1.D30(IO_T2U_N12_47_D30) U141.D13(A13) U142.D13(A13)
RLD3_C3_72B_A14: R958.2 U1.E29(IO_L18N_T2U_N11_AD2N_47_E29) U141.H3(A14) U142.H3(A14)
RLD3_C3_72B_A15: R959.2 U1.F29(IO_L18P_T2U_N10_AD2P_47_F29) U141.G2(A15) U142.G2(A15)
RLD3_C3_72B_A16: R960.2 U1.D32(IO_L17N_T2U_N9_AD10N_47_D32) U141.H4(A16) U142.H4(A16)
RLD3_C3_72B_A17: R961.2 U1.E32(IO_L17P_T2U_N8_AD10P_47_E32) U141.H10(A17) U142.H10(A17)
RLD3_C3_72B_A18: R962.2 U1.D31(IO_L16N_T2U_N7_QBC_AD3N_47_D31) U141.G12(A18) U142.G12(A18)
RLD3_C3_72B_A19: R963.2 U1.E31(IO_L16P_T2U_N6_QBC_AD3P_47_E31) U141.H1(NF_A19) U142.H1(NF_A19)
RLD3_C3_72B_A20: R990.2 U1.R28(IO_L1P_T0L_N0_DBC_47_R28) U141.F2(NF_A20) U142.F2(NF_A20)
RLD3_C3_72B_BA0: R978.2 U1.E33(IO_L15N_T2L_N5_AD11N_47_E33) U141.G9(BA0) U142.G9(BA0)
RLD3_C3_72B_BA1: R977.2 U1.F33(IO_L15P_T2L_N4_AD11P_47_F33) U141.G5(BA1) U142.G5(BA1)
RLD3_C3_72B_BA2: R976.2 U1.F30(IO_L14N_T2L_N3_GC_47_F30) U141.H8(BA2) U142.H8(BA2)
RLD3_C3_72B_BA3: R975.2 U1.G30(IO_L14P_T2L_N2_GC_47_G30) U141.H6(BA3) U142.H6(BA3)
RLD3_C3_72B_CK_N: R1292.1 U1.H30(IO_L11N_T1U_N9_GC_47_H30) U141.G7(CK_B) U142.G7(CK_B)
RLD3_C3_72B_CK_P: R951.1 U1.H29(IO_L11P_T1U_N8_GC_47_H29) U141.H7(CK) U142.H7(CK)
RLD3_C3_72B_CS_B: R952.2 U1.N29(IO_L5N_T0U_N9_AD14N_47_N29) U141.E12(CS_B) U142.E12(CS_B)
RLD3_C3_72B_DK0_N: U1.J31(IO_L7N_T1L_N1_QBC_AD13N_47_J31) U141.C7(DK0_B)
RLD3_C3_72B_DK0_P: U1.K31(IO_L7P_T1L_N0_QBC_AD13P_47_K31) U141.D7(DK0)
RLD3_C3_72B_DK1_N: U1.J32(IO_L8N_T1L_N3_AD5N_47_J32) U141.L7(DK1_B)
RLD3_C3_72B_DK1_P: U1.K32(IO_L8P_T1L_N2_AD5P_47_K32) U141.K7(DK1)
RLD3_C3_72B_DK2_N: U1.J30(IO_L9N_T1L_N5_AD12N_47_J30) U142.C7(DK0_B)
RLD3_C3_72B_DK2_P: U1.J29(IO_L9P_T1L_N4_AD12P_47_J29) U142.D7(DK0)
RLD3_C3_72B_DK3_N: U1.G33(IO_L10N_T1U_N7_QBC_AD4N_47_G33) U142.L7(DK1_B)
RLD3_C3_72B_DK3_P: U1.H33(IO_L10P_T1U_N6_QBC_AD4P_47_H33) U142.K7(DK1)
RLD3_C3_72B_DM0: U1.F39(IO_L6N_T0U_N11_AD6N_46_F39) U141.B7(DM0)
RLD3_C3_72B_DM1: U1.A35(IO_L24N_T3U_N11_46_A35) U141.M7(DM1)
RLD3_C3_72B_DM2: U1.N24(IO_L6N_T0U_N11_AD6N_48_N24) U142.B7(DM0)
RLD3_C3_72B_DM3: U1.B25(IO_L24N_T3U_N11_48_B25) U142.M7(DM1)
RLD3_C3_72B_DQ0: U1.H39(IO_L2P_T0L_N2_46_H39) U141.D11(DQ0)
RLD3_C3_72B_DQ1: U1.H40(IO_L2N_T0L_N3_46_H40) U141.E10(DQ1)
RLD3_C3_72B_DQ2: U1.G40(IO_L3P_T0L_N4_AD15P_46_G40) U141.C8(DQ2)
RLD3_C3_72B_DQ3: U1.F40(IO_L3N_T0L_N5_AD15N_46_F40) U141.C10(DQ3)
RLD3_C3_72B_DQ4: U1.H38(IO_L4P_T0U_N6_DBC_AD7P_46_H38) U141.C12(DQ4)
RLD3_C3_72B_DQ5: U1.G38(IO_L4N_T0U_N7_DBC_AD7N_46_G38) U141.B9(DQ5)
RLD3_C3_72B_DQ6: U1.K37(IO_L5P_T0U_N8_AD14P_46_K37) U141.B11(DQ6)
RLD3_C3_72B_DQ7: U1.J37(IO_L5N_T0U_N9_AD14N_46_J37) U141.A8(DQ7)
RLD3_C3_72B_DQ8: U1.F38(IO_L6P_T0U_N10_AD6P_46_F38) U141.A10(DQ8)
RLD3_C3_72B_DQ9: U1.J35(IO_L8P_T1L_N2_AD5P_46_J35) U141.J10(DQ9)
RLD3_C3_72B_DQ10: U1.H35(IO_L8N_T1L_N3_AD5N_46_H35) U141.K11(DQ10)
RLD3_C3_72B_DQ11: U1.J36(IO_L9P_T1L_N4_AD12P_46_J36) U141.K13(DQ11)
RLD3_C3_72B_DQ12: U1.H37(IO_L9N_T1L_N5_AD12N_46_H37) U141.L8(DQ12)
RLD3_C3_72B_DQ13: U1.H34(IO_L10P_T1U_N6_QBC_AD4P_46_H34) U141.L10(DQ13)
RLD3_C3_72B_DQ14: U1.G35(IO_L10N_T1U_N7_QBC_AD4N_46_G35) U141.L12(DQ14)
RLD3_C3_72B_DQ15: U1.F35(IO_L11P_T1U_N8_GC_46_F35) U141.M9(DQ15)
RLD3_C3_72B_DQ16: U1.F36(IO_L11N_T1U_N9_GC_46_F36) U141.M11(DQ16)
RLD3_C3_72B_DQ17: U1.G36(IO_L12P_T1U_N10_GC_46_G36) U141.N8(DQ17)
RLD3_C3_72B_DQ18: U1.E37(IO_L14P_T2L_N2_GC_46_E37) U141.D3(DQ18)
RLD3_C3_72B_DQ19: U1.E38(IO_L14N_T2L_N3_GC_46_E38) U141.E4(DQ19)
RLD3_C3_72B_DQ20: U1.C39(IO_L15P_T2L_N4_AD11P_46_C39) U141.C6(DQ20)
RLD3_C3_72B_DQ21: U1.B40(IO_L15N_T2L_N5_AD11N_46_B40) U141.C4(DQ21)
RLD3_C3_72B_DQ22: U1.A39(IO_L16P_T2U_N6_QBC_AD3P_46_A39) U141.C2(DQ22)
RLD3_C3_72B_DQ23: U1.A40(IO_L16N_T2U_N7_QBC_AD3N_46_A40) U141.B5(DQ23)
RLD3_C3_72B_DQ24: U1.D40(IO_L17P_T2U_N8_AD10P_46_D40) U141.B3(DQ24)
RLD3_C3_72B_DQ25: U1.C40(IO_L17N_T2U_N9_AD10N_46_C40) U141.A6(DQ25)
RLD3_C3_72B_DQ26: U1.B38(IO_L18P_T2U_N10_AD2P_46_B38) U141.A4(DQ26)
RLD3_C3_72B_DQ27: U1.D35(IO_L20P_T3L_N2_AD1P_46_D35) U141.J4(DQ27)
RLD3_C3_72B_DQ28: U1.C35(IO_L20N_T3L_N3_AD1N_46_C35) U141.K3(DQ28)
RLD3_C3_72B_DQ29: U1.D34(IO_L21P_T3L_N4_AD8P_46_D34) U141.K1(DQ29)
RLD3_C3_72B_DQ30: U1.C34(IO_L21N_T3L_N5_AD8N_46_C34) U141.L6(DQ30)
RLD3_C3_72B_DQ31: U1.B36(IO_L22P_T3U_N6_DBC_AD0P_46_B36) U141.L4(DQ31)
RLD3_C3_72B_DQ32: U1.B37(IO_L22N_T3U_N7_DBC_AD0N_46_B37) U141.L2(DQ32)
RLD3_C3_72B_DQ33: U1.B35(IO_L23P_T3U_N8_46_B35) U141.M5(DQ33)
RLD3_C3_72B_DQ34: U1.A36(IO_L23N_T3U_N9_46_A36) U141.M3(DQ34)
RLD3_C3_72B_DQ35: U1.A34(IO_L24P_T3U_N10_46_A34) U141.N6(DQ35)
RLD3_C3_72B_DQ36: U1.T24(IO_L2P_T0L_N2_48_T24) U142.D11(DQ0)
RLD3_C3_72B_DQ37: U1.R24(IO_L2N_T0L_N3_48_R24) U142.E10(DQ1)
RLD3_C3_72B_DQ38: U1.R27(IO_L3P_T0L_N4_AD15P_48_R27) U142.C8(DQ2)
RLD3_C3_72B_DQ39: U1.P27(IO_L3N_T0L_N5_AD15N_48_P27) U142.C10(DQ3)
RLD3_C3_72B_DQ40: U1.P25(IO_L4P_T0U_N6_DBC_AD7P_48_P25) U142.C12(DQ4)
RLD3_C3_72B_DQ41: U1.N25(IO_L4N_T0U_N7_DBC_AD7N_48_N25) U142.B9(DQ5)
RLD3_C3_72B_DQ42: U1.P26(IO_L5P_T0U_N8_AD14P_48_P26) U142.B11(DQ6)
RLD3_C3_72B_DQ43: U1.N27(IO_L5N_T0U_N9_AD14N_48_N27) U142.A8(DQ7)
RLD3_C3_72B_DQ44: U1.P24(IO_L6P_T0U_N10_AD6P_48_P24) U142.A10(DQ8)
RLD3_C3_72B_DQ45: U1.M25(IO_L8P_T1L_N2_AD5P_48_M25) U142.J10(DQ9)
RLD3_C3_72B_DQ46: U1.L26(IO_L8N_T1L_N3_AD5N_48_L26) U142.K11(DQ10)
RLD3_C3_72B_DQ47: U1.L28(IO_L9P_T1L_N4_AD12P_48_L28) U142.K13(DQ11)
RLD3_C3_72B_DQ48: U1.K28(IO_L9N_T1L_N5_AD12N_48_K28) U142.L8(DQ12)
RLD3_C3_72B_DQ49: U1.L24(IO_L10P_T1U_N6_QBC_AD4P_48_L24) U142.L10(DQ13)
RLD3_C3_72B_DQ50: U1.L25(IO_L10N_T1U_N7_QBC_AD4N_48_L25) U142.L12(DQ14)
RLD3_C3_72B_DQ51: U1.K26(IO_L11P_T1U_N8_GC_48_K26) U142.M9(DQ15)
RLD3_C3_72B_DQ52: U1.J26(IO_L11N_T1U_N9_GC_48_J26) U142.M11(DQ16)
RLD3_C3_72B_DQ53: U1.K27(IO_L12P_T1U_N10_GC_48_K27) U142.N8(DQ17)
RLD3_C3_72B_DQ54: U1.H27(IO_L14P_T2L_N2_GC_48_H27) U142.D3(DQ18)
RLD3_C3_72B_DQ55: U1.G27(IO_L14N_T2L_N3_GC_48_G27) U142.E4(DQ19)
RLD3_C3_72B_DQ56: U1.F28(IO_L15P_T2L_N4_AD11P_48_F28) U142.C6(DQ20)
RLD3_C3_72B_DQ57: U1.E28(IO_L15N_T2L_N5_AD11N_48_E28) U142.C4(DQ21)
RLD3_C3_72B_DQ58: U1.H28(IO_L16P_T2U_N6_QBC_AD3P_48_H28) U142.C2(DQ22)
RLD3_C3_72B_DQ59: U1.G28(IO_L16N_T2U_N7_QBC_AD3N_48_G28) U142.B5(DQ23)
RLD3_C3_72B_DQ60: U1.E26(IO_L17P_T2U_N8_AD10P_48_E26) U142.B3(DQ24)
RLD3_C3_72B_DQ61: U1.E27(IO_L17N_T2U_N9_AD10N_48_E27) U142.A6(DQ25)
RLD3_C3_72B_DQ62: U1.G25(IO_L18P_T2U_N10_AD2P_48_G25) U142.A4(DQ26)
RLD3_C3_72B_DQ63: U1.B28(IO_L20P_T3L_N2_AD1P_48_B28) U142.J4(DQ27)
RLD3_C3_72B_DQ64: U1.A28(IO_L20N_T3L_N3_AD1N_48_A28) U142.K3(DQ28)
RLD3_C3_72B_DQ65: U1.C27(IO_L21P_T3L_N4_AD8P_48_C27) U142.K1(DQ29)
RLD3_C3_72B_DQ66: U1.B27(IO_L21N_T3L_N5_AD8N_48_B27) U142.L6(DQ30)
RLD3_C3_72B_DQ67: U1.B26(IO_L22P_T3U_N6_DBC_AD0P_48_B26) U142.L4(DQ31)
RLD3_C3_72B_DQ68: U1.A26(IO_L22N_T3U_N7_DBC_AD0N_48_A26) U142.L2(DQ32)
RLD3_C3_72B_DQ69: U1.D25(IO_L23P_T3U_N8_48_D25) U142.M5(DQ33)
RLD3_C3_72B_DQ70: U1.D26(IO_L23N_T3U_N9_48_D26) U142.M3(DQ34)
RLD3_C3_72B_DQ71: U1.C25(IO_L24P_T3U_N10_48_C25) U142.N6(DQ35)
RLD3_C3_72B_QK0_N: U1.J40(IO_L1N_T0L_N1_DBC_46_J40) U141.E8(QK0_B)
RLD3_C3_72B_QK0_P: U1.J39(IO_L1P_T0L_N0_DBC_46_J39) U141.D9(QK0)
RLD3_C3_72B_QK1_N: U1.E34(IO_L7N_T1L_N1_QBC_AD13N_46_E34) U141.J8(QK1_B)
RLD3_C3_72B_QK1_P: U1.F34(IO_L7P_T1L_N0_QBC_AD13P_46_F34) U141.K9(QK1)
RLD3_C3_72B_QK2_N: U1.D39(IO_L13N_T2L_N1_GC_QBC_46_D39) U141.E6(QK2_B)
RLD3_C3_72B_QK2_P: U1.E39(IO_L13P_T2L_N0_GC_QBC_46_E39) U141.D5(QK2)
RLD3_C3_72B_QK3_N: U1.C37(IO_L19N_T3L_N1_DBC_AD9N_46_C37) U141.J6(QK3_B)
RLD3_C3_72B_QK3_P: U1.D37(IO_L19P_T3L_N0_DBC_AD9P_46_D37) U141.K5(QK3)
RLD3_C3_72B_QK4_N: U1.R26(IO_L1N_T0L_N1_DBC_48_R26) U142.E8(QK0_B)
RLD3_C3_72B_QK4_P: U1.T26(IO_L1P_T0L_N0_DBC_48_T26) U142.D9(QK0)
RLD3_C3_72B_QK5_N: U1.M28(IO_L7N_T1L_N1_QBC_AD13N_48_M28) U142.J8(QK1_B)
RLD3_C3_72B_QK5_P: U1.M27(IO_L7P_T1L_N0_QBC_AD13P_48_M27) U142.K9(QK1)
RLD3_C3_72B_QK6_N: U1.F26(IO_L13N_T2L_N1_GC_QBC_48_F26) U142.E6(QK2_B)
RLD3_C3_72B_QK6_P: U1.G26(IO_L13P_T2L_N0_GC_QBC_48_G26) U142.D5(QK2)
RLD3_C3_72B_QK7_N: U1.C28(IO_L19N_T3L_N1_DBC_AD9N_48_C28) U142.J6(QK3_B)
RLD3_C3_72B_QK7_P: U1.D27(IO_L19P_T3L_N0_DBC_AD9P_48_D27) U142.K5(QK3)
RLD3_C3_72B_QVLD0: U1.G37(IO_L12N_T1U_N11_GC_46_G37) U141.J12(QVLD0)
RLD3_C3_72B_QVLD1: U1.A38(IO_L18N_T2U_N11_AD2N_46_A38) U141.J2(QVLD1)
RLD3_C3_72B_QVLD2: U1.J27(IO_L12N_T1U_N11_GC_48_J27) U142.J12(QVLD0)
RLD3_C3_72B_QVLD3: U1.F25(IO_L18N_T2U_N11_AD2N_48_F25) U142.J2(QVLD1)
RLD3_C3_72B_REF_B: R953.2 U1.L30(IO_L6N_T0U_N11_AD6N_47_L30) U141.F8(REF_B) U142.F8(REF_B)
RLD3_C3_72B_RESET_B: U1.L29(IO_L6P_T0U_N10_AD6P_47_L29) U141.A13(RESET_B) U142.A13(RESET_B)
RLD3_C3_72B_TCK: J105.5(P5) R1195.2 U141.N2(TCK) U142.N2(TCK)
RLD3_C3_72B_TDI: J105.3(P3) R1194.2 U141.N10(TDI)
RLD3_C3_72B_TMS: J105.4(P4) R1193.2 U141.N12(TMS) U142.N12(TMS)
RLD3_C3_72B_WE_B: R954.2 U1.K29(IO_T1U_N12_47_K29) U141.F6(WE_B) U142.F6(WE_B)
RLD3_C3_COMP1_72B_TDO: U141.N4(TDO) U142.N10(TDI)
RLD3_C3_COMP2_72B_TDO: J105.2(P2) U142.N4(TDO)
RLD3_C3_VTERM_0V6: C1237.1(CAP2) C1238.1(CAP2) C1239.1(CAP2) C1240.1(CAP2) C1241.1(CAP2) C1242.1(CAP2) C1243.1(CAP2) C1244.1(CAP2) C1245.1(CAP2) C1246.1(CAP2) C1388.1(CAP2) C1389.1(CAP2) C1390.1(CAP2) J104.1(P1) R952.1 R953.1 R954.1 R955.1 R956.1 R957.1 R958.1 R959.1 R960.1 R961.1 R962.1 R963.1 R964.1 R965.1 R966.1 R967.1 R968.1 R969.1 R970.1 R971.1 R972.1 R973.1 R974.1 R975.1 R976.1 R977.1 R978.1 R990.1 U143.3(VO) Z87.1(NET1)
RLD3_C3_VTERM_0V6_PGOOD: Q41.1(GATE) R1008.2 U143.9(PGOOD)
RLD3_EN: R1009.2 U143.7(EN)
RLD3_REFIN: C1289.1(CAP2) R991.2 R992.1 U143.1(REFIN)
RLD3_REFOUT: C1247.1(CAP2) U143.6(REFOUT)
RLD3_SENSE: U143.5(VOSNS) Z87.2(NET2)
RX_CTRL: R57.2 R65.1 U7.38(RX_CTRL)
SDIO_CD: J83.13(DETECT) R1101.2 U111.D8(PS_MIO0_500_D8)
SDIO_CLK: R1103.1 R1104.1 U111.B7(PS_MIO12_500_B7) U154.12(CLK_VL)
SDIO_CMD: U111.B10(PS_MIO11_500_B10) U154.10(IO_VL5)
SDIO_CONN_CLK: J83.5(CLK) U154.14(CLK_VCC)
SDIO_CONN_CMD: J83.3(CMD) U154.8(IO_VCC5)
SDIO_CONN_DATA0: J83.7(DAT0) U154.15(IO_VCC1)
SDIO_CONN_DATA1: J83.8(DAT1) U154.5(IO_VCC2)
SDIO_CONN_DATA2: J83.1(DAT2) U154.6(IO_VCC3)
SDIO_CONN_DATA3: J83.2(CD_DAT3) U154.7(IO_VCC4)
SDIO_DATA0: U111.D6(PS_MIO10_500_D6) U154.1(IO_VL1)
SDIO_DATA1: U111.C6(PS_MIO13_500_C6) U154.3(IO_VL2)
SDIO_DATA2: U111.B9(PS_MIO14_500_B9) U154.4(IO_VL3)
SDIO_DATA3: U111.D10(PS_MIO15_500_D10) U154.9(IO_VL4)
SI570_0_OUTPUT_N: R36.1 U18.5(OUT_B) U157.4(CLK1_N)
SI570_0_OUTPUT_P: R36.2 U18.4(OUT) U157.3(CLK1_P)
SI570_1_OUTPUT_N: R687.1 U32.5(OUT_B) U104.7(CLK0_N)
SI570_1_OUTPUT_P: R687.2 U32.4(OUT) U104.6(CLK0_P)
SI5328_CLOCK1_C_N: C24.2(CAP1) U1.U8(MGTREFCLK1N_231_U8)
SI5328_CLOCK1_C_P: C23.2(CAP1) U1.U9(MGTREFCLK1P_231_U9)
SI5328_CLOCK1_N: C24.1(CAP2) U57.29(CKOUT1_N)
SI5328_CLOCK1_P: C23.1(CAP2) U57.28(CKOUT1_P)
SI5328_CLOCK2_C_N: C1363.2(CAP1) U1.N8(MGTREFCLK1N_232_N8)
SI5328_CLOCK2_C_P: C1364.2(CAP1) U1.N9(MGTREFCLK1P_232_N9)
SI5328_CLOCK2_N: C1363.1(CAP2) U57.34(CKOUT2_N)
SI5328_CLOCK2_P: C1364.1(CAP2) U57.35(CKOUT2_P)
SI5328_INT_ALM: U17.12(B7) U57.3(INT_C1B)
SI5328_INT_ALM_LS: U1.H20(IO_T2U_N12_72_H20) U17.9(A7)
SI5328_RST_B: U3.13(B6) U57.1(RST_B)
SI5328_RST_LS_B: R1092.2 U1.BC21(IO_L6P_T0U_N10_AD6P_64_BC21) U3.8(A6)
SI5328_SCL: R612.2 U28.14(SC4) U57.22(SCL)
SI5328_SDA: R611.2 U28.13(SD4) U57.23(SDA_SDO)
SI5328_VCC: C26.1(CAP2) C27.1(CAP2) C294.1(CAP2) L31.1 U57.5(VDD1) U57.10(VDD2) U57.32(VDD3)
SI5328_XTAL_XA: U57.6(XA) X5.1(XA)
SI5328_XTAL_XB: U57.7(XB) X5.3(XB)
SIT9122_N: R37.2 U14.5(OUT_N) U21.6(NCLK)
SIT9122_P: R37.1 U14.4(OUT_P) U21.7(CLK)
SM_FAN_PWM: Q61.1(GATE) R422.2 U31.12(PWM_OUT)
SM_FAN_TACH: J73.3(P3) R1327.2 U31.10(FAN_IN2) U31.11(FAN_IN1)
SYS1V0_LX: L63.1 U124.A2(LX)
SYS2V5_LX: L73.1 U151.A2(LX)
SYS_1V0: C78.1(CAP2) C82.1(CAP2) C103.1(CAP2) C109.1(CAP2) C110.1(CAP2) C111.1(CAP2) C133.1(CAP2) C134.1(CAP2) C135.1(CAP2) C136.1(CAP2) C788.1(CAP2) C798.1(CAP2) C806.1(CAP2) C816.1(CAP2) C820.1(CAP2) C821.1(CAP2) C822.1(CAP2) C833.1(CAP2) C834.1(CAP2) C865.1(CAP2) C867.1(CAP2) C868.1(CAP2) C879.1(CAP2) J86.1(P1) L63.2 R814.1 R817.1 U7.6(VDD1P1_1_8) U7.24(VDD1P1_2_29) U7.31(VDD1P1_3_42) U7.42(VDD1P1_4_58) U111.E10(VCCINT_E10) U111.F9(VCCINT_F9) U111.G6(VCCPINT_G6) U111.G10(VCCINT_G10) U111.H5(VCCPINT_H5) U111.J10(VCCINT_J10) U111.K5(VCCPINT_K5) U111.L10(VCCINT_L10) U128.16(DISC1)
SYS_1V0_PGOOD: Q36.1(GATE) R828.2 U124.C3(PGOOD)
SYS_1V0_POR_B: R823.2 U124.B3(EN) U128.17(OUT1)
SYS_1V8: C79.1(CAP2) C83.1(CAP2) C114.1(CAP2) C115.1(CAP2) C116.1(CAP2) C140.1(CAP2) C141.1(CAP2) C142.1(CAP2) C775.1(CAP2) C780.1(CAP2) C789.1(CAP2) C790.1(CAP2) C791.1(CAP2) C792.1(CAP2) C795.1(CAP2) C796.1(CAP2) C801.1(CAP2) C803.1(CAP2) C805.1(CAP2) C808.1(CAP2) C810.1(CAP2) C811.1(CAP2) C825.1(CAP2) C828.1(CAP2) C830.1(CAP2) C837.1(CAP2) C841.1(CAP2) C842.1(CAP2) C843.1(CAP2) C844.1(CAP2) C848.1(CAP2) C849.1(CAP2) C850.1(CAP2) C851.1(CAP2) C852.1(CAP2) C853.1(CAP2) C876.1(CAP2) C1566.1(CAP2) D15.3 J70.1(P1) J82.1(P1) L60.1 L62.2 Q23.1(GATE) R26.1 R27.1 R29.1 R30.1 R31.1 R34.1 R39.1 R54.1 R55.1 R56.1 R57.1 R60.1 R61.1 R68.1 R70.1 R198.1 R201.1 R203.1 R205.2 R206.2 R334.1 R724.1 R726.1 R748.1 R776.1 R802.1 R803.1 R816.1 R820.1 R826.1 R832.1 R854.1 R855.1 R856.1 R857.1 R860.2 R1101.1 R1103.2 R1196.1 R1197.1 SW15.5 SW15.6 SW15.7 SW15.8 SW16.8 U7.19(VDDIO3_57) U7.30(VDDIO2_41) U7.41(VDDIO1_23) U109.2(VREFA) U111.A6(VCCO_MIO0_500_A6) U111.B3(VCCO_DDR_502_B3) U111.B13(VCCO_MIO1_501_B13) U111.C10(VCCO_MIO1_501_C10) U111.D7(VCCO_MIO0_500_D7) U111.E4(VCCO_DDR_502_E4) U111.E6(VCCBATT_0_E6) U111.E14(VCCO_MIO1_501_E14) U111.F1(VCCO_DDR_502_F1) U111.G4(RSVDVCC_G4) U111.H4(RSVDVCC_H4) U111.H9(VCCAUX_H9) U111.J2(VCCO_DDR_502_J2) U111.J4(RSVDVCC_J4) U111.J6(VCCPAUX_J6) U111.J8(VCCAUX_J8) U111.J12(VCCO_34_J12) U111.K8(VCCO_0_K8) U111.K9(VCCAUX_K9) U111.L6(VCCPAUX_L6) U111.M3(VCCO_DDR_502_M3) U111.M13(VCCO_34_M13) U111.N10(VCCO_34_N10) U111.P7(VCCO_34_P7) U111.R4(VCCO_DDR_502_R4) U111.R14(VCCO_34_R14) U114.2(VCC) U122.7(VDD1) U122.11(VDDO3) U122.15(VDDO2) U122.16(VDDO1) U122.20(VDDO0) U122.24(VDD2) U125.9(OUT2) U125.10(OUT1) U128.13(DISC2) U154.2(VL)
SYS_1V8_POR_B: R163.2 R824.2 U10.5(EN) U125.5(EN) U128.12(OUT2)
SYS_2V2: C75.1(CAP2) C192.1(CAP2) C522.1(CAP2) J28.1(P1) R75.1 R164.1 R166.1 R354.1 R355.1 R580.1 R601.1 R602.1 U10.9(OUT2) U10.10(OUT1) U28.24(VCC) U80.24(VCC)
SYS_2V5: C80.1(CAP2) C84.1(CAP2) C112.1(CAP2) C113.1(CAP2) C137.1(CAP2) C139.1(CAP2) C555.1(CAP2) C560.1(CAP2) C603.1(CAP2) C604.1(CAP2) C697.1(CAP2) C700.1(CAP2) C704.1(CAP2) C707.1(CAP2) C955.1(CAP2) C1054.1(CAP2) C1145.1(CAP2) C1148.1(CAP2) C1151.1(CAP2) C1154.1(CAP2) C1160.1(CAP2) C1167.1(CAP2) C1170.1(CAP2) C1173.1(CAP2) C1176.1(CAP2) C1182.1(CAP2) C1280.1(CAP2) C1281.1(CAP2) C1287.1(CAP2) C1288.1(CAP2) C1294.1(CAP2) C1295.1(CAP2) C1300.1(CAP2) C1301.1(CAP2) C1343.1(CAP2) C1353.1(CAP2) C1354.1(CAP2) C1359.1(CAP2) J99.1(P1) L73.2 R819.1 R1096.1 U7.3(VDDA2P5_1_4) U7.9(VDDA2P5_2_12) U60.B1(VPP1) U60.R9(VPP2) U61.B1(VPP1) U61.R9(VPP2) U62.B1(VPP1) U62.R9(VPP2) U63.B1(VPP1) U63.R9(VPP2) U64.B1(VPP1) U64.R9(VPP2) U128.10(DISC3) U135.B1(VPP1) U135.R9(VPP2) U136.B1(VPP1) U136.R9(VPP2) U137.B1(VPP1) U137.R9(VPP2) U138.B1(VPP1) U138.R9(VPP2) U139.B1(VPP1) U139.R9(VPP2) U141.B1(VEXT1) U141.B13(VEXT2) U141.M1(VEXT3) U141.M13(VEXT4) U142.B1(VEXT1) U142.B13(VEXT2) U142.M1(VEXT3) U142.M13(VEXT4)
SYS_2V5_PGOOD: Q6.1(GATE) R1100.2 U151.C3(PGOOD)
SYS_2V5_POR_B: R1192.2 U128.9(OUT3) U151.B3(EN)
SYSCLK1_300_C_N: C651.1(CAP2) U157.10(Q0_N)
SYSCLK1_300_C_P: C650.1(CAP2) U157.9(Q0_P)
SYSCLK1_300_N: C651.2(CAP1) R595.1 R597.2 R1177.1 U1.F31(IO_L13N_T2L_N1_GC_QBC_47_F31)
SYSCLK1_300_P: C650.2(CAP1) R594.1 R596.2 R1177.2 U1.G31(IO_L13P_T2L_N0_GC_QBC_47_G31)
SYSCLK2_300_N: R38.1 U104.4(CLK1_N) U157.12(Q1_N)
SYSCLK2_300_P: R38.2 U104.3(CLK1_P) U157.11(Q1_P)
SYSCLK_300_N: R1140.1 U122.21(CLK0B) U157.7(CLK0_N)
SYSCLK_300_P: R1140.2 U122.22(CLK0A) U157.6(CLK0_P)
SYSCLK_OEB_ALL: R792.1 U122.5(OEB_ALL)
SYSCLK_RESET: R793.1 U122.3(RESET)
SYSCTLR_AGND: C913.2(CAP1) C1567.2(CAP1) C1579.2(CAP1) L61.1 U111.F8(GNDADC_0_F8) U111.G8(VREFN_0_G8) U155.3(GND)
SYSCTLR_CFG_JTAG_TCK: R810.2 U111.N7(IO_L22P_T3_34_N7)
SYSCTLR_CFG_JTAG_TDI: R811.2 U111.P8(IO_L23P_T3_34_P8)
SYSCTLR_CFG_JTAG_TMS: R812.2 U111.N8(IO_L22N_T3_34_N8)
SYSCTLR_CLK: R799.2 U111.C7(PS_CLK_500_C7)
SYSCTLR_CLK_R: R799.1 U122.10(CLK3A)
SYSCTLR_DONE: Q3.1(GATE) R748.2 U111.M7(DONE_0_M7)
SYSCTLR_ENABLE: R1087.1 SW16.1 U111.K12(IO_L11N_T1_SRCC_34_K12)
SYSCTLR_ERR_LED: Q35.1(GATE) R96.1 U111.G12(IO_L2P_T0_34_G12)
SYSCTLR_GPIO_5: U1.BD21(IO_L6N_T0U_N11_AD6N_64_BD21) U111.D13(PS_MIO49_501_D13)
SYSCTLR_GPIO_6: U1.BA25(IO_L7P_T1L_N0_QBC_AD13P_64_BA25) U111.A12(PS_MIO52_501_A12)
SYSCTLR_GPIO_7: U1.BA24(IO_L7N_T1L_N1_QBC_AD13N_64_BA24) U111.C13(PS_MIO53_501_C13)
SYSCTLR_INIT_B: DS42.4(RED_CATHODE) Q7.1(GATE) R726.2 U111.D5(INIT_B_0_D5)
SYSCTLR_MODE0: R727.1 SW15.4 U111.E15(PS_MIO32_501_E15)
SYSCTLR_MODE1: R728.1 SW15.3 U111.C11(PS_MIO33_501_C11)
SYSCTLR_MODE2: R729.1 SW15.2 U111.D15(PS_MIO34_501_D15)
SYSCTLR_MODE3: R730.1 SW15.1 U111.A14(PS_MIO35_501_A14)
SYSCTLR_POR_B: R13.2 SW14.1(P1) SW14.2(P2) U111.C9(PS_POR_B_500_C9) U128.20(RESET_B)
SYSCTLR_QSPI_IO0: R774.1 U111.A8(PS_MIO2_500_A8) U114.15(DQ0)
SYSCTLR_QSPI_IO1: R773.1 U111.A7(PS_MIO3_500_A7) U114.8(DQ1)
SYSCTLR_QSPI_IO2: R772.1 U111.C8(PS_MIO4_500_C8) U114.9(DQ2_VPP_WP_B)
SYSCTLR_QSPI_IO3: J110.1(P1) R776.2 U111.A9(PS_MIO5_500_A9) U114.1(DQ3_HOLD_B)
SYSCTLR_QSPI_SCLK: R775.1 U111.A10(PS_MIO6_500_A10) U114.16(C)
SYSCTLR_QSPI_SS_B: U111.A5(PS_MIO1_500_A5) U114.7(S_B)
SYSCTLR_STAT_LED: Q34.1(GATE) R97.1 U111.H12(IO_L1N_T0_34_H12)
SYSCTLR_TCK: J82.3(P3) R857.2 U111.G9(TCK_0_G9)
SYSCTLR_TDI: J82.5(P5) R855.2 U111.L7(TDI_0_L7)
SYSCTLR_TDO: J82.6(P6) R854.2 U111.L8(TDO_0_L8)
SYSCTLR_TMS: J82.4(P4) R856.2 U111.L9(TMS_0_L9)
SYSCTLR_UART_RX: Q56.2(SOURCE) U111.B15(PS_MIO30_501_B15)
SYSCTLR_UART_TX: Q57.2(SOURCE) U111.C12(PS_MIO31_501_C12)
SYSCTLR_VREF: C913.1(CAP2) C1567.1(CAP2) U111.H7(VREFP_0_H7) U155.2(OUT)
SYSMON_AGND: C2.2(CAP1) L87.1 U1.AB17(GNDADC_AB17)
SYSMON_SCL: R618.2 U1.AP18(IO_L23P_T3U_N8_I2C_SCLK_65_AP18) U28.18(SC6)
SYSMON_SDA: R617.2 U1.AP17(IO_L23N_T3U_N9_PERSTN1_I2C_SDA_65_AP17) U28.17(SD6)
SYSMON_VCCADC: C1579.1(CAP2) L60.2 U111.F7(VCCADC_0_F7) U155.1(IN)
SYSMON_VN: R560.1 U1.AD17(VN_AD17)
SYSMON_VP: R547.2 R548.1 U1.AC18(VP_AC18)
USB_FLTR: C57.1(CAP2) C295.1(CAP2) C346.1(CAP2) C891.1(CAP2) L34.1 U34.7(REGIN) U34.8(VBUS) U131.1(IN) U131.3(SHDN_B)
USB_JTAG_DATA_N: J106.2(D_N) U115.12(DM) X7.2(D_N)
USB_JTAG_DATA_P: J106.3(D_P) U115.13(DP) X7.1(D_P)
USB_JTAG_FLTR: C1583.1(CAP2) C1640.1(CAP2) L93.1
USB_JTAG_GND: C1582.2(CAP1) J106.5(GND) L94.2
USB_JTAG_VBUS: C1582.1(CAP2) J106.1(VBUS) L93.2 X7.6(VBUS)
USB_POWERED_VIO: C543.1(CAP2) C892.1(CAP2) R498.2 R858.2 R860.1 U34.5(VIO) U131.5(OUT)
USB_UART_CTS: Q54.2(SOURCE) U1.BB22(IO_L8P_T1L_N2_AD5P_64_BB22)
USB_UART_DATA_N: J4.2(D_N) U34.4(D_N) X1.2(D_N)
USB_UART_DATA_P: J4.3(D_P) U34.3(D_P) X1.1(D_P)
USB_UART_RTS: Q55.2(SOURCE) U1.AY25(IO_L9N_T1L_N5_AD12N_64_AY25)
USB_UART_RX: Q52.2(SOURCE) U1.BB21(IO_L8N_T1L_N3_AD5N_64_BB21)
USB_UART_TX: Q53.2(SOURCE) U1.AW25(IO_L9P_T1L_N4_AD12P_64_AW25)
USB_VBUS: C55.1(CAP2) J4.1(VBUS) L34.2 X1.6(VBUS)
USB_VBUS_GND: C55.2(CAP1) J4.5(GND) L35.2
USER_SI570_0_CLOCK_SCL: R614.2 U18.8(SCL) U28.16(SC5)
USER_SI570_0_CLOCK_SDA: R613.2 U18.7(SDA) U28.15(SD5)
USER_SI570_1_CLOCK_SCL: R604.2 U28.5(SC0) U32.8(SCL)
USER_SI570_1_CLOCK_SDA: R603.2 U28.4(SD0) U32.7(SDA)
USER_SI570_2_CLOCK_SCL: R190.2 U38.8(SCL) U80.16(SC5)
USER_SI570_2_CLOCK_SDA: R189.2 U38.7(SDA) U80.15(SD5)
USER_SI570_CLOCK1_N: R174.1 R182.2 R184.1 U1.AW22(IO_L12N_T1U_N11_GC_64_AW22) U157.14(Q2_N)
USER_SI570_CLOCK1_P: R174.2 R181.2 R183.1 U1.AW23(IO_L12P_T1U_N10_GC_64_AW23) U157.13(Q2_P)
USER_SI570_CLOCK_N: R88.1 R178.2 R180.1 U1.G32(IO_L12N_T1U_N11_GC_47_G32) U104.10(Q0_N)
USER_SI570_CLOCK_P: R88.2 R177.2 R179.1 U1.H32(IO_L12P_T1U_N10_GC_47_H32) U104.9(Q0_P)
USER_SMA_CLOCK_N: J35.1(SIG) R8.2 U1.P32(IO_L11N_T1U_N9_GC_45_P32)
USER_SMA_CLOCK_P: J34.1(SIG) R8.1 U1.R32(IO_L11P_T1U_N8_GC_45_R32)
UTIL_1V35: C1269.1(CAP2) C1271.1(CAP2) C1277.1(CAP2) C1282.1(CAP2) C1283.1(CAP2) C1284.1(CAP2) C1290.1(CAP2) C1291.1(CAP2) C1296.1(CAP2) C1392.1(CAP2) C1424.1(CAP2) C1425.1(CAP2) C1426.1(CAP2) C1427.1(CAP2) D8.1(CATHODE) J97.1(P1) R152.2 U141.A3(VDD1) U141.A11(VDD2) U141.C1(VDD3) U141.C13(VDD4) U141.F3(VDD5) U141.F11(VDD6) U141.H2(VDD7) U141.H5(VDD8) U141.H9(VDD9) U141.H12(VDD10) U141.L1(VDD11) U141.L13(VDD12) U141.N3(VDD13) U141.N11(VDD14) U142.A3(VDD1) U142.A11(VDD2) U142.C1(VDD3) U142.C13(VDD4) U142.F3(VDD5) U142.F11(VDD6) U142.H2(VDD7) U142.H5(VDD8) U142.H9(VDD9) U142.H12(VDD10) U142.L1(VDD11) U142.L13(VDD12) U142.N3(VDD13) U142.N11(VDD14) Z91.2(NET2)
UTIL_1V35_DH_R: Q39.1(HSG) R1022.2
UTIL_1V35_DL: Q39.7(LSG) U150.19(DL)
UTIL_1V35_FET_SWITCH: C1325.2(CAP1) L66.1 Q39.2(SW1) Q39.3(SW2) Q39.4(SW3) R1029.1 R1076.2 R1079.2 U150.16(LX)
UTIL_1V35_PGOOD: D35.1(CATHODE) Q58.1(GATE) R1288.2 U150.32(PG)
UTIL_1V35_SNS_N: C1318.1(CAP2) C1329.2(CAP1) U150.26(OUTN) Z92.1(NET1)
UTIL_1V35_SNS_P: C1329.1(CAP2) U150.27(OUTP) Z91.1(NET1)
UTIL_1V35_TEMPX: C1330.1(CAP2) Q40.1(BASE) Q40.2(COLLECTOR) U150.7(TEMPX)
UTIL_3V3: C7.1(CAP2) C12.1(CAP2) C15.1(CAP2) C40.1(CAP2) C53.1(CAP2) C63.1(CAP2) C65.1(CAP2) C69.1(CAP2) C70.1(CAP2) C71.1(CAP2) C73.1(CAP2) C76.1(CAP2) C81.1(CAP2) C92.1(CAP2) C96.1(CAP2) C98.1(CAP2) C120.1(CAP2) C123.1(CAP2) C125.1(CAP2) C128.1(CAP2) C154.1(CAP2) C157.1(CAP2) C162.1(CAP2) C172.1(CAP2) C191.1(CAP2) C204.1(CAP2) C236.1(CAP2) C239.1(CAP2) C290.1(CAP2) C324.1(CAP2) C356.1(CAP2) C500.1(CAP2) C501.1(CAP2) C525.1(CAP2) C527.1(CAP2) C550.1(CAP2) C551.1(CAP2) C633.1(CAP2) C640.1(CAP2) C701.1(CAP2) C774.1(CAP2) C864.1(CAP2) C866.1(CAP2) C874.1(CAP2) C893.1(CAP2) C894.1(CAP2) C895.1(CAP2) C896.1(CAP2) C905.1(CAP2) C956.1(CAP2) C957.1(CAP2) C1013.1(CAP2) C1164.1(CAP2) C1273.1(CAP2) C1342.1(CAP2) C1344.1(CAP2) C1348.1(CAP2) C1349.1(CAP2) C1361.1(CAP2) C1362.1(CAP2) C1395.1(CAP2) C1396.1(CAP2) C1441.1(CAP2) C1551.1(CAP2) C1554.1(CAP2) C1586.1(CAP2) C1597.1(CAP2) C1602.1(CAP2) C1626.1(CAP2) C1628.1(CAP2) C1629.1(CAP2) C1630.1(CAP2) C1631.1(CAP2) C1644.1(CAP2) C1645.1(CAP2) C1646.1(CAP2) C1647.1(CAP2) C1652.1(CAP2) C1653.1(CAP2) C1654.1(CAP2) C1655.1(CAP2) C1659.1(CAP2) C1667.1(CAP2) C1673.1(CAP2) C1753.1(CAP2) DS2.3(RED_ANODE) DS3.3(RED_ANODE) DS34.2 J2.C39(3P3V_1) J2.D32(3P3VAUX) J2.D36(3P3V_2) J2.D38(3P3V_3) J2.D40(3P3V_4) J8.1(P1) J9.1(P1) J22.C39(3P3V_1) J22.D32(3P3VAUX) J22.D36(3P3V_2) J22.D38(3P3V_3) J22.D40(3P3V_4) J22.Z40(3P3V_5) J52.11(P11) J52.12(P12) J53.11(P11) J53.12(P12) J83.4(VDD) J103.1(P1) L1.1 L2.1 L4.2 L5.2 L31.2 L70.1 L71.1 L72.1 L86.1 Q52.1(GATE) Q53.1(GATE) Q54.1(GATE) Q55.1(GATE) Q56.1(GATE) Q57.1(GATE) R1.1 R2.1 R11.1 R13.1 R19.1 R28.1 R33.1 R77.1 R81.1 R82.1 R85.1 R86.1 R89.1 R90.1 R91.1 R92.1 R93.1 R94.1 R106.1 R107.1 R125.1 R126.1 R127.1 R128.1 R129.1 R130.1 R131.1 R132.1 R142.1 R143.1 R144.1 R145.1 R146.1 R147.1 R148.1 R149.1 R151.1 R153.1 R163.1 R189.1 R190.1 R192.1 R208.1 R213.1 R217.1 R218.1 R220.1 R221.1 R308.1 R321.1 R323.1 R327.1 R331.2 R388.1 R389.1 R399.1 R422.1 R492.1 R499.1 R500.1 R501.1 R502.1 R603.1 R604.1 R607.1 R608.1 R611.1 R612.1 R613.1 R614.1 R621.1 R622.1 R623.1 R624.1 R625.1 R626.1 R627.1 R628.1 R629.1 R630.1 R639.1 R640.1 R784.1 R785.1 R786.1 R787.1 R818.1 R823.1 R824.1 R828.1 R888.1 R890.1 R928.1 R929.1 R934.1 R945.1 R1008.1 R1009.1 R1013.1 R1094.1 R1095.1 R1100.1 R1183.1 R1192.1 R1288.1 RP2.1 RP2.2 RP2.3 RP2.4 RP3.1 RP3.2 RP3.3 RP3.4 U5.2(IN1) U5.3(IN2) U5.4(IN3) U5.5(IN4) U8.6(VS_P) U10.1(IN1) U10.2(IN2) U10.3(IN3) U12.8(VCC) U13.1(DIR2) U13.7(VCCA) U13.10(DIR1) U14.6(VDD) U18.6(VDD) U19.23(VCCB2) U19.24(VCCB1) U20.8(VDD) U21.8(VDD) U22.1(DIR2) U22.7(VCCA) U22.10(DIR1) U23.6(VS_P) U24.10(VIN) U25.5(VCC) U26.5(VCC) U27.6(VS_P) U29.6(VS_P) U31.5(TACHSET) U31.16(VDD) U32.6(VDD) U33.7(VCCA) U35.6(VS_P) U36.6(VS_P) U37.6(VS_P) U38.6(VDD) U39.3(VDD1) U39.4(VDDO1) U39.10(VDDO2) U39.15(VDD03) U39.21(VDDO4) U39.22(VDD2) U40.8(VDD) U51.1(VCCA) U51.23(VCCB2) U51.24(VCCB1) U53.1(VCCA) U71.5(VCC) U104.5(VDD) U115.11(3V3) U124.A3(IN) U125.1(IN1) U125.2(IN2) U125.3(IN3) U132.5(VCC) U134.10(VIN) U143.10(VIN) U151.A3(IN) U154.16(VCC) U157.5(VDD) U164.27(VDD33) U165.27(VDD33) U166.27(VDD33) U167.2(IN1) U167.3(IN2) U167.4(IN3) U167.5(IN4) Z115.2(NET2)
UTIL_3V3_DH_R: Q47.4(GATE) R1147.2
UTIL_3V3_DL: Q45.4(GATE) U156.19(DL)
UTIL_3V3_EN: R333.2 R756.1 U156.12(EN)
UTIL_3V3_FET_SWITCH: C1526.2(CAP1) L75.1 Q45.5(D_5) Q45.6(D_6) Q45.7(D_7) Q45.8(D_8) Q47.1(S_1) Q47.2(S_2) Q47.3(S_3) R1135.2 R1139.1 R1165.2 U156.16(LX)
UTIL_3V3_PGOOD: D13.1(CATHODE) RP3.5 U51.10(A8) U156.32(PG)
UTIL_3V3_SNS_N: C1449.1(CAP2) C1538.2(CAP1) U156.26(OUTN) Z116.1(NET1)
UTIL_3V3_SNS_P: C1538.1(CAP2) U156.27(OUTP) Z115.1(NET1)
UTIL_3V3_TEMPX: C1542.1(CAP2) Q51.1(BASE) Q51.2(COLLECTOR) U156.7(TEMPX)
VAD_1V8_TEMPX: C740.1(CAP2) Q25.1(BASE) Q25.2(COLLECTOR) U30.7(TEMPX)
VADJ_1V8: C174.1(CAP2) L3.2 R87.1 R102.2 R434.1 Z65.2(NET2)
VADJ_1V8_EN: U25.4(Y) U30.12(EN)
VADJ_1V8_FET_SWITCH: C406.2(CAP1) L3.1 Q9.2(SW1) Q9.3(SW2) Q9.4(SW3) R231.1 R464.2 R712.2 U30.16(LX)
VADJ_1V8_FPGA: C99.1(CAP2) C169.1(CAP2) C170.1(CAP2) C289.1(CAP2) C1012.1(CAP2) C1467.1(CAP2) C1568.1(CAP2) C1569.1(CAP2) C1573.1(CAP2) C1625.1(CAP2) C1627.1(CAP2) C1641.1(CAP2) C1642.1(CAP2) C1643.1(CAP2) C1649.1(CAP2) C1650.1(CAP2) C1651.1(CAP2) D19.1(CATHODE) J2.E39(VADJ_1) J2.F40(VADJ_2) J2.G39(VADJ_3) J2.H40(VADJ_4) J22.E39(VADJ_1) J22.F40(VADJ_2) J22.G39(VADJ_3) J22.H40(VADJ_4) J58.1(P1) R87.2 R101.2 U1.AH32(VCCO_43_AH32) U1.AK36(VCCO_43_AK36) U1.AL13(VCCO_67_AL13) U1.AL33(VCCO_43_AL33) U1.AM30(VCCO_43_AM30) U1.AP14(VCCO_67_AP14) U1.AP34(VCCO_43_AP34) U1.AT38(VCCO_43_AT38) U1.AU15(VCCO_67_AU15) U1.AV12(VCCO_67_AV12) U1.AW9(VCCO_66_AW9) U1.AY16(VCCO_67_AY16) U1.BA13(VCCO_67_BA13) U1.BB10(VCCO_66_BB10) U1.BC7(VCCO_66_BC7) U1.BD14(VCCO_66_BD14) U1.BE11(VCCO_66_BE11) U1.BF8(VCCO_66_BF8) U1.J13(VCCO_70_J13) U1.L37(VCCO_45_L37) U1.M14(VCCO_70_M14) U1.M34(VCCO_45_M34) U1.N11(VCCO_70_N11) U1.P38(VCCO_45_P38) U1.R15(VCCO_70_R15) U1.R35(VCCO_45_R35) U1.T12(VCCO_70_T12) U1.T32(VCCO_45_T32) U1.W13(VCCO_70_W13) U1.W33(VCCO_45_W33) U44.2(VREFA) Z16.2(NET2)
VADJ_1V8_FPGA_SNS_N: C369.2(CAP1) C370.1(CAP2) U30.26(OUTN) Z14.1(NET1)
VADJ_1V8_FPGA_SNS_P: C369.1(CAP2) U27.8(VBUS) U30.27(OUTP) Z16.1(NET1)
VADJ_1V8_FPGA_VIN: C97.1(CAP2) R101.1 U27.9(VIN_N)
VADJ_1V8_PGOOD: J2.D1(PG_C2M) J22.D1(PG_C2M) RP2.6 U30.32(PG) U44.18(B1) U51.5(A3)
VADJ_1V8_PGOOD_LS: U1.AK35(IO_T1U_N12_43_AK35) U44.3(A1)
VADJ_1V8_VIN: C97.2(CAP1) R102.1 U27.10(VIN_P)
VADJ_DH_R: Q9.1(HSG) R98.2
VADJ_DL: Q9.7(LSG) U30.19(DL)
VREF_43: R798.2 U1.AJ29(VREF_43_AJ29)
VREF_45: R796.2 U1.U30(VREF_45_U30)
VREF_66: R1024.2 U1.BA11(VREF_66_BA11)
VREF_67: R1023.2 U1.AL16(VREF_67_AL16)
VREF_70: R3.2 U1.AB13(VREF_70_AB13)
VRP_40: R378.1 U1.BC30(IO_T0U_N12_VRP_40_BC30)
VRP_41: R384.1 U1.BC29(IO_T0U_N12_VRP_41_BC29)
VRP_42: R377.1 U1.BB34(IO_T0U_N12_VRP_42_BB34)
VRP_43: R383.1 U1.AR34(IO_T0U_N12_VRP_43_AR34)
VRP_45: R700.1 U1.Y33(IO_T0U_N12_VRP_45_Y33)
VRP_46: R1001.1 U1.K38(IO_T0U_N12_VRP_46_K38)
VRP_47: R379.1 U1.T29(IO_T0U_N12_VRP_47_T29)
VRP_48: R1002.1 U1.M26(IO_T0U_N12_VRP_48_M26)
VRP_65: R108.1 U1.BF21(IO_T0U_N12_VRP_A28_65_BF21)
VRP_66: R4.1 U1.BD16(IO_T0U_N12_VRP_66_BD16)
VRP_67: R380.1 U1.BA12(IO_T0U_N12_VRP_67_BA12)
VRP_70: R5.1 U1.W15(IO_T0U_N12_VRP_70_W15)
VRP_71: R1072.1 U1.D8(IO_T0U_N12_VRP_71_D8)
VRP_72: R1073.1 U1.T21(IO_T0U_N12_VRP_72_T21)
VRP_73: R1071.1 U1.T18(IO_T0U_N12_VRP_73_T18)

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4604 vias
v2: diameter 0.483, hole 0.254, TOP to BOTTOM, 2747 vias
v3: diameter 0.61, hole 0.305, TOP to BOTTOM, 325 vias
v4: diameter 0.432, hole 0.203, TOP to BOTTOM, 1289 vias
v5: diameter 0.457, hole 0.203, TOP to BOTTOM, 230 vias
v6: diameter 0.508, hole 0.254, TOP to 10_GND, 113 vias
v7: diameter 1.727, hole 1.143, TOP to 10_GND, 2 vias
v8: diameter 0.559, hole 0.305, TOP to BOTTOM, 4 vias
v9: diameter 0.508, hole 0.279, TOP to BOTTOM, 81 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
AGND1: length 12.2
  TOP w0.381: C1712.2 R1219.2 v1(237.74,114.6) ; v3(235.17,110.48) 234.44,111.21 Z119.1 ; C229.2 236.9,102.13 v1(236.9,102.13)
  BOTTOM w0.279: U164.7 236.17,114.02 v1(236.09,114.1)
  BOTTOM w0.381: C1684.2 v1(236.9,102.13) ; C1685.2 v1(239.44,102.13) ; R1238.2 v1(227.63,117.4) ; C1683.2 v1(234.36,102.13) ; R1205.2 v1(231.44,117.4) ; R1206.2 v1(233.98,117.4) ; R1201.2 v1(232.71,117.4) ; R1265.2 v1(228.9,117.4) ; R1254.2 v3(230.17,117.44)
  vias: v3(233.9,110.48) v3(233.9,109.21) v3(233.9,107.94) v3(235.17,109.21) v3(235.17,107.94) v3(236.44,110.48) v3(236.44,109.21) v3(236.44,107.94)
AGND2: length 36.2
  TOP w0.381: v1(159.89,116.2) 160.21,115.89 Z93.1
  BOTTOM w0.254: U9.28 159.13,115.44 v1(158.88,115.19) 159.13,114.94 U9.29 ; C1539.2 155.58,109.8 154.34,109.8 148.67,115.48 148.67,117.32 149.45,118.11 149.45,124.03 150.01,124.59 150.18,124.59 Q48.3 ; U9.5 158.63,111.76 v1(158.37,111.5) ; U9.8 156.76,112.77 v1(156.49,112.5)
  BOTTOM w0.381: v1(165.51,118.82) C1543.2 ; R1131.2 163.12,109.44 v1(163.44,109.12) ; R1166.2 v1(159.05,109.09) ; C1446.2 162.77,118.07 v1(162.43,117.73) ; R1125.2 v1(160.07,109.09) ; R1132.2 v1(161.09,109.09) ; C1539.2 156.31,109.07 v1(156.46,109.07) 156.46,108.7 156.86,108.3 C1408.2
  vias: v1(157.86,116.2) v1(157.86,114.17) v1(159.89,114.17)
AGND5: length 35.8
  TOP w0.381: v1(182.18,136.5) 181.86,136.18 Z15.1
  BOTTOM w0.254: C740.2 175.78,140.81 175.78,141.95 181.27,147.45 190.28,147.45 191.41,146.31 Q25.3 ; v1(178.47,139.9) 178.52,139.9 178.75,139.68 U30.8 ; U30.29 180.91,137.27 v1(181.16,137.52) 181.41,137.27 U30.28 ; U30.5 177.74,137.77 v1(177.54,137.96)
  BOTTOM w0.381: v1(186.88,130.96) 185.94,130.96 C480.2 ; v1(175.13,133.27) 175.81,133.27 R214.2 ; C370.2 v1(184.05,133.9) ; C423.2 175.13,138.89 v1(175.13,137.34) R515.2 ; v1(175.13,135.31) 175.81,135.31 R155.2 ; R199.2 v1(175.13,136.32) ; C740.2 v1(174.73,140.56)
  vias: v1(180.14,138.53) v1(180.14,136.5) v1(182.18,138.53)
AGND6: length 35.9
  TOP w0.381: v1(210.76,65.53) 211.08,65.85 Z1.1
  BOTTOM w0.254: Q20.3 202.06,56.54 202.06,55.93 203.4,54.58 209.11,54.58 210.4,54.58 211.26,55.44 212.52,55.44 217.16,60.08 217.16,61.22 C188.2 ; v1(215.46,64.01) 215.2,64.26 U6.5 ; U6.8 214.19,62.35 214.42,62.13 v1(214.47,62.13) ; U6.29 212.03,64.76 v1(211.78,64.51) 211.53,64.76 U6.28
  BOTTOM w0.381: C175.2 v1(208.89,68.13) ; R136.2 v1(217.93,68.76) ; C188.2 v1(218.2,61.47) ; C189.2 206.14,71.15 v1(206.06,71.07) ; R74.2 v1(217.93,65.71) ; R159.2 v1(217.93,64.69) ; C145.2 218.67,62.01 218.86,61.81 218.86,61.82 v1(218.88,61.82) ; R137.2 v1(217.93,66.72)
  vias: v1(210.76,63.5) v1(212.79,65.53) v1(212.79,63.5)
AGND8: length 34.7
  TOP w0.381: v1(217.48,46.97) 217.17,46.65 Z94.1
  BOTTOM w0.254: U4.5 213.04,48.23 v1(212.78,48.49) ; C1540.2 211.08,51.28 211.08,52.01 216.98,57.91 224.71,57.91 226.05,56.57 Q49.3 ; v1(213.78,50.37) 213.83,50.37 214.05,50.14 U4.8 ; U4.28 216.72,47.73 v1(216.47,47.98) 216.22,47.73 U4.29
  BOTTOM w0.381: R1133.2 v1(210.44,43.74) ; C1409.2 209.09,49.86 v1(209.09,50.32) ; R1108.2 v1(210.44,46.74) ; C1544.2 v1(220.07,41.35) ; R1167.2 v1(210.44,47.8) ; R1126.2 v1(210.44,45.77) ; C1447.2 v1(219.35,44.35) ; C1540.2 v1(210.04,51.03)
  vias: v1(215.45,49) v1(215.45,46.97) v1(217.48,49)
AGND9: length 24.6
  TOP w0.254: U166.16 164.69,138.73 v3(164.42,138.46) 163.69,139.19 U166.18 ; U166.7 166.69,138.19 v3(165.69,137.19) 165.19,137.69 U166.15
  BOTTOM w0.254: R1221.2 166.17,139.24 v3(166.96,138.46) 167.59,137.82 R1262.2
  BOTTOM w0.381: R1266.2 168,134.66 Z121.1 ; R1266.2 R1258.2 R1214.2 ; R1266.2 R1240.2 ; C1717.2 164.65,138.69 v3(164.42,138.46) ; R1214.2 166.07,136.81 v3(165.69,137.19) ; R1214.2 R1262.2 R1207.2 167.34,138.84 v3(166.96,138.46)
  vias: v3(164.42,135.92) v3(166.96,135.92)
AGND10: length 21.8
  TOP w0.254: U165.7 179.04,45.67 v3(178.04,46.67) 178.54,47.17 U165.15 ; U165.18 180.04,48.67 v3(179.31,47.94) 179.58,47.67 U165.16
  BOTTOM w0.254: R1220.2 180.1,46.19 v3(179.31,45.4)
  BOTTOM w0.381: v3(179.31,45.4) 179.7,45.02 R1280.2 R1213.2 R1281.2 R1256.2 ; C1715.2 179.55,47.71 v3(179.31,47.94) ; R1256.2 R1229.2 ; R1256.2 176.65,45.28 v3(176.77,45.4) ; R1229.2 175.52,44.36 Z120.1 ; R1229.2 R1239.2
  vias: v3(176.77,47.94)
AGND12: length 37
  TOP w0.381: Z88.1 44.52,121.6 v1(45.17,122.26)
  BOTTOM w0.254: U150.29 44.94,122.55 U150.33 44.94,122.05 U150.28 ; C1330.2 48.48,127.68 49.9,127.68 54.04,123.54 54.04,121.47 54.04,113.91 53.29,113.16 52.81,113.16 Q40.3 ; U150.8 47.35,124.71 47.58,124.94 v1(47.58,124.99) ; v1(45.93,126.16) 45.44,125.67 U150.5
  BOTTOM w0.381: C1330.2 48.24,128.42 v1(48.51,128.7) ; C1318.2 v1(41.57,119.41) ; v1(47.62,128.96) 47.39,129.19 C1313.2 ; R1174.2 v1(42.98,127.92) ; R1077.2 v1(45.01,128.01) ; C1336.2 v1(38.55,119.3) ; R1078.2 v1(44,127.92) ; R1028.2 v1(40.95,127.97)
AGND13: length 48.9
  BOTTOM w0.178: Q51.3 195.18,48.97 195.18,49.49 193.88,50.79 188.43,50.79 187.18,49.54 187.18,47.06 183.96,43.84 183.96,39.6 182.55,38.2 182.55,32.6 183.24,31.92 183.24,29.96 C1542.2
  BOTTOM w0.211: U156.5 185.25,27.02 v1(185.12,27.15)
  BOTTOM w0.254: U156.28 188.93,26.52 v1(188.68,26.77) 188.42,26.52 U156.29
  BOTTOM w0.305: U156.8 186.26,28.93 v1(185.88,29.31)
  BOTTOM w0.381: v1(185.75,33.3) 184.94,33.3 184.65,33.59 Z96.1 ; v1(182.25,23.97) R1109.2 R1130.2 ; R1170.2 v1(182.25,25.24) ; C1546.2 v3(193.12,18.69) ; C1542.2 v1(182.33,29.81) ; C1411.2 v1(181.11,28.04) ; R1169.2 v1(182.25,26.51) ; C1449.2 v3(191.95,20.04)
  vias: v1(187.66,27.78) v1(187.66,25.75) v1(189.69,27.78) v1(189.69,25.75)
GND: length 15761.6
  TOP w0.127: J32.3 56.41,111.37 v3(56.75,111.71) ; J34.5 83.51,129.49 v3(83.85,129.83) ; J33.3 61.49,100.12 v3(61.15,99.78) ; J33.5 56.41,100.12 v3(56.75,99.78) ; v3(69.71,132.03) 69.37,131.69 J35.2 ; J31.2 15.39,99.44 v3(15.73,99.78) ; J30.3 29.53,102.32 v3(29.87,101.98) ; J34.2 86.39,132.37 v3(86.05,132.03) ; J30.2 32.41,100.12 v3(32.07,99.78) ; J35.5 72.25,134.57 v3(71.91,134.23) ; J32.2 58.61,114.25 v3(58.95,113.91) ; J31.3 18.27,97.24 v3(17.93,97.58) ; v3(29.87,97.58) 29.53,97.24 J30.5 ; v3(83.85,134.23) 83.51,134.57 J34.3 ; v3(61.15,111.71) 61.49,111.37 J32.5 ; v3(71.91,129.83) 72.25,129.49 J35.3 ; J31.5 18.27,102.32 v3(17.93,101.98) ; J33.2 59.29,97.24 v3(58.95,97.58)
  TOP w0.152: Z131.2 139.01,32.18 v1(137.74,30.91)
  TOP w0.203: v1(13.36,69.04) 13.36,68.71 13.53,68.54 U34.2 ; v1(83.56,25.13) 83.58,25.15 U57.8
  TOP w0.254: U166.20 161.9,138.69 161.11,139.47 v1(161.06,139.47) ; U24.4 63.15,88.53 v1(62.9,88.78) ; C498.2 75.7,34.9 v4(75.56,35.04) ; C559.2 v1(69.69,33.15) ; v4(74.76,50.74) 74.16,51.33 C435.2 73.75,51.33 v4(73.16,50.74) ; v4(73.96,70.44) 73.56,70.83 C719.2 ; C1709.2 152.46,136.64 v1(152.59,136.77) ; v1(86.61,25.13) 87.04,25.56 87.34,25.56 87.38,25.6 U57.36 ; C705.2 77.24,91.35 v4(77.16,91.43) ; v4(75.56,49.14) 75.7,48.99 C492.2 ; v4(73.96,56.34) 73.56,56.74 C434.2 ; R707.2 71.56,58.89 C695.2 v1(72.45,58.71) ; v4(77.16,35.04) 77.24,34.96 C354.2 ; C953.2 71.56,72.48 R895.2 ; v3(148.59,136.23) 148.58,136.24 U163.17 147.49,136.76 147.76,137.03 U163.14 ; C697.2 C752.2 71.27,70.82 71.65,70.44 v4(72.36,70.44) ; C353.2 70.04,34.32 v4(70.76,35.04) ; v1(48.56,64.12) 48.14,64.54 J6.A1 ; v1(174.08,67.59) 173.82,67.84 U36.7 ; R704.2 75.84,70.72 v4(75.56,70.44) ; R42.2 85.41,51.89 v1(85.48,51.82) ; R300.2 v1(66.22,84.13) ; C751.2 75.7,63.09 v4(75.56,63.24) ; U165.25 177.04,51.39 v1(176.92,51.52) ; v4(79.56,98.63) 80.16,99.24 C722.2 ; C557.2 v1(69.69,47.24) ; C1139.2 71.27,84.95 71.69,84.53 v4(72.36,84.53) ; J6.B4 46.64,68.29 v1(46.59,68.34) ; C436.2 80.16,56.94 v4(79.56,56.34) ; C1070.2 80.16,85.14 v4(79.56,84.53) ; v1(180.33,51.31) 180.33,51.25 179.54,50.46 U165.20 ; v1(45.19,68.34) 45.14,68.29 J6.B7 ; v4(72.36,98.63) 71.6,98.63 71.27,98.96 C755.2 ; v1(40.59,64.32) 40.64,64.37 J6.A16 ; C1527.2 v1(149.9,115.91) ; v1(42.09,67.64) 42.14,67.59 J6.B13 ; U166.23 161.11,137.19 v1(160.84,137.46) 161.07,137.69 U166.22 ; v4(73.16,36.64) 73.75,37.24 C439.2 74.16,37.24 v4(74.76,36.64) ; C496.2 77.99,42.27 v4(77.96,42.24) ; v4(72.36,42.24) 71.65,42.24 71.27,42.62 C497.2 ; v3(106.39,23.87) 105.64,23.12 U104.1 ; v1(46.59,64.32) 46.64,64.37 J6.A4 ; U57.25 86.08,21.59 v1(85.59,22.08) 85.58,22.07 U57.24 ; U122.4 164.29,22.14 v1(164.03,22.4) ; v4(77.16,63.24) 77.24,63.15 C702.2 ; U165.22 178.54,51.29 v1(178.31,51.52) 178.04,51.25 U165.23 ; C754.2 75.7,91.28 v4(75.56,91.43) ; C1273.2 54.83,131.57 v1(54.39,132.01) ; v4(77.96,56.34) 77.99,56.37 C493.2 ; U122.6 163.29,21.83 162.77,22.35 v1(162.77,22.47) ; R893.2 75.84,84.82 v4(75.56,84.53) ; J6.A7 45.14,64.37 v1(45.19,64.32) ; U24.8 v1(62.4,88.03) ; C706.2 70.7,91.43 v4(70.76,91.43) ; C1072.2 73.56,84.93 v4(73.96,84.53) ; R559.2 71.56,30.7 C558.2 v1(72.45,30.51) ; v3(175.11,16.32) 175.86,15.57 U157.1 ; C440.2 73.56,42.64 v4(73.96,42.24) ; C441.2 80.16,42.85 v4(79.56,42.24) ; C696.2 v1(69.69,61.34) ; J6.B19 39.14,67.26 38.92,67.48 38.65,67.48 v1(38.53,67.36) ; v1(132.37,129.03) U37.7 ; C494.2 71.27,56.76 71.69,56.34 v4(72.36,56.34) ; R385.2 75.84,56.63 v4(75.56,56.34) ; v4(77.96,70.44) 77.99,70.46 C749.2 ; C1141.2 77.99,84.56 v4(77.96,84.53) ; C1052.2 70.04,76.61 v4(70.76,77.33) ; v4(77.96,98.63) 77.99,98.66 C756.2 ; v1(72.45,44.61) C556.2 71.56,44.8 R557.2 ; v4(73.96,98.63) 73.56,99.03 C721.2 ; U29.7 225.84,68.24 226.09,68.49 v1(226.09,68.78) ; v1(86.61,22.08) 86.58,22.06 U57.26 ; v1(40.69,67.64) 40.64,67.59 J6.B16 ; C703.2 70.04,62.52 v4(70.76,63.24) ; U166.25 160.97,136.19 v1(160.84,136.06) ; C105.2 81.11,104.54 81.24,104.67 81.24,105.09 81.69,105.54 R76.2 ; v4(75.56,98.63) 75.84,98.92 R705.2 ; U10.8 46.89,134.77 v1(46.91,134.75) ; v1(16.16,67.79) 15.41,68.54 U34.2 ; J6.A13 42.14,64.47 v1(41.99,64.32) ; U122.23 165.82,20.25 v1(165.55,20.52) ; v1(86.61,23.1) 86.61,23.1 U57.31 ; C349.2 70.04,48.42 v4(70.76,49.14) ; v1(53.49,33.03) 53.25,33.03 ; U37.2 v1(128.15,130.03) ; v4(79.56,70.44) 80.16,71.04 C716.2 ; v1(79.38,61.64) C704.2 ; v1(39.19,64.32) 39.14,64.37 J6.A19 ; v4(75.56,42.24) 75.84,42.53 R386.2 ; U29.1 v1(224.34,62.21)
  TOP w0.305: v1(46.41,141.5) 46.56,141.66 C191.2 ; U123.32 53.25,53.81 v9(53.45,53.61) ; v9(46.94,49) 47.14,48.79 47.99,48.79 48.18,48.61 U123.13 ; v9(47.54,32.98) 48.37,32.98 48.72,32.63 U145.1 ; v1(47.98,23.23) 48.18,23.03 U145.13 ; v1(53.44,23.23) 53.24,23.43 U145.26 ; U145.19 48.24,18.23 47.71,17.7 v9(47.47,17.7) ; U10.4 46.39,138.14 v1(46.14,137.89) ; U145.32 53.25,28.23 v1(53.45,28.03) ; J6.B1 49.2,66.78 v1(49.61,67.2) ; 53.25,33.03 U145.38 ; U145.16 47.56,20.63 v9(47.52,20.6) ; v9(53.44,44) 53.24,44.21 U123.20 ; U123.26 53.24,49.01 v1(53.44,48.81) ; U159.14 214.24,113.2 U159.17 ; U11.14 214.24,81.96 U11.17 ; C1071.2 73.53,77.71 v4(73.16,77.33) ; U160.14 214.24,102.79 U160.17 ; C120.2 226.91,70.02 226.3,69.41 226.3,68.99 v1(226.09,68.78) ; v1(58.66,121.98) 58.66,121.85 U151.A1 ; J22.G1 v1(106.93,165.86) ; U145.7 v9(48.12,27.83) ; U145.35 53.25,30.63 v1(53.45,30.43) ; v1(215.1,91.69) 214.69,92.1 U161.17 214.24,92.37 U161.14 ; U145.4 v9(48.12,30.23) ; U123.16 47.56,46.21 v9(47.52,46.17) ; U145.23 53.11,21.03 v9(53.67,21.59) ; U123.4 v9(48.12,55.81) ; v9(53.28,18.39) 53.03,18.63 U145.20 ; v1(53.44,46.41) 53.24,46.61 U123.23 ; U123.7 48.19,53.41 v9(47.99,53.61) ; U123.19 48.13,43.81 v9(47.47,43.15) ; v9(47.55,58.37) 48.03,58.37 48.19,58.21 U123.1
  TOP w0.381: U141.K2 v2(88.23,113.32) ; U1.AD3 118.74,45.34 v2(119.24,44.84) ; 231.65,34.82 J39.8 ; J39.8 233.95,35.81 ; J39.8 231.98,35.81 ; J39.8 231.98,33.84 ; J39.8 233.95,33.84 ; C1594.2 C1679.2 209.43,91.7 v1(209.14,91.41) ; J22.C17 v1(86.61,160.78) ; v2(133.24,69.84) 132.74,69.34 U1.AV27 ; U1.A6 v2(95.24,47.84) ; U1.BC1 v2(138.24,42.84) ; v1(154.91,130.38) 155.42,129.87 C1675.2 ; v4(68.36,49.14) 65.66,49.14 C156.2 65.67,50.17 67.28,50.17 67.85,50.74 v4(68.36,50.74) ; J82.2 12.39,104.59 ; J82.2 12.06,103.61 ; J82.2 10.09,105.58 ; J82.2 9.75,104.59 ; J82.2 10.09,103.61 ; U137.E9 v4(157.96,80.55) ; U135.E9 v4(157.96,52.36) ; J25.1 225.73,16.69 ; J25.1 223.09,16.69 ; J25.1 224.41,15.37 ; J25.1 224.41,18.01 ; J25.1 225.39,17.67 ; J25.1 223.42,15.7 ; J25.1 223.42,17.67 ; J25.1 225.39,15.7 ; X6.4 168.42,23.65 v1(168.7,23.93) ; J22.M21 v1(81.53,172.21) ; v2(122.24,55.84) 121.74,56.34 U1.AG14 ; v1(207.47,82.58) 207.32,82.42 C150.2 ; U1.T27 110.74,69.34 v2(110.24,69.84) ; v1(57.9,124.61) 57.61,124.32 C1358.2 ; C1671.2 v1(152.59,136.77) ; v2(113.24,85.84) U1.W43 ; v2(105.24,81.84) 105.74,81.34 U1.L39 ; U1.AE39 119.74,81.34 v2(120.24,81.84) ; C350.2 67.89,100.54 v1(67.69,100.33) ; U1.AU2 131.74,44.34 v2(132.24,43.84) ; J22.M12 v1(92.96,172.21) ; SW14.3 v1(25.7,114.1) ; U142.L5 v2(71.32,119.17) ; v2(129.24,83.84) 128.74,83.34 U1.AP41 ; v2(141.24,47.84) U1.BF6 ; v1(186.83,92.25) 188.24,92.25 188.63,91.87 C1758.2 188.63,91.11 188.24,90.73 v1(186.83,90.73) ; v1(134.7,145.75) 133.74,145.75 C957.2 133.03,146.91 133.72,147.6 v1(134.7,147.6) ; U1.AH9 v2(123.24,50.84) ; v1(82.92,88.8) 82.92,88.77 83,88.7 C659.2 ; U111.L1 v5(13.1,140.57) ; MH7.1 11.23,94.72 ; MH7.1 7.49,98.45 ; MH7.1 3.76,94.72 ; MH7.1 4.8,97.41 ; MH7.1 10.18,97.41 ; MH7.1 10.18,92.03 ; MH7.1 7.49,90.98 ; MH7.1 4.8,92.03 ; v2(123.24,44.84) 122.74,45.34 U1.AH3 ; U1.AG38 121.74,80.34 v2(122.24,80.84) ; R1289.2 136.21,103 136.4,103.19 136.79,103.19 137.06,103.45 U167.10 137.06,105.48 138.14,106.57 ; U139.A2 v4(154.76,31.61) ; U123.38 53.25,58.61 v9(53.45,58.41) ; J39.16 233.95,45.97 ; J39.16 232.97,46.3 ; J39.16 231.98,44 ; J39.16 231.65,44.98 ; J39.16 231.98,45.97 ; J39.16 233.95,44 ; C1466.2 145.8,100.37 v1(146.57,101.14) C1142.2 ; U142.D6 v2(79.32,118.17) ; U1.AC1 117.74,43.34 v2(117.24,42.84) ; J22.J1 v1(106.93,168.4) ; J22.B31 v1(68.83,159.51) ; J22.F3 v1(104.39,164.59) ; R66.2 v1(40.26,131.14) ; C618.2 C630.2 119.51,29.27 v1(119.29,29.05) ; U1.BE16 v2(140.24,57.84) ; J22.Z18 v1(85.34,156.97) ; J22.G4 v1(103.12,165.86) ; v2(100.24,44.84) 100.74,45.34 U1.F3 ; U136.D8 v4(157.16,65.66) ; v2(101.59,108.74) 101.69,108.64 102.64,108.64 102.95,108.34 C1424.2 102.95,107.93 102.64,107.63 v1(101.5,107.63) ; J2.G11 v1(164.24,165.86) ; U2.A4 v6(48.65,7.13) ; U25.3 v1(125.21,141.76) ; v1(183.08,61.8) 183.31,62.03 U162.17 ; U1.W16 113.74,58.34 v2(113.24,57.84) ; U1.AF41 120.74,83.34 v2(121.24,83.84) ; U1.AF42 120.74,84.34 v2(121.24,84.84) ; J2.H24 v1(147.73,167.13) ; J5.3 199.23,14.56 ; J5.3 199.57,15.54 ; J5.3 198.25,14.22 ; 115.93,134.9 MH2.1 ; MH2.1 121.31,140.28 ; MH2.1 118.62,141.33 ; MH2.1 122.35,137.59 ; MH2.1 115.93,140.28 ; MH2.1 114.88,137.59 ; MH2.1 118.62,133.86 ; MH2.1 121.31,134.9 ; U141.L5 v2(91.23,112.32) ; U1.Y29 v2(114.24,71.84) ; U135.B2 v4(155.56,45.96) ; R121.2 v1(211.11,159.86) ; v2(127.24,77.84) U1.AM35 ; U1.H3 102.74,45.34 v2(102.24,44.84) ; v2(123.24,69.84) 122.74,69.34 U1.AH27 ; v2(129.24,51.84) U1.AP10 ; L94.1 v1(9.02,81.81) ; U1.BB6 v2(137.24,47.84) ; v2(115.24,57.84) 115.74,58.34 U1.AA16 ; 231.65,29.74 J39.4 ; J39.4 231.98,28.76 ; J39.4 233.95,30.73 ; J39.4 233.95,28.76 ; J39.4 231.98,30.73 ; U111.E7 v5(18.7,135.77) ; C1592.2 v1(216.76,93.22) ; v2(121.24,58.84) 120.74,59.34 U1.AF17 ; J2.F30 v1(140.11,164.59) ; U1.T9 v2(110.24,50.84) ; J22.J29 v1(71.37,168.4) ; J2.E8 v1(168.05,163.32) ; U111.K10 v5(13.9,132.57) ; U1.AC43 v2(117.24,85.84) ; U1.AC34 v2(117.24,76.84) ; 47.78,98.95 J27.1 ; J27.1 49.75,98.95 ; J27.1 49.75,96.98 ; J27.1 47.45,97.97 ; J27.1 50.09,97.97 ; J27.1 48.77,96.65 ; J27.1 47.78,96.98 ; J27.1 48.77,99.29 ; v2(114.24,77.84) U1.Y35 ; U142.E11 v2(78.32,112.17) ; U1.K46 v2(104.24,88.84) ; v2(115.24,59.84) U1.AA18 ; J2.J29 v1(141.38,168.4) ; U1.AH13 122.74,55.34 v2(123.24,54.84) ; U138.C9 v4(156.36,94.65) ; U1.AY6 v2(135.24,47.84) ; U1.AG43 v2(122.24,85.84) ; v6(126.4,5.99) 126.65,5.74 U2.B80 ; v2(139.24,81.84) 138.74,81.34 U1.BD39 ; U142.B10 v2(81.32,113.17) ; J2.K24 v1(147.73,169.67) ; v1(125.4,108.94) 125.4,107.81 C1748.2 126.82,107.78 v1(126.82,108.94) ; U111.P12 v5(10.7,130.97) ; U1.G42 v2(101.24,84.84) ; J22.B10 v1(95.5,159.51) ; v1(128.96,30.18) 128.65,30.48 C1516.2 ; v2(130.24,81.84) 129.74,81.34 U1.AR39 ; U1.AB27 v2(116.24,69.84) ; v1(116.76,145.85) 117.33,145.85 C956.2 118.05,147.02 117.44,147.62 v1(116.71,147.62) ; U1.D13 98.74,55.34 v2(98.24,54.84) ; DS2.2 223.23,169.61 223.88,168.96 v1(223.88,168.66) ; U1.AD4 118.74,46.34 v2(119.24,45.84) ; U1.AC42 117.74,84.34 v2(117.24,84.84) ; v2(104.24,44.84) 104.74,45.34 U1.K3 ; v2(103.24,42.84) 103.74,43.34 U1.J1 ; U139.E9 v4(157.96,38.01) ; C104.2 87.28,104.29 v1(87.83,103.73) ; v2(129.24,87.84) U1.AP45 ; J22.D39 v1(58.67,162.05) ; U135.A2 v4(154.76,45.96) ; U1.AT44 v2(131.24,86.84) ; U1.L32 v2(105.24,74.84) ; v3(216.8,112.06) 216.97,111.89 C1705.2 ; 55.92,24.46 J96.3 56.27,23.43 ; U141.M12 v2(99.23,111.32) ; v2(103.24,85.84) U1.J43 ; v2(113.24,72.84) U1.W30 ; C713.2 v1(122.68,101.77) ; U1.AF5 v2(121.24,46.84) ; C619.2 95.84,101.43 95.61,101.66 v1(95.61,101.74) ; U1.AT23 v2(131.24,64.84) ; v2(123.24,71.84) 122.74,71.34 U1.AH29 ; U1.L1 105.74,43.34 v2(105.24,42.84) ; v4(68.36,91.43) 68.31,91.48 C698.2 ; J22.D3 v1(104.39,162.05) ; v2(97.24,43.84) 97.74,44.34 U1.C2 ; U1.AL1 v2(126.24,42.84) ; J2.E11 v1(164.24,163.32) ; C190.2 47.47,130.89 v1(48.01,130.35) ; J2.A36 v1(132.49,158.24) ; U1.M3 106.74,45.34 v2(106.24,44.84) ; U1.BA28 135.74,70.34 v2(136.24,70.84) ; U1.AF10 v2(121.24,51.84) ; v2(139.24,60.84) U1.BD19 ; U124.A1 13.1,118.29 12.89,118.5 v1(12.89,118.94) ; v2(123.24,82.84) 122.74,82.34 U1.AH40 ; Q3.2 v1(3.56,130) ; U1.AD18 v2(119.24,59.84) ; U1.AU20 v2(132.24,61.84) ; U1.A32 v2(95.24,74.84) ; U1.AA42 v2(115.24,84.84) ; v2(113.24,77.84) U1.W35 ; C707.2 C753.2 81.48,90.02 81.66,90.02 82.58,90.94 v1(82.68,90.94) ; v2(121.24,44.84) 120.74,45.34 U1.AF3 ; R804.2 168.29,17.9 168.66,18.26 v1(168.66,18.97) ; C1678.2 209.31,102.11 v1(209.01,101.82) ; v1(68.35,116.97) 67.21,116.97 C1426.2 67.39,116.03 v1(68.32,116.03) ; C53.2 143.97,113.22 v1(144.28,112.91) ; C1484.2 v1(104.09,101.78) ; v2(114.24,64.84) U1.Y23 ; J22.M16 v1(87.88,172.21) ; U142.N1 v2(69.32,123.17) ; U53.5 v1(129.07,15.57) ; U11.17 214.69,81.68 v1(215.1,81.28) ; 171.99,145.43 J24.1 ; J24.1 172.97,143.13 ; J24.1 174.29,144.45 ; J24.1 173.96,143.47 ; J24.1 173.96,145.43 ; J24.1 171.65,144.45 ; J24.1 172.97,145.77 ; J24.1 171.99,143.47 ; v1(153.7,98.95) 153.54,99.11 C1158.2 ; U1.L6 v2(105.24,47.84) ; U1.N2 107.74,44.34 v2(107.24,43.84) ; U1.AP29 128.74,71.34 v2(129.24,71.84) ; v1(118.62,103.12) 119.09,103.12 C165.2 119.21,104.88 v1(118.6,104.88) ; R179.2 84.79,76.71 85.34,77.27 v1(85.34,77.3) ; 27.38,65.02 J36.1 ; J36.1 28.7,65.02 ; J36.1 30.02,65.02 ; J36.1 28.7,67.67 ; J36.1 27.38,67.67 ; U136.T1 v4(167.56,59.26) ; C718.2 67.58,68.93 v1(67.45,68.8) ; R180.2 85.23,73.71 v1(85.34,73.6) ; v1(105.66,156.97) J22.Z2 ; v1(7.32,117.53) 7.32,118.68 7.6,118.95 C867.2 8.19,118.95 8.59,118.55 v1(8.59,117.53) ; J2.K15 v1(159.16,169.67) ; v6(95.15,5.99) 95.65,5.49 95.65,3.49 ; C226.2 219.16,81.02 v3(218.96,80.82) ; v1(180.02,68) 179.77,67.74 C166.2 ; U1.AJ24 v2(124.24,66.84) ; v1(62.63,140.78) 62.44,140.59 U19.13 ; R96.2 5.38,136.7 5.4,136.73 Q35.2 5.71,137.21 v1(6.1,137.59) ; v2(104.24,82.84) 104.74,82.34 U1.K40 ; J2.G32 v1(137.57,165.86) ; J22.Z30 v1(70.1,156.97) ; v2(138.24,53.84) U1.BC12 ; v2(95.24,83.84) 95.74,83.34 U1.A41 ; U136.B2 v4(155.56,60.06) ; U1.AJ14 123.74,56.34 v2(124.24,55.84) ; J22.Y25 v1(76.45,155.7) ; v2(101.24,55.84) 101.74,56.34 U1.G14 ; U1.AE20 v2(120.24,61.84) ; J39.10 233.95,36.38 ; J39.10 233.95,38.35 ; J39.10 231.65,37.36 ; J39.10 231.98,36.38 ; J39.10 231.98,38.35 ; J22.L23 v1(78.99,170.94) ; U1.D23 v2(98.24,64.84) ; U1.AG2 121.74,44.34 v2(122.24,43.84) 121.74,43.34 U1.AG1 ; v1(123.9,109.58) 123.09,109.58 C903.2 123.25,108.05 v1(123.95,108.05) ; U141.K8 v2(95.23,113.32) ; v1(4.53,117.53) 4.53,118.68 4.8,118.95 C868.2 5.27,118.95 5.8,118.42 v1(5.8,117.53) ; v2(108.24,45.84) 108.74,46.34 U1.P4 ; v2(131.24,83.84) 130.74,83.34 U1.AT41 ; v1(67.38,40.61) 67.58,40.81 C438.2 ; 231.98,31.3 J39.6 ; J39.6 233.95,31.3 ; J39.6 233.95,33.27 ; J39.6 231.65,32.28 ; J39.6 231.98,33.27 ; J22.A17 v1(86.61,158.24) ; v2(128.24,74.84) U1.AN32 ; v1(115.9,111.86) 116.02,111.74 116.02,110.92 C462.2 114.5,110.13 114.5,111.86 v1(114.5,111.86) ; J2.C25 v1(146.46,160.78) ; U111.N5 v5(11.5,137.37) ; J22.E29 v1(71.37,163.32) ; v2(110.24,82.84) 110.74,82.34 U1.T40 ; v1(17.07,154.81) 17.07,152.68 16.75,152.36 U115.10 15.35,152.36 15.11,152.6 v1(15.11,154.81) ; v2(103.24,51.84) U1.J10 ; R63.2 v1(45.08,143.18) ; R63.2 R64.2 ; R63.2 R62.2 ; v2(112.24,87.84) U1.V45 ; J2.D3 v1(174.4,162.05) ; v1(110.93,107.48) 110.93,106.35 C1733.2 112.71,106.36 v1(112.71,107.48) ; J2.B38 v1(129.95,159.51) ; v2(112.24,86.84) U1.V44 ; U1.M39 106.74,81.34 v2(106.24,81.84) ; J22.Z14 v1(90.42,156.97) ; Q24.2 206.01,159.3 v1(206.51,159.3) ; J2.C34 v1(135.03,160.78) ; MH4.1 8.15,143.42 ; MH4.1 5.46,142.38 ; MH4.1 1.73,146.11 ; MH4.1 8.15,148.8 ; MH4.1 2.77,143.42 ; MH4.1 9.19,146.11 ; MH4.1 5.46,149.85 ; MH4.1 2.77,148.8 ; J22.Z27 v1(73.91,156.97) ; U111.A11 v5(21.9,131.77) ; U137.E3 v4(157.96,75.75) ; U1.AC44 v2(117.24,86.84) ; U1.BB25 136.74,67.34 v2(137.24,67.84) ; U1.AH42 122.74,84.34 v2(123.24,84.84) ; v2(140.24,85.84) U1.BE43 ; U111.H8 v5(15.5,134.97) ; U1.AC20 v2(117.24,61.84) ; v2(117.24,55.84) 117.74,56.34 U1.AC14 ; J22.G20 v1(82.8,165.86) ; U141.K6 v2(92.23,113.32) ; v2(117.24,70.84) 117.74,70.34 U1.AC28 ; v2(106.24,83.84) 106.74,83.34 U1.M41 ; v2(104.24,56.84) 104.74,57.34 U1.K15 ; U1.V27 v2(112.24,69.84) ; U1.AF31 v2(121.24,73.84) ; J22.M33 v1(66.29,172.21) ; v2(126.24,84.84) 125.74,84.34 U1.AL42 ; v2(116.24,64.84) U1.AB23 ; U19.22 v1(63.03,146.44) ; v2(103.24,44.84) 103.74,45.34 U1.J3 ; U141.G4 v2(90.23,117.32) ; C1706.2 216.85,101.48 v2(216.55,101.78) ; MH3.1 131.32,25.12 ; MH3.1 131.32,17.65 ; MH3.1 135.05,21.39 ; MH3.1 127.58,21.39 ; MH3.1 134.01,18.7 ; MH3.1 128.63,18.7 ; MH3.1 128.63,24.08 ; MH3.1 134.01,24.08 ; J22.H39 v1(58.67,167.13) ; U19.12 53.77,140.59 53.39,140.21 v1(53.39,140.18) ; SW14.4 25.7,125.68 v1(26.21,126.19) ; J22.C12 v1(92.96,160.78) ; U167.17 138.08,107.71 v1(136.46,107.71) ; U167.17 138.14,106.57 ; U167.17 v1(140.74,107.11) ; U1.C41 97.74,83.34 v2(97.24,83.84) ; U1.AF27 120.74,69.34 v2(121.24,69.84) ; R318.2 R229.2 176.29,40.45 v1(175.91,40.07) ; U1.T45 v2(110.24,87.84) ; U1.AK27 124.74,69.34 v2(125.24,69.84) ; J22.F21 v1(81.53,164.59) ; v2(138.24,47.84) U1.BC6 ; U1.AY31 v2(135.24,73.84) ; U1.AG20 v2(122.24,61.84) ; 118.74,75.34 v2(119.24,75.84) ; R25.2 v1(85.32,54.89) ; v2(138.24,83.84) 137.74,83.34 U1.BC41 ; U1.W2 113.74,44.34 v2(113.24,43.84) ; 199.47,36.42 J38.1 ; J38.1 199.21,35.61 ; J38.1 200.28,34.29 ; J38.1 200.28,36.68 ; J38.1 201.26,36.6 ; U111.G7 v5(17.1,135.77) ; U141.G13 v2(100.23,117.32) ; C1270.2 v1(85.49,123.88) ; J22.B14 v1(90.42,159.51) ; 138.14,106.57 v1(136.46,106.57) ; v1(170.81,98.86) 170.18,98.86 169.61,99.43 C170.2 169.61,100.27 170.15,100.81 v1(170.15,101.57) ; U1.AK17 v2(125.24,58.84) ; v2(115.24,42.84) 115.74,43.34 U1.AA1 ; U142.C5 v2(80.32,119.17) ; C324.2 109.73,23.66 109.98,23.92 v1(110.74,23.92) ; R729.2 R730.2 14.38,112.92 v1(14.22,113.08) ; U142.E13 v2(78.32,110.17) ; R582.2 v1(139.52,114.36) ; v2(112.24,60.84) U1.V19 ; U1.C26 97.74,68.34 v2(97.24,68.84) ; U1.Y27 v2(114.24,69.84) ; U139.T1 v4(167.56,30.81) ; J2.F18 v1(155.35,164.59) ; U1.U37 v2(111.24,79.84) ; U1.AC17 117.74,59.34 v2(117.24,58.84) ; C1590.2 217.64,107.35 v1(217.98,107.69) ; v2(131.24,54.84) 130.74,55.34 U1.AT13 ; v2(124.24,81.84) 123.74,81.34 U1.AJ39 ; v2(132.24,42.84) 131.74,43.34 U1.AU1 ; U1.AJ2 123.74,44.34 v2(124.24,43.84) 123.74,43.34 U1.AJ1 ; v2(125.24,64.84) U1.AK23 ; U1.AR6 v2(130.24,47.84) ; U1.BD4 v2(139.24,45.84) ; v1(215.1,112.52) 214.69,112.92 U159.17 ; U142.K8 v2(72.32,115.17) ; J22.C4 v1(103.12,160.78) ; J22.H21 v1(81.53,167.13) ; v2(140.24,68.84) 139.74,68.34 U1.BE26 ; v1(209.03,112.23) 209.33,112.53 C1677.2 ; v1(15.54,93.8) 15.54,92.23 C68.2 16.64,92.25 v1(16.64,93.78) ; R65.2 v1(45.08,137.72) ; v1(101.04,101.78) 100.96,101.7 C1520.2 ; J22.K30 v1(70.1,169.67) ; J22.D16 v1(87.88,162.05) ; J2.A13 v1(161.7,158.24) ; v2(132.24,44.84) 131.74,45.34 U1.AU3 ; v1(68.1,108.99) 67.92,109.17 67.1,109.17 C1427.2 67.1,108.08 v1(68.07,108.08) ; U111.G3 v5(17.1,138.97) ; U1.U7 v2(111.24,48.84) ; J22.L15 v1(89.15,170.94) ; v1(59.84,84.21) 60.01,84.38 60.92,84.38 C519.2 61.18,85.02 v1(59.85,85.02) ; C138.2 v1(57.35,89.97) ; v2(120.24,84.84) 119.74,84.34 U1.AE42 ; J22.B23 v1(78.99,159.51) ; J22.H18 v1(85.34,167.13) ; U141.G8 v2(95.23,117.32) ; v2(116.24,78.84) U1.AB36 ; J2.H30 v1(140.11,167.13) ; U1.AT45 v2(131.24,87.84) ; v6(59.61,6.72) 59.65,6.68 U2.B13 ; v2(112.24,46.84) U1.V5 ; U142.L9 v2(71.32,114.17) ; 235.03,82.44 J53.9 ; J53.9 235.03,80.47 ; J53.9 234.7,81.46 ; v2(113.24,66.84) U1.W24 ; v1(170.89,41.81) 171,41.7 R319.2 ; v2(140.24,87.84) U1.BE45 ; J2.F6 v1(170.59,164.59) ; v1(124.54,134.09) 124.54,133.64 C171.2 125.96,133.44 v1(125.96,134.14) ; v2(125.24,62.84) U1.AK21 ; v1(110.39,31.37) 110.46,31.3 C177.2 C180.2 112.65,30.96 v1(113,30.61) ; U1.P8 v2(108.24,49.84) ; v2(125.24,87.84) U1.AK45 ; J22.E8 v1(98.04,163.32) ; U137.E8 v4(157.96,79.75) ; U1.AV5 v2(133.24,46.84) ; R122.2 v1(213.01,159.86) ; C603.2 C348.2 77.73,48.56 v4(77.16,49.14) ; U1.P46 v2(108.24,88.84) ; v2(139.24,87.84) U1.BD45 ; C1663.2 219.16,91.44 v3(218.96,91.24) ; v1(125.23,140.89) 125.05,141.07 R435.1 ; J22.E11 v1(94.23,163.32) ; U1.V3 112.74,45.34 v2(112.24,44.84) ; U1.R39 109.74,81.34 v2(109.24,81.84) ; U1.L10 v2(105.24,51.84) ; J22.C5 v1(101.85,160.78) ; U1.BA44 v2(136.24,86.84) ; R901.2 C1208.2 144.03,106.01 143.71,106.32 142.39,106.32 142.08,106.64 v1(142.08,107.11) ; J22.Y20 v1(82.8,155.7) ; v2(112.24,62.84) U1.V21 ; U1.BB15 136.74,57.34 v2(137.24,56.84) ; v2(109.24,84.84) 109.74,84.34 U1.R42 ; J2.E20 v1(152.81,163.32) ; v1(141.35,147.45) 140.49,147.45 140.02,146.98 C1633.2 140.02,145.74 140.49,145.26 v1(141.26,145.26) ; R162.2 46.67,132.38 v1(46.1,132.38) ; 26.28,173.84 J10.SH2 ; J10.SH2 30.57,173.84 ; J10.SH2 26.86,172.27 ; R594.2 85.25,71.27 v1(85.34,71.37) ; J22.E32 v1(67.56,163.32) ; U141.M10 v2(97.23,111.32) ; v1(105.66,159.51) J22.B2 ; U141.D12 v2(99.23,120.32) ; U135.F1 v4(158.76,45.16) ; v2(100.24,58.84) 100.74,59.34 U1.F17 ; 103.07,130.46 J105.6 102.08,130.13 ; v2(104.24,67.84) 104.74,67.34 U1.K25 ; U1.AF46 v2(121.24,88.84) ; U2.B29 75.65,5.74 v6(75.4,5.99) ; v1(60.98,131.1) 60.98,131.45 60.51,131.92 C1247.2 ; v2(97.24,44.84) 97.74,45.34 U1.C3 ; U1.W42 v2(113.24,84.84) ; v2(97.24,84.84) 97.74,84.34 U1.C42 ; C527.2 v1(206.76,144.33) ; U1.C6 v2(97.24,47.84) ; J2.H21 v1(151.54,167.13) ; v2(123.24,56.84) 122.74,57.34 U1.AH15 ; J22.G40 v1(57.4,165.86) ; C1138.2 73.29,77.2 v4(73.16,77.33) ; 98.74,75.34 v2(98.24,75.84) ; J2.F9 v1(166.78,164.59) ; U141.B2 v2(88.23,122.32) ; U1.R37 v2(109.24,79.84) ; v2(126.24,59.84) U1.AL18 ; R1073.2 v1(82.86,59.49) ; Z15.2 178.6,135.31 177.96,134.67 v1(177.96,133.91) ; J2.C8 v1(168.05,160.78) ; v2(133.24,44.84) 132.74,45.34 U1.AV3 ; v2(138.24,84.84) 137.74,84.34 U1.BC42 ; J22.M29 v1(71.37,172.21) ; U1.AW24 v2(134.24,66.84) ; U141.N1 v2(87.23,110.32) ; v2(113.24,61.84) U1.W20 ; C1589.2 v1(216.76,103.64) ; U1.K4 104.74,46.34 v2(104.24,45.84) ; U1.BD1 v2(139.24,42.84) ; v1(80.45,103.89) 80.59,104.03 C105.2 ; U39.7 v1(123.04,115.48) ; J22.M36 v1(62.48,172.21) ; J22.C28 v1(72.64,160.78) ; v2(102.24,46.84) U1.H5 ; C1519.2 v1(83.57,44.92) ; U1.R6 v2(109.24,47.84) ; v2(112.24,52.84) U1.V11 ; J2.A12 v1(162.97,158.24) ; U139.N1 v4(165.16,30.81) ; C1454.2 v1(82.93,60.76) ; v1(82.93,82.37) 82.95,82.35 C159.2 ; C1140.2 75.7,77.19 v4(75.56,77.33) ; U1.K10 v2(104.24,51.84) ; v2(130.24,57.84) 129.74,58.34 U1.AR16 ; J22.B27 v1(73.91,159.51) ; J2.G20 v1(152.81,165.86) ; C954.2 69.99,76.01 C1052.2 ; C1588.2 v1(209.18,110.86) ; J39.14 233.95,41.46 ; J39.14 231.98,43.43 ; J39.14 233.95,43.43 ; J39.14 231.65,42.44 ; J39.14 231.98,41.46 ; U1.AR26 129.74,68.34 v2(130.24,68.84) ; v2(116.24,87.84) U1.AB45 ; U141.B10 v2(97.23,122.32) ; J22.G17 v1(86.61,165.86) ; v1(82.14,43.64) 82.48,43.3 R1072.2 ; J2.G1 v1(176.94,165.86) ; U1.AF35 v2(121.24,77.84) ; v2(99.24,44.84) 99.74,45.34 U1.E3 ; J78.4 24.97,91.64 ; J78.4 25.96,89.34 ; J78.4 23.99,91.31 ; J78.4 23.99,89.34 ; J78.4 23.65,90.32 ; U1.U14 111.74,56.34 v2(111.24,55.84) ; U1.T46 v2(110.24,88.84) ; C1661.2 v1(219.16,108.55) ; C238.2 v1(26.13,154.4) ; U1.B9 v2(96.24,50.84) ; U137.F1 v4(158.76,73.35) ; 198.2,129.34 J26.1 ; J26.1 198.53,130.32 ; J26.1 199.52,130.66 ; J26.1 198.53,128.35 ; J26.1 200.5,128.35 ; J26.1 200.5,130.32 ; J26.1 200.84,129.34 ; v1(17.3,149.89) 17.3,149.1 C790.2 16.03,149.1 v1(16.03,149.89) ; U1.AC38 117.74,80.34 v2(117.24,80.84) ; v1(82.81,48.11) 82.85,48.11 82.85,48.14 82.89,48.18 C596.2 C1474.2 ; v2(112.24,64.84) U1.V23 ; v1(134.25,100.62) 133.53,100.62 C169.2 132.78,99.33 133.79,98.31 134.09,98.31 134.18,98.22 v1(134.27,98.22) ; C1755.2 116.46,101.75 v1(116.48,101.77) ; J22.G38 v1(59.94,165.86) ; R352.2 147.45,113.6 v1(147.41,113.56) ; v1(215.77,57.86) 215.35,57.44 C185.2 ; C1292.2 103.12,114.07 v1(103.28,114.22) ; U1.AC30 v2(117.24,72.84) ; v1(170.76,39.3) 170.87,39.3 171.25,38.92 Q61.2 ; U1.AY21 v2(135.24,62.84) ; J22.A1 v1(106.93,158.24) ; U135.E1 v4(157.96,45.16) ; J22.Z23 v1(78.99,156.97) ; J2.E32 v1(137.57,163.32) ; v1(131.83,26.54) 131.83,27.71 C1750.2 v1(131.05,26.51) ; U1.AW44 v2(134.24,86.84) ; v2(113.24,79.84) U1.W37 ; J2.A4 v1(173.13,158.24) ; U138.G8 v4(159.56,93.85) ; v2(110.24,58.84) 110.74,59.34 U1.T17 ; v1(82.86,58.34) R1071.2 C919.2 ; J2.J38 v1(129.95,168.4) ; v2(127.24,67.84) 126.74,67.34 U1.AM25 ; U1.D44 v2(98.24,86.84) ; v2(116.24,49.84) U1.AB8 ; U1.AK41 124.74,83.34 v2(125.24,83.84) ; U142.M4 v2(70.32,120.17) ; v2(96.24,81.84) 96.74,81.34 U1.B39 ; v2(99.24,86.84) U1.E44 ; v2(121.24,67.84) 120.74,67.34 U1.AF25 ; U1.AE30 v2(120.24,72.84) ; v1(79.05,19.56) 79.38,19.89 R21.2 ; C780.2 v1(15.45,113.26) ; v1(194.39,18.61) C1445.2 194.39,20.04 ; 231.98,38.92 J39.12 ; J39.12 233.95,40.89 ; J39.12 231.98,40.89 ; J39.12 231.65,39.9 ; J39.12 233.95,38.92 ; J22.Y21 v1(81.53,155.7) ; v1(22.66,169.67) 22.66,171.2 21.99,171.86 U115.1 20.99,171.86 20.72,171.59 20.72,171.21 21.51,170.41 v1(21.51,169.72) ; v2(97.24,42.84) 97.74,43.34 U1.C1 ; U162.17 183.59,62.97 U162.14 ; U162.17 v1(181.71,63.25) ; v2(136.24,80.84) 135.74,80.34 U1.BA38 ; U1.C16 97.74,58.34 v2(97.24,57.84) ; U1.AE1 119.74,43.34 v2(120.24,43.84) 119.74,44.34 U1.AE2 ; v1(72.47,72.59) 72.17,72.3 C953.2 ; U135.K9 v4(161.96,52.36) ; U1.M9 v2(106.24,50.84) ; C1558.2 v1(82.93,83.62) ; v2(116.24,51.84) U1.AB10 ; J22.D6 v1(100.58,162.05) ; U1.BA3 135.74,45.34 v2(136.24,44.84) ; U1.AR3 129.74,45.34 v2(130.24,44.84) ; U1.AG6 v2(122.24,47.84) ; U139.H1 v4(160.36,30.81) ; U142.E1 v2(78.32,123.17) 78.37,123.21 R1007.2 ; U1.AV6 v2(133.24,47.84) ; v2(135.24,83.84) 134.74,83.34 U1.AY41 ; v2(117.24,57.84) 117.74,58.34 U1.AC16 ; U1.U44 v2(111.24,86.84) ; U1.BB46 v2(137.24,88.84) ; U111.K7 v5(13.9,135.77) ; U1.AC2 117.74,44.34 v2(117.24,43.84) ; U139.K9 v4(161.96,38.01) ; U1.AH19 v2(123.24,60.84) ; J22.B26 v1(75.18,159.51) ; v2(116.24,73.84) U1.AB31 ; U1.AE11 v2(120.24,52.84) ; J2.C24 v1(147.73,160.78) ; U135.G8 v4(159.56,51.56) ; v1(141.73,24.64) 142.01,24.92 C1304.2 ; U2.B47 93.65,5.61 v6(93.27,5.99) ; U111.J5 v5(14.7,137.37) ; U1.AC32 v2(117.24,74.84) ; v2(117.24,68.84) 117.74,68.34 U1.AC26 ; U160.17 214.69,102.51 v1(215.1,102.11) ; v2(138.24,74.84) U1.BC32 ; U1.AH37 v2(123.24,79.84) ; v1(213.27,44.38) 213.27,45.14 213.9,45.77 Z94.2 ; v1(59.34,91.65) 60.12,91.65 C517.2 60.12,90.76 v1(59.34,90.76) ; U1.AC24 v2(117.24,66.84) ; v2(134.24,55.84) 133.74,56.34 U1.AW14 ; U1.AW6 v2(134.24,47.84) ; v2(107.24,81.84) 107.74,81.34 U1.N39 ; v1(68.34,103.79) 67.89,104.23 C107.2 ; U1.V4 112.74,46.34 v2(112.24,45.84) ; v2(139.24,47.84) U1.BD6 ; v2(116.24,60.84) U1.AB19 ; v1(91.57,32.99) 91.57,31.95 C1736.2 92.68,32.01 v1(92.68,32.99) ; v2(112.24,78.84) U1.V36 ; J2.K6 v1(170.59,169.67) ; v2(114.24,60.84) U1.Y19 ; v1(71.21,105.54) R259.2 ; J22.L18 v1(85.34,170.94) ; U139.M9 v4(163.56,38.01) ; R118.2 v1(203.11,156.68) ; v1(118.34,28.12) 118.34,27.9 117.99,27.54 U32.3 ; C891.2 9.01,67.7 v1(8.74,67.44) ; C356.2 v1(57.4,86.54) ; v1(38.61,145.77) 38.22,146.16 C78.2 ; J2.A24 v1(147.73,158.24) ; Q5.2 v1(217.33,155.2) ; U1.AK3 v2(125.24,44.84) ; J22.G35 v1(63.75,165.86) ; U138.H1 v4(160.36,87.45) ; C1662.2 v1(219.16,101.88) ; J22.F15 v1(89.15,164.59) ; C454.2 v1(177.59,145.93) ; U1.BB41 136.74,83.34 v2(137.24,83.84) ; U1.AH45 v2(123.24,87.84) ; EMICAGE1.14 v1(211.92,125.53) ; v2(130.24,84.84) 129.74,84.34 U1.AR42 ; J2.A5 v1(171.86,158.24) ; J22.D25 v1(76.45,162.05) ; v2(103.24,43.84) 103.74,44.34 U1.J2 ; v2(101.24,42.84) 101.74,43.34 U1.G1 ; v4(77.16,77.33) 77.73,76.76 C1053.2 C1054.2 ; v1(142.47,111.18) 142.53,111.11 C161.2 145.3,111.11 v1(146.25,112.06) ; v2(126.24,80.84) 125.74,80.34 U1.AL38 ; U1.AA26 v2(115.24,68.84) ; v1(82.93,87.42) 82.94,87.43 C1559.2 ; J22.C1 v1(106.93,160.78) ; v4(68.36,97.03) 67.9,97.03 67.58,97.34 C723.2 ; U1.N4 107.74,46.34 v2(107.24,45.84) ; v1(73.99,103.82) 73.99,104.29 C106.2 ; EMICAGE1.16 v1(183.17,123.73) ; U1.AD45 v2(119.24,87.84) ; J2.B3 v1(174.4,159.51) ; U142.E3 v2(78.32,121.17) ; v9(53.45,56.01) 53.25,56.21 U123.35 ; D36.2 v1(176.43,116.99) ; C1506.2 134.75,30.76 135.1,30.4 v1(135.32,30.4) 135.63,30.4 136.02,30.78 C1515.2 ; C1744.2 178.21,69.13 v1(177.12,69.13) ; v2(96.24,71.84) 96.74,71.34 U1.B29 ; J22.J17 v1(86.61,168.4) ; U1.AE26 119.74,68.34 v2(120.24,68.84) ; v2(128.24,81.84) 127.74,81.34 U1.AN39 ; J22.Z7 v1(99.31,156.97) ; v2(114.24,88.84) U1.Y46 ; U138.E9 v4(157.96,94.65) ; J2.D16 v1(157.89,162.05) ; v2(139.24,71.84) 138.74,71.34 U1.BD29 ; v2(115.24,66.84) U1.AA24 ; v1(105.66,162.05) J22.D2 ; U1.AV46 v2(133.24,88.84) ; J22.L26 v1(75.18,170.94) ; v2(101.24,47.84) U1.G6 ; J22.Y37 v1(61.21,155.7) ; U138.K1 v4(162.76,87.45) ; U1.P3 108.74,45.34 v2(108.24,44.84) ; J22.C21 v1(81.53,160.78) ; U1.AD25 118.74,67.34 v2(119.24,67.84) ; C352.2 81.86,100.94 81.32,100.4 80.73,100.4 v1(80.7,100.37) ; v1(66.85,54.91) 67.08,54.91 C437.2 ; U1.A44 v2(95.24,86.84) ; U142.B2 v2(81.32,122.17) ; U1.AA39 v2(115.24,81.84) ; J22.B22 v1(80.26,159.51) ; v1(186.83,84.38) 188.24,84.38 188.63,84 C1757.2 188.63,83.24 188.24,82.85 v1(186.83,82.85) ; v2(114.24,78.84) U1.Y36 ; v1(132.62,29.91) 132.08,30.44 131.46,30.44 131.06,30.84 R5.2 ; J22.Y1 v1(106.93,155.7) ; C1665.2 v1(182.82,57.85) ; U1.AC5 v2(117.24,46.84) ; U1.N7 v2(107.24,48.84) ; U1.W26 v2(113.24,68.84) ; v1(59.85,82.38) 60.93,82.38 C520.2 60.91,83.27 v1(59.85,83.27) ; U138.F1 v4(158.76,87.45) ; U1.AG36 v2(122.24,78.84) ; v2(130.24,43.84) 129.74,44.34 U1.AR2 ; EMICAGE1.15 v1(199.22,125.53) ; v2(98.24,83.84) 98.74,83.34 U1.D41 ; v2(139.24,86.84) U1.BD44 ; R700.2 v1(102.54,101.78) ; J22.H9 v1(96.77,167.13) ; U1.AN38 127.74,80.34 v2(128.24,80.84) ; C1164.2 145.41,102.68 v1(145.84,103.12) ; J2.J17 v1(156.62,168.4) ; J22.F24 v1(77.72,164.59) ; J2.B31 v1(138.84,159.51) ; J2.B10 v1(165.51,159.51) ; v1(109.98,30.4) 109.47,30.91 C622.2 ; U1.AW2 133.74,44.34 v2(134.24,43.84) ; J22.Z19 v1(84.07,156.97) ; J22.A12 v1(92.96,158.24) ; J22.Y16 v1(87.88,155.7) ; v2(102.24,88.84) U1.H46 ; v2(128.24,85.84) U1.AN43 ; U136.F1 v4(158.76,59.26) ; Q17.2 v1(208.5,155.14) ; U1.Y42 v2(114.24,84.84) ; J22.A37 v1(61.21,158.24) ; J2.C28 v1(142.65,160.78) ; U111.D2 v5(19.5,139.77) ; EMICAGE1.12 v1(231.96,124.53) ; J2.J8 v1(168.05,168.4) ; U1.P5 v2(108.24,46.84) ; v1(82.93,86.11) 82.93,86.14 82.95,86.16 C590.2 ; J2.A16 v1(157.89,158.24) ; U1.BA43 v2(136.24,85.84) ; U1.AU10 v2(132.24,51.84) ; J22.Z3 v1(104.39,156.97) ; v2(131.24,44.84) 130.74,45.34 U1.AT3 ; C1601.2 v1(151.07,142.52) ; C491.2 73.29,49.01 v4(73.16,49.14) ; J22.K9 v1(96.77,169.67) ; v2(127.24,79.84) U1.AM37 ; v1(230.12,94.41) 230.12,95.43 230.48,95.78 EMICAGE1.10 ; v2(127.24,88.84) U1.AM46 ; R595.2 85.23,68.27 v1(85.34,68.16) ; v2(132.24,83.84) 131.74,83.34 U1.AU41 ; U138.E3 v4(157.96,89.85) ; U1.AH36 v2(123.24,78.84) ; v2(122.24,57.84) 121.74,58.34 U1.AG16 ; C1657.2 v1(219.16,112.3) ; v1(59.34,93.8) 60.12,93.8 C516.2 60.12,92.91 v1(59.34,92.91) ; U111.E5 v5(18.7,137.37) ; J22.Z38 v1(59.94,156.97) ; U1.AE14 119.74,56.34 v2(120.24,55.84) ; U1.AC22 v2(117.24,63.84) ; v2(103.24,86.84) U1.J44 ; U1.AJ20 v2(124.24,61.84) ; J22.Z39 v1(58.67,156.97) ; J22.L27 v1(73.91,170.94) ; 130.74,75.34 v2(131.24,75.84) ; U1.W38 v2(113.24,80.84) ; v1(208.33,165.71) DS3.2 ; J2.G38 v1(129.95,165.86) ; v2(124.24,70.84) 123.74,70.34 U1.AJ28 ; U1.R38 109.74,80.34 v2(109.24,80.84) ; U1.Y17 114.74,59.34 v2(114.24,58.84) ; U141.K12 v2(99.23,113.32) ; v1(181.4,67.1) 181.62,66.88 C1599.2 182.22,66.14 182.6,66.52 v1(182.6,66.97) 183.36,66.97 C1680.2 ; J2.E14 v1(160.43,163.32) ; U1.AJ22 v2(124.24,63.84) ; R1085.2 R1087.2 124.58,33.52 v1(124.82,33.76) ; R1085.2 v1(123.43,33.69) ; R1085.2 R1084.2 ; U1.F27 v2(100.24,69.84) ; U1.V29 v2(112.24,71.84) ; U1.AW3 133.74,45.34 v2(134.24,44.84) ; J22.K6 v1(100.58,169.67) ; U141.C9 v2(96.23,121.32) ; U1.AY46 v2(135.24,88.84) ; J22.K15 v1(89.15,169.67) ; v2(107.24,57.84) 107.74,58.34 U1.N16 ; v2(135.24,45.84) 134.74,46.34 U1.AY4 ; U138.A8 v4(154.76,93.85) ; U111.A1 v5(21.9,140.57) ; J10.SH1 46.92,173.84 ; J10.SH1 46.34,172.27 ; J10.SH1 42.63,173.84 ; C1756.2 v1(82.93,55.93) ; U1.T3 110.74,45.34 v2(110.24,44.84) ; v2(99.24,61.84) U1.E20 ; U1.D46 v2(98.24,88.84) ; C1181.2 150.65,104.83 150.45,105.03 v1(150.24,105.03) ; J2.D7 v1(169.32,162.05) ; U141.G10 v2(97.23,117.32) ; J2.G4 v1(173.13,165.86) ; J22.E23 v1(78.99,163.32) ; U142.A2 v2(82.32,122.17) ; U1.AJ5 v2(124.24,46.84) ; U1.AU7 v2(132.24,48.84) ; U1.AG26 121.74,68.34 v2(122.24,68.84) ; U1.K8 v2(104.24,49.84) ; U1.AH23 v2(123.24,64.84) ; U1.AH44 v2(123.24,86.84) ; U137.K1 v4(162.76,73.35) ; v2(135.24,44.84) 134.74,45.34 U1.AY3 ; C1232.2 103.14,119.12 102.35,118.32 v2(101.24,118.32) ; U111.N15 v5(11.5,128.57) ; v2(216.32,81.51) 216.67,81.16 C232.2 ; U1.AJ26 123.74,68.34 v2(124.24,68.84) ; U1.AU9 v2(132.24,50.84) ; v1(151.13,110.92) 150.43,110.92 C1406.2 149.8,111.9 149.52,112.18 148.18,112.18 v1(147.41,111.4) ; v2(113.24,47.84) U1.W6 ; U136.K1 v4(162.76,59.26) ; J22.J38 v1(59.94,168.4) ; v1(209.12,100.87) 209.72,100.87 C1591.2 ; U1.AR40 129.74,82.34 v2(130.24,82.84) ; R67.2 v1(35.54,131.14) ; U1.C36 v2(97.24,78.84) ; J22.Z35 v1(63.75,156.97) ; U1.AM3 v2(127.24,44.84) ; U1.AB5 v2(116.24,46.84) ; U111.L5 v5(13.1,137.37) ; U1.AW41 133.74,83.34 v2(134.24,83.84) ; v1(53.59,129.47) 53.59,130.2 C1386.2 52.7,130.16 v1(52.7,129.47) ; J22.D10 v1(95.5,162.05) ; U1.AY45 v2(135.24,87.84) ; v2(116.24,44.84) 116.74,45.34 U1.AB3 ; v2(113.24,86.84) U1.W44 ; v2(125.24,51.84) U1.AK10 ; J2.G5 v1(171.86,165.86) ; 25.95,129.16 J110.2 ; J110.2 26.94,126.85 ; J110.2 27.92,127.19 ; J110.2 25.95,127.19 ; J110.2 25.61,128.18 ; C1483.2 v1(110.28,101.77) ; C1681.2 v1(142.74,137.97) ; J22.B3 v1(104.39,159.51) ; J2.K39 v1(128.68,169.67) ; U142.B12 v2(81.32,111.17) ; EMICAGE1.9 v1(230.01,83.08) ; J22.J8 v1(98.04,168.4) ; U142.N13 v2(69.32,110.17) ; C717.2 v4(73.93,66.07) ; J22.M4 v1(103.12,172.21) ; U111.R9 v5(9.9,133.37) ; J22.L10 v1(95.5,170.94) ; U1.M5 v2(106.24,46.84) ; U1.U20 v2(111.24,61.84) ; U1.AJ44 v2(124.24,86.84) ; U138.M9 v4(163.56,94.65) ; J22.Y24 v1(77.72,155.7) ; C1731.2 141.38,103.08 v1(141.73,103.43) ; v2(125.24,86.84) U1.AK44 ; J2.G8 v1(168.05,165.86) ; J2.B11 v1(164.24,159.51) ; J2.J32 v1(137.57,168.4) ; Q41.2 v1(210.71,155.2) ; U135.T1 v4(167.56,45.16) ; J22.J26 v1(75.18,168.4) ; SW4.4 100.56,131.9 v1(103.04,131.9) ; U1.V41 v2(112.24,83.84) ; v2(115.24,79.84) U1.AA37 ; J22.Y8 v1(98.04,155.7) ; U1.AG44 v2(122.24,86.84) ; J2.D39 v1(128.68,162.05) ; J22.J5 v1(101.85,168.4) ; U1.AP3 v2(129.24,44.84) ; U1.V42 v2(112.24,84.84) ; J22.F33 v1(66.29,164.59) ; U137.D2 v4(157.16,74.15) ; C657.2 82.98,89.84 v1(82.93,89.89) ; v2(106.24,82.84) 106.74,82.34 U1.M40 ; v2(140.24,83.84) 139.74,83.34 U1.BE41 ; 108.74,75.34 v2(108.24,75.84) ; J2.F2 v1(175.67,164.59) ; v1(171.35,105.11) 171.35,105.82 172.48,106.95 EMICAGE1.2 ; U137.N1 v4(165.16,73.35) ; U133.10 v1(153.06,18.57) ; U1.J28 v2(103.24,70.84) ; J22.D19 v1(84.07,162.05) ; U1.L12 v2(105.24,53.84) ; U1.AD31 v2(119.24,73.84) ; U136.K9 v4(161.96,66.46) ; J22.K33 v1(66.29,169.67) ; J2.A33 v1(136.3,158.24) ; U111.G14 v5(17.1,129.37) ; C589.2 94.31,101.68 v1(94.41,101.78) ; R460.2 v1(205.08,145.72) ; U136.A2 v4(154.76,60.06) ; U1.M46 v2(106.24,88.84) ; v2(133.24,83.84) 132.74,83.34 U1.AV41 ; U1.AF36 v2(121.24,78.84) ; v2(101.24,86.84) U1.G44 ; v1(72.84,86.92) 74.5,86.92 74.87,87.29 C1488.2 74.87,88.56 74.72,88.7 v1(72.84,88.7) ; v2(100.24,79.84) U1.F37 ; J22.E5 v1(101.85,163.32) ; U142.K2 v2(72.32,122.17) ; U1.B41 96.74,83.34 v2(96.24,83.84) ; J22.C29 v1(71.37,160.78) ; v2(100.24,87.84) U1.F45 ; J2.F21 v1(151.54,164.59) ; J2.G17 v1(156.62,165.86) ; U1.R10 v2(109.24,51.84) ; v1(82.93,81.06) 82.95,81.08 C658.2 ; C1557.2 v1(82.93,79.81) ; U1.AD27 118.74,69.34 v2(119.24,69.84) ; U111.L11 v5(13.1,131.77) ; J22.B35 v1(63.75,159.51) ; J2.D22 v1(150.27,162.05) ; R728.2 R727.2 v1(14.38,107.4) ; J2.K36 v1(132.49,169.67) ; U1.AD29 118.74,71.34 v2(119.24,71.84) ; v1(162.48,111.99) 161.72,111.99 161.09,112.62 Z93.2 ; J2.C1 v1(176.94,160.78) ; U137.E1 v4(157.96,73.35) ; U111.G5 v5(17.1,137.37) ; U1.AC35 v2(117.24,77.84) ; U138.N1 v4(165.16,87.45) ; U1.AT4 130.74,46.34 v2(131.24,45.84) ; U138.E1 v4(157.96,87.45) ; U136.N1 v4(165.16,59.26) ; v2(115.24,48.84) U1.AA7 ; v2(100.24,49.84) U1.F8 ; U1.L3 105.74,45.34 v2(105.24,44.84) ; v2(112.24,88.84) U1.V46 ; EMICAGE1.7 v1(205.14,78.74) ; SW4.3 90.19,131.9 v1(89.95,131.66) ; U1.AJ37 v2(124.24,79.84) ; C237.2 v1(27.1,158.52) ; J22.J14 v1(90.42,168.4) ; 196.43,133.73 C499.2 ; C499.2 196.43,136.37 ; C499.2 197.75,135.05 ; C499.2 197.42,134.07 ; C499.2 197.42,136.04 ; U1.N10 v2(107.24,51.84) ; U1.AD35 v2(119.24,77.84) ; v2(113.24,42.84) 113.74,43.34 U1.W1 ; U1.AF21 v2(121.24,62.84) ; J52.10 232.51,64.99 ; J52.10 232.18,65.97 ; J52.10 232.18,64.01 ; U111.E9 v5(18.7,133.37) ; v2(122.24,84.84) 121.74,84.34 U1.AG42 ; U139.E3 v4(157.96,33.21) ; J22.M32 v1(67.56,172.21) ; R1145.2 v1(83.72,121.6) ; v1(230.5,104.07) 230.5,105.02 230.83,105.35 231.43,105.35 231.96,105.89 EMICAGE1.11 ; C1505.2 C602.2 v1(82.79,50.72) ; J22.Z22 v1(80.26,156.97) ; v2(126.24,79.84) U1.AL37 ; J22.F12 v1(92.96,164.59) ; 120.74,75.34 v2(121.24,75.84) ; U1.AD46 v2(119.24,88.84) ; v1(154.08,162.05) J2.D19 ; J2.C13 v1(161.7,160.78) ; U1.AF19 v2(121.24,60.84) ; U111.H10 v5(15.5,132.57) ; J2.F36 v1(132.49,164.59) ; v1(145.39,29.97) 146.61,29.97 147,29.58 C168.2 147,28.75 146.62,28.37 v1(145.49,28.37) ; J22.C25 v1(76.45,160.78) ; v1(184.28,60.27) 184.45,60.1 C1595.2 ; U1.AF45 v2(121.24,87.84) ; v1(212.09,54.58) 212.39,54.88 C1528.2 ; J22.M37 v1(61.21,172.21) ; U1.AE43 v2(120.24,85.84) ; v2(101.24,44.84) 101.74,45.34 U1.G3 ; U1.T37 v2(110.24,79.84) ; U1.A12 v2(95.24,53.84) ; J22.D13 v1(91.69,162.05) ; U137.H1 v4(160.36,73.35) ; C872.2 v1(18.4,117.26) ; U141.G1 v2(87.23,117.32) ; U1.M10 v2(106.24,51.84) ; J22.C38 v1(59.94,160.78) ; 56.27,49.01 J1.3 55.92,50.04 ; C181.2 C176.2 115.88,31.3 v1(116.02,31.44) 116.55,31.44 R418.2 ; v2(100.24,86.84) U1.F44 ; C1617.2 v1(173.42,55.17) ; U1.AG18 v2(122.24,59.84) ; v2(125.24,73.84) U1.AK31 ; C1547.2 98.17,101.06 98.17,101.8 v1(98.12,101.85) ; v2(128.24,86.84) U1.AN44 ; C495.2 C604.2 v1(79.38,33.44) ; U137.C9 v4(156.36,80.55) ; U1.AH25 122.74,67.34 v2(123.24,67.84) ; J22.A32 v1(67.56,158.24) ; U136.M9 v4(163.56,66.46) ; J2.K2 v1(175.67,169.67) ; U38.3 93.41,28.15 v1(93.75,28.5) ; J22.M20 v1(82.8,172.21) ; J2.H9 v1(166.78,167.13) ; U1.K39 104.74,81.34 v2(104.24,81.84) ; U1.AM40 126.74,82.34 v2(127.24,82.84) ; v2(114.24,62.84) U1.Y21 ; J2.E4 v1(173.13,163.32) ; v2(99.24,72.84) U1.E30 ; U1.AN3 v2(128.24,44.84) ; U1.A3 95.74,45.34 v2(95.24,44.84) ; C149.2 v1(216.89,83.32) ; U1.AE16 119.74,58.34 v2(120.24,57.84) ; U1.AV7 v2(133.24,48.84) ; v1(93.01,101.78) 93.01,101.68 93.04,101.65 C1479.2 ; U141.E3 v2(89.23,119.32) ; U141.B4 v2(90.23,122.32) ; U1.F4 100.74,46.34 v2(100.24,45.84) ; C1584.2 v1(217.64,117.98) ; J22.M25 v1(76.45,172.21) ; U141.L9 v2(96.23,112.32) ; v2(112.24,58.84) 112.74,59.34 U1.V17 ; U39.24 120.03,111.58 v1(120.36,111.9) 120.03,112.23 U39.23 ; U1.N3 107.74,45.34 v2(107.24,44.84) ; J2.K33 v1(136.3,169.67) ; U1.U5 v2(111.24,46.84) ; U1.A43 v2(95.24,85.84) ; U1.C46 v2(97.24,88.84) ; J22.C9 v1(96.77,160.78) ; v2(113.24,59.84) U1.W18 ; U1.AR36 v2(130.24,78.84) ; C144.2 v1(30.44,147.35) ; J2.E35 v1(133.76,163.32) ; v1(192.56,79.2) 193.02,78.74 EMICAGE1.6 ; J22.B6 v1(100.58,159.51) ; v2(102.24,51.84) U1.H10 ; U1.AB41 v2(116.24,83.84) ; J22.L34 v1(65.02,170.94) ; U1.AE24 v2(120.24,66.84) ; v2(115.24,63.84) U1.AA22 ; J2.C4 v1(173.13,160.78) ; J2.K12 v1(162.97,169.67) ; J22.K24 v1(77.72,169.67) ; U1.R20 v2(109.24,61.84) ; v1(154.08,159.51) J2.B19 ; v2(106.24,71.84) 106.74,71.34 U1.M29 ; J2.D35 v1(133.76,162.05) ; J22.M9 v1(96.77,172.21) ; v2(114.24,44.84) 114.74,45.34 U1.Y3 ; J2.E23 v1(149,163.32) ; v2(119.24,84.84) 118.74,84.34 U1.AD42 ; J22.H12 v1(92.96,167.13) ; J22.J4 v1(103.12,168.4) ; J2.J11 v1(164.24,168.4) ; v2(139.24,88.84) U1.BD46 ; v2(103.24,48.84) U1.J7 ; v1(131.47,126.72) 132.49,126.72 132.78,126.42 C167.2 132.78,125.41 132.51,125.14 v1(131.56,125.14) ; U1.Y4 114.74,46.34 v2(114.24,45.84) ; U142.G4 v2(76.32,120.17) ; EMICAGE1.1 v1(174.48,121.18) ; J2.E1 v1(176.94,163.32) ; J2.B7 v1(169.32,159.51) ; v2(128.24,48.84) U1.AN7 ; U141.J11 v2(98.23,114.32) ; v2(112.24,73.84) U1.V31 ; U1.G2 101.74,44.34 v2(101.24,43.84) ; C1669.2 177.04,59.26 v1(177.16,59.39) ; v2(112.24,49.84) U1.V8 ; v2(126.24,86.84) U1.AL44 ; C551.2 v1(206.64,147.74) R424.2 ; v1(124.38,126.16) 123.3,126.16 C1740.2 123.27,127.41 v1(124.41,127.41) ; 39.42,118.07 39.42,119.1 v1(39.62,119.3) ; J6.2 v1(46.44,83.93) ; J22.C20 v1(82.8,160.78) ; J2.D2 v1(175.67,162.05) ; v2(127.24,86.84) U1.AM44 ; Q18.2 48.72,143.2 v1(48.72,143.61) 48.72,145.03 48.34,145.4 C1632.2 46.99,144.64 46.99,143.81 v1(46.91,143.74) ; U1.AE32 v2(120.24,74.84) ; v2(128.24,79.84) U1.AN37 ; v1(41.15,143.91) C80.2 ; v2(101.24,49.84) U1.G8 ; J22.Z11 v1(94.23,156.97) ; U111.K14 v5(13.9,129.37) ; v2(113.24,46.84) U1.W5 ; U135.H9 v4(160.36,52.36) ; U2.B16 62.65,5.49 v6(62.15,5.99) ; J22.H24 v1(77.72,167.13) ; C121.2 217.83,86.67 v3(217.83,87.38) ; U1.P13 108.74,55.34 v2(108.24,54.84) ; J2.C38 v1(129.95,160.78) ; J2.B22 v1(150.27,159.51) ; v1(164.27,27.94) 164.27,27.04 165.22,26.1 X6.2 164.03,25.25 163.96,25.18 R793.2 162.18,25.18 R792.2 ; C699.2 72.84,90.71 73.16,91.03 v4(73.16,91.43) ; J22.H33 v1(66.29,167.13) ; J2.E26 v1(145.19,163.32) ; v2(107.24,68.84) 107.74,68.34 U1.N26 ; J22.L31 v1(68.83,170.94) ; U141.G6 v2(92.23,117.32) ; J22.J32 v1(67.56,168.4) ; R1324.2 v1(7.33,88.63) ; C720.2 74.66,92.93 v4(74.76,93.03) ; U138.K9 v4(161.96,94.65) ; U111.J7 v5(14.7,135.77) ; U1.AU8 v2(132.24,49.84) ; U1.AH4 122.74,46.34 v2(123.24,45.84) ; J22.L6 v1(100.58,170.94) ; v2(134.24,42.84) 133.74,43.34 U1.AW1 ; U1.BB44 v2(137.24,86.84) ; v2(136.24,83.84) 135.74,83.34 U1.BA41 ; v2(129.24,86.84) U1.AP44 ; U1.AH46 v2(123.24,88.84) ; J2.D28 v1(142.65,162.05) ; Z116.2 v1(39.34,100.63) ; U1.AE22 v2(120.24,63.84) ; J22.E4 v1(103.12,163.32) ; J2.B26 v1(145.19,159.51) ; U1.W28 v2(113.24,70.84) ; U111.J9 v5(14.7,133.37) ; U1.BC3 v2(138.24,44.84) ; J22.Y4 v1(103.12,155.7) ; v2(105.24,43.84) 105.74,44.34 U1.L2 ; U1.AT46 v2(131.24,88.84) ; J22.L30 v1(70.1,170.94) ; U1.R30 v2(109.24,72.84) ; J22.E26 v1(75.18,163.32) ; C1576.2 v1(82.93,64.57) ; J22.K18 v1(85.34,169.67) ; U141.J7 v2(93.23,114.32) ; U136.E1 v4(157.96,59.26) ; J2.A21 v1(151.54,158.24) ; J22.A9 v1(96.77,158.24) ; U138.D2 v4(157.16,88.25) ; U139.F1 v4(158.76,30.81) ; J2.G26 v1(145.19,165.86) ; U111.C5 v5(20.3,137.37) ; v2(102.24,52.84) U1.H11 ; C1620.2 v1(168.49,128.23) ; U138.E8 v4(157.96,93.85) ; v1(188.63,59.37) C1596.2 ; U1.P45 v2(108.24,87.84) ; v2(73.32,117.17) U142.J7 ; v2(216.32,91.41) 216.75,91.41 217.1,91.06 C1707.2 ; C560.2 C497.2 ; J2.D6 v1(170.59,162.05) ; U1.E41 v2(99.24,83.84) ; v2(127.24,87.84) U1.AM45 ; J2.F12 v1(162.97,164.59) ; U1.AR11 v2(130.24,52.84) ; J22.Y36 v1(62.48,155.7) ; v2(119.24,82.84) 118.74,82.34 U1.AD40 ; J22.G23 v1(78.99,165.86) ; U135.E3 v4(157.96,47.56) ; U1.BF13 v2(141.24,54.84) ; J22.B7 v1(99.31,159.51) ; v2(116.24,88.84) U1.AB46 ; U139.E1 v4(157.96,30.81) ; J2.C21 v1(151.54,160.78) ; U1.T44 v2(110.24,86.84) ; U1.E40 v2(99.24,82.84) ; v1(91.64,101.78) 91.77,101.65 C1548.2 ; J22.C8 v1(98.04,160.78) ; U141.D8 v2(95.23,120.32) ; U1.AV37 v2(133.24,79.84) ; v1(18.82,149.89) 18.82,149.1 C791.2 20.09,149.1 v1(20.09,149.89) ; U1.BA8 v2(136.24,49.84) ; U1.AJ43 v2(124.24,85.84) ; v2(114.24,46.84) U1.Y5 ; Q60.2 44.98,146.64 v1(45.15,146.82) ; v2(124.24,57.84) 123.74,58.34 U1.AJ16 ; v2(129.24,49.84) U1.AP8 ; U2.B32 78.65,5.74 v6(78.9,5.99) ; J22.H6 v1(100.58,167.13) ; U1.AG30 v2(122.24,72.84) ; J22.A40 v1(57.4,158.24) ; U1.AW34 v2(134.24,76.84) ; J22.M5 v1(101.85,172.21) ; U1.AV45 v2(133.24,87.84) ; v2(115.24,61.84) U1.AA20 ; B1.2 v1(169.54,25.93) ; J22.D28 v1(72.64,162.05) ; J22.A21 v1(81.53,158.24) ; U142.M10 v2(70.32,113.17) ; U138.A2 v4(154.76,88.25) ; J2.J14 v1(160.43,168.4) ; J2.D10 v1(165.51,162.05) ; C71.2 v1(225.05,73.58) ; U1.BA1 135.74,43.34 v2(136.24,42.84) ; C1481.2 v1(142.37,30.4) ; R1084.2 R1083.2 ; R1084.2 122.04,33.49 v1(123.44,34.9) ; v1(229.23,113.97) 229.78,113.42 Z119.2 ; J22.E40 v1(57.4,163.32) ; U1.U28 111.74,70.34 v2(111.24,70.84) ; U1.L42 105.74,84.34 v2(105.24,84.84) ; v1(90.37,101.78) 90.5,101.65 C1549.2 ; J22.C36 v1(62.48,160.78) ; J2.C36 v1(132.49,160.78) ; J2.J1 v1(176.94,168.4) ; U1.AR1 129.74,43.34 v2(130.24,42.84) ; J22.H27 v1(73.91,167.13) ; v2(116.24,77.84) U1.AB35 ; C1574.2 v1(82.93,72.31) ; v2(125.24,52.84) U1.AK11 ; U1.U2 111.74,44.34 v2(111.24,43.84) ; U135.K1 v4(162.76,45.16) ; U1.BB5 v2(137.24,46.84) ; J2.H15 v1(159.16,167.13) ; v1(105.66,164.59) J22.F2 ; U135.H1 v4(160.36,45.16) ; J2.A32 v1(137.57,158.24) ; J22.J11 v1(94.23,168.4) ; U111.C15 v5(20.3,128.57) ; U2.A18 64.65,5.61 v6(65.03,5.99) ; U138.T1 v4(167.56,87.45) ; v2(114.24,51.84) U1.Y10 ; v2(125.24,88.84) U1.AK46 ; v1(74.49,72.82) 75.63,72.82 C1487.2 75.62,74.61 v1(74.49,74.61) ; v1(48.59,136.75) 49.1,137.26 49.48,137.26 49.73,137.52 C192.2 49.49,138.05 48.97,138.05 v1(48.51,137.59) ; J2.C33 v1(136.3,160.78) ; v1(156.25,105.7) 156.25,106.91 C206.2 155,106.6 155,105.98 v1(154.76,105.74) ; U1.D6 v2(98.24,47.84) ; v2(125.24,49.84) U1.AK8 ; v2(133.24,58.84) 132.74,59.34 U1.AV17 ; J2.C20 v1(152.81,160.78) ; U1.K35 v2(104.24,77.84) ; U1.AF12 v2(121.24,53.84) ; U1.U34 v2(111.24,76.84) ; R119.2 v1(207.17,159.86) ; J2.G40 v1(127.41,165.86) ; v1(120.36,115.48) U39.18 ; J2.C32 v1(137.57,160.78) ; U1.AB42 v2(116.24,84.84) ; J22.H3 v1(104.39,167.13) ; J22.C16 v1(87.88,160.78) ; J22.L7 v1(99.31,170.94) ; v1(133.02,114.87) 133.02,113.74 C461.2 131.39,113.57 v1(131.39,114.85) ; C1666.2 v1(189.67,57.85) ; J22.L35 v1(63.75,170.94) ; v1(105.66,169.67) J22.K2 ; v1(83.39,27.74) X5.4 ; J2.K27 v1(143.92,169.67) ; v2(130.24,83.84) 129.74,83.34 U1.AR41 ; v1(186.83,97.59) 188.24,97.59 188.63,97.21 R1228.2 188.63,96.44 188.24,96.06 v1(186.83,96.06) ; J2.B23 v1(149,159.51) ; J2.K18 v1(155.35,169.67) ; J2.B14 v1(160.43,159.51) ; J22.A24 v1(77.72,158.24) ; J2.C40 v1(127.41,160.78) ; EMICAGE1.3 v1(170.64,95.78) ; C555.2 C494.2 ; U135.E8 v4(157.96,51.56) ; U142.G8 v2(76.32,115.17) ; U141.A12 v2(99.23,123.32) ; Z1.2 214.34,66.72 214.98,67.36 v1(214.98,68.12) ; U136.G8 v4(159.56,65.66) ; J2.H36 v1(132.49,167.13) ; J22.K36 v1(62.48,169.67) ; J2.B15 v1(159.16,159.51) ; U1.AE35 v2(120.24,77.84) ; v1(72.68,140.8) 73.53,140.8 C460.2 74.15,138.9 v1(72.83,138.9) ; J2.H3 v1(174.4,167.13) ; v2(98.24,44.84) 98.74,45.34 U1.D3 ; J2.H18 v1(155.35,167.13) ; U19.11 53.48,141.24 v1(53.37,141.12) ; U1.AP39 128.74,81.34 v2(129.24,81.84) ; v2(141.24,64.84) U1.BF23 ; J22.Z34 v1(65.02,156.97) ; J22.D7 v1(99.31,162.05) ; J22.J35 v1(63.75,168.4) ; C1781.2 v1(47.55,152.93) ; J22.Y28 v1(72.64,155.7) ; v2(141.24,86.84) U1.BF44 ; Q7.2 4.69,128.03 v1(4.47,127.81) ; v2(99.24,51.84) U1.E10 ; v2(112.24,77.84) U1.V35 ; U40.5 v1(119.99,124.41) ; J2.C9 v1(166.78,160.78) ; U80.12 v1(143.19,123.47) ; U142.G10 v2(76.32,113.17) ; J22.M24 v1(77.72,172.21) ; U138.H9 v4(160.36,94.65) ; v1(82.93,61.99) 83.54,61.99 C1577.2 ; U1.V25 v2(112.24,67.84) ; J22.Y40 v1(57.4,155.7) ; R124.2 v1(217.08,159.73) ; U141.N13 v2(100.23,110.32) ; U1.AE5 v2(120.24,46.84) ; U1.AN1 v2(128.24,42.84) ; v2(120.24,70.84) 119.74,70.34 U1.AE28 ; J2.K30 v1(140.11,169.67) ; v1(141.13,22.26) 140.93,22.46 D9.2 ; J2.C16 v1(157.89,160.78) ; EMICAGE1.5 v1(179.74,78.74) ; C1327.2 v1(53.44,125.87) ; U111.F10 v5(17.9,132.57) ; J22.Z31 v1(68.83,156.97) ; v3(219.16,87.77) C227.2 ; U1.F41 v2(100.24,83.84) ; J22.F18 v1(85.34,164.59) ; C1708.2 v1(182.29,58.55) ; U139.K1 v4(162.76,30.81) ; C1451.2 82.98,63.3 v1(82.93,63.35) ; U1.AP5 v2(129.24,46.84) ; U1.AF8 v2(121.24,49.84) ; v2(140.24,47.84) U1.BE6 ; J22.Y9 v1(96.77,155.7) ; v2(121.24,71.84) 120.74,71.34 U1.AF29 ; J22.K3 v1(104.39,169.67) ; R1325.2 v1(7.33,75.8) ; J22.B15 v1(89.15,159.51) ; J2.B34 v1(135.03,159.51) ; U1.Y25 v2(114.24,67.84) ; U1.AH10 v2(123.24,51.84) ; J22.M13 v1(91.69,172.21) ; J2.A20 v1(152.81,158.24) ; J22.M40 v1(57.4,172.21) ; v1(11.76,63.45) 11.6,63.61 C54.2 ; U1.Y15 114.74,57.34 v2(114.24,56.84) ; J22.C32 v1(67.56,160.78) ; J2.J20 v1(152.81,168.4) ; J22.E17 v1(86.61,163.32) ; J22.E38 v1(59.94,163.32) ; v2(116.24,62.84) U1.AB21 ; U1.AC37 v2(117.24,79.84) ; v1(145.52,120.76) 145.52,121.19 C92.2 ; J22.L11 v1(94.23,170.94) ; U1.AL3 v2(126.24,44.84) ; v2(96.24,43.84) 96.74,44.34 U1.B2 ; U141.D6 v2(92.23,120.32) ; U137.D8 v4(157.16,79.75) ; U1.AB15 116.74,57.34 v2(116.24,56.84) ; v2(137.24,44.84) 136.74,45.34 U1.BB3 ; J22.L3 v1(104.39,170.94) ; J2.H12 v1(162.97,167.13) ; v2(73.32,121.17) U142.J3 ; R801.2 v1(162.18,14.39) ; U1.AE44 v2(120.24,86.84) ; C1600.2 v3(151.07,137.58) ; U1.J41 v2(103.24,83.84) ; J2.G23 v1(149,165.86) ; v1(73.49,100.41) 73.34,100.41 73.22,100.52 C108.2 ; J2.F24 v1(147.73,164.59) ; U1.AV44 v2(133.24,86.84) ; J22.J23 v1(78.99,168.4) ; J2.A17 v1(156.62,158.24) ; J2.G14 v1(160.43,165.86) ; U139.C9 v4(156.36,38.01) ; U1.AT9 v2(131.24,50.84) ; U1.AD5 v2(119.24,46.84) ; U1.AK25 124.74,67.34 v2(125.24,67.84) ; U1.L22 v2(105.24,63.84) ; U111.E8 v5(18.7,134.97) ; v1(67.79,113.08) 67.79,113.77 C1235.2 ; v1(35.6,104.47) 36.13,104.47 C905.2 36.13,103.58 v1(35.58,103.03) ; U139.G8 v4(159.56,37.21) ; J2.E38 v1(129.95,163.32) ; U1.AW42 133.74,84.34 v2(134.24,84.84) ; v2(122.24,70.84) 121.74,70.34 U1.AG28 ; U141.D2 v2(88.23,120.32) ; U1.AG24 v2(122.24,66.84) ; U1.AY11 v2(135.24,52.84) ; U1.B45 v2(96.24,87.84) ; J22.K21 v1(81.53,169.67) ; U139.D2 v4(157.16,31.61) ; R44.2 v1(31.75,147.88) ; v2(99.24,47.84) U1.E6 ; v2(115.24,77.84) U1.AA35 ; J22.B39 v1(58.67,159.51) ; U1.AF4 120.74,46.34 v2(121.24,45.84) ; J22.A20 v1(82.8,158.24) ; U1.BA18 v2(136.24,59.84) ; U1.B19 v2(96.24,60.84) ; v2(100.24,88.84) U1.F46 ; U1.BF3 v2(141.24,44.84) ; U1.AA28 v2(115.24,70.84) ; v2(102.24,50.84) U1.H9 ; Q34.2 3.18,136.83 3.3,136.7 v1(3.3,136.32) 2.94,135.96 R97.2 ; C1518.2 v1(82.93,84.89) ; U1.E1 99.74,43.34 v2(99.24,42.84) ; v1(87.32,100.4) 87.07,100.4 86.69,100.78 C351.2 ; J22.Z6 v1(100.58,156.97) ; J22.H30 v1(70.1,167.13) ; EMICAGE1.13 v1(224.62,125.53) ; U1.BF5 v2(141.24,46.84) ; v1(142.78,136.82) 142.79,136.81 C1604.2 ; U1.AL2 v2(126.24,43.84) ; U139.A8 v4(154.76,37.21) ; U136.E8 v4(157.96,65.66) ; J22.K27 v1(73.91,169.67) ; v2(103.24,59.84) U1.J18 ; v2(102.24,73.84) U1.H31 ; J22.B34 v1(65.02,159.51) ; J22.M28 v1(72.64,172.21) ; J2.J35 v1(133.76,168.4) ; J22.A25 v1(76.45,158.24) ; v2(126.24,70.84) 125.74,70.34 U1.AL28 ; R117.2 v1(200.72,157.42) ; v1(13.23,149.89) 13.23,149.1 C789.2 14.5,149.1 v1(14.5,149.89) ; U2.B7 v6(51.65,7.14) ; v2(115.24,43.84) 115.74,44.34 U1.AA2 ; U139.E8 v4(157.96,37.21) ; U1.BF41 140.74,83.34 v2(141.24,83.84) ; J22.Y5 v1(101.85,155.7) ; J22.L19 v1(84.07,170.94) ; U1.L44 v2(105.24,86.84) ; J22.G14 v1(90.42,165.86) ; v2(114.24,87.84) U1.Y45 ; v2(129.24,60.84) U1.AP19 ; v1(41.51,125.35) 42.5,125.35 42.98,124.86 Z88.2 ; U1.R2 109.74,44.34 v2(109.24,43.84) ; v1(107.41,125.11) 108.56,125.11 C911.2 108.57,123.32 v1(107.41,123.32) ; U1.Y40 v2(114.24,82.84) ; v2(101.24,76.84) U1.G34 ; U1.BC2 v2(138.24,43.84) ; J22.M17 v1(86.61,172.21) ; U135.D8 v4(157.16,51.56) ; C228.2 209.73,81.54 v1(209.18,82.09) ; v2(141.24,75.84) 140.74,75.34 ; U1.U43 v2(111.24,85.84) ; v1(10.26,68.78) 11.16,68.78 C892.2 ; v1(28.75,126.11) 30.25,126.11 30.53,126.39 C796.2 30.53,126.75 30.28,127 v1(28.75,127) ; v2(116.24,52.84) U1.AB11 ; J2.A40 v1(127.41,158.24) ; U1.AD36 v2(119.24,78.84) ; v1(177.09,72.49) 178.1,72.49 C1743.2 ; U1.AL5 v2(126.24,46.84) ; U1.B6 v2(96.24,47.84) ; U1.J38 v2(103.24,80.84) ; J22.Y29 v1(71.37,155.7) ; v1(148.17,100.78) 148.83,100.12 C251.2 C254.2 ; v2(126.24,47.84) U1.AL6 ; U1.AJ18 v2(124.24,59.84) ; J22.E1 v1(106.93,163.32) ; U135.N1 v4(165.16,45.16) ; v2(108.24,83.84) 108.74,83.34 U1.P41 ; v1(99.57,101.8) 99.57,101.74 99.54,101.7 99.54,101.69 99.39,101.54 C628.2 ; v2(99.24,43.84) 99.74,44.34 U1.E2 ; v2(111.24,42.84) 111.74,43.34 U1.U1 ; U141.E11 v2(98.23,119.32) ; U1.T5 v2(110.24,46.84) ; U1.BC22 v2(138.24,63.84) ; U1.K44 v2(104.24,86.84) ; C1672.2 v1(152.59,143.56) ; U1.T4 110.74,46.34 v2(110.24,45.84) ; U1.U22 v2(111.24,63.84) ; J22.K12 v1(92.96,169.67) ; J22.E20 v1(82.8,163.32) ; J2.E17 v1(156.62,163.32) ; U1.AK5 v2(125.24,46.84) ; Q36.2 v1(215.07,155.16) ; J2.D37 v1(131.22,162.05) ; v2(107.24,42.84) 107.74,43.34 U1.N1 ; U138.B2 v4(155.56,88.25) ; v2(73.32,112.17) U142.J11 ; U1.AY44 v2(135.24,86.84) ; J2.F27 v1(143.92,164.59) ; v1(72.18,87.64) 71.13,88.69 R709.2 ; v2(128.24,53.84) U1.AN12 ; v2(99.24,48.84) U1.E7 ; U1.D45 v2(98.24,87.84) ; U141.M2 v2(88.23,111.32) ; J2.A29 v1(141.38,158.24) ; J22.G32 v1(67.56,165.86) ; J2.A9 v1(166.78,158.24) ; J2.J40 v1(127.41,168.4) ; C129.2 v1(33.52,145.47) ; J2.G35 v1(133.76,165.86) ; J2.G29 v1(141.38,165.86) ; v1(133.25,16.33) 133.25,15.93 132.89,15.57 U53.2 ; v2(108.24,81.84) 108.74,81.34 U1.P39 ; R1235.2 v1(236.52,117.54) ; v2(129.24,88.84) U1.AP46 ; v2(104.24,83.84) 104.74,83.34 U1.K41 ; v2(113.24,63.84) U1.W22 ; J22.E35 v1(63.75,163.32) ; v2(102.24,87.84) U1.H45 ; U1.N36 v2(107.24,78.84) ; J2.B2 v1(175.67,159.51) ; J22.H15 v1(89.15,167.13) ; U111.M8 v5(12.3,134.97) ; C1658.2 v1(219.16,118.96) ; U1.B4 96.74,46.34 v2(96.24,45.84) ; U137.M9 v4(163.56,80.55) ; J2.C5 v1(171.86,160.78) ; U1.K45 v2(104.24,87.84) ; J2.H39 v1(128.68,167.13) ; U141.J3 v2(89.23,114.32) ; v2(115.24,85.84) U1.AA43 ; U137.G8 v4(159.56,79.75) ; J22.K39 v1(58.67,169.67) ; C750.2 C704.2 ; C346.2 v1(13.31,63.47) ; U135.C9 v4(156.36,52.36) ; J22.C33 v1(66.29,160.78) ; C1073.2 v1(66.81,83.61) ; U1.U36 v2(111.24,78.84) ; J22.G5 v1(101.85,165.86) ; J22.Z15 v1(89.15,156.97) ; J2.F3 v1(174.4,164.59) ; J22.L22 v1(80.26,170.94) ; v2(123.24,58.84) 122.74,59.34 U1.AH17 ; U142.M2 v2(70.32,122.17) ; U1.H41 v2(102.24,83.84) ; U1.AD23 v2(119.24,64.84) ; U1.BD41 138.74,83.34 v2(139.24,83.84) ; v2(115.24,72.84) U1.AA30 ; v2(117.24,52.84) U1.AC11 ; U141.M4 v2(90.23,111.32) ; v2(125.24,79.84) U1.AK37 ; J2.E40 v1(127.41,163.32) ; U141.C5 v2(91.23,121.32) ; U1.AE7 v2(120.24,48.84) ; J2.B6 v1(170.59,159.51) ; J22.F9 v1(96.77,164.59) ; J2.A28 v1(142.65,158.24) ; U136.E9 v4(157.96,66.46) ; J22.A16 v1(87.88,158.24) ; C825.2 v1(8.05,141.52) ; J22.Y13 v1(91.69,155.7) ; v2(101.24,66.84) U1.G24 ; C1585.2 v2(216.76,114.05) ; U1.AD19 v2(119.24,60.84) ; U139.H9 v4(160.36,38.01) ; U111.D12 v5(19.5,130.97) ; v2(140.24,78.84) U1.BE36 ; U111.G13 v5(17.1,130.17) ; U1.AN2 v2(128.24,43.84) ; U1.A22 v2(95.24,63.84) ; U139.D8 v4(157.16,37.21) ; C81.2 v1(199.79,16.54) ; U1.AD9 v2(119.24,50.84) ; U111.K4 v5(13.9,138.17) ; v2(115.24,76.84) U1.AA34 ; U136.D2 v4(157.16,60.06) ; C1475.2 v1(143.64,30.53) ; J22.F27 v1(73.91,164.59) ; J22.F6 v1(100.58,164.59) ; J22.G8 v1(98.04,165.86) ; U1.AT10 v2(131.24,51.84) ; U137.H9 v4(160.36,80.55) ; J22.B18 v1(85.34,159.51) ; U1.BA2 135.74,44.34 v2(136.24,43.84) ; J22.F39 v1(58.67,164.59) ; v2(125.24,60.84) U1.AK19 ; U135.M9 v4(163.56,52.36) ; J22.Y32 v1(67.56,155.7) ; J22.M8 v1(98.04,172.21) ; U1.AH21 v2(123.24,62.84) ; J22.B38 v1(59.94,159.51) ; J22.G29 v1(71.37,165.86) ; U1.AU43 v2(132.24,85.84) ; J2.B18 v1(155.35,159.51) ; Q37.2 v1(206.47,155.14) ; U1.N43 v2(107.24,85.84) ; J22.D37 v1(61.21,162.05) ; v2(111.24,68.84) 111.74,68.34 U1.U26 ; U1.M45 v2(106.24,87.84) ; J2.B39 v1(128.68,159.51) ; v2(99.24,85.84) U1.E43 ; U137.A2 v4(154.76,74.15) ; U1.BE2 v2(140.24,43.84) ; J22.Y12 v1(92.96,155.7) ; U1.AD10 v2(119.24,51.84) ; J22.L14 v1(90.42,170.94) ; v2(138.24,86.84) U1.BC44 ; U111.B8 v5(21.1,134.97) ; U1.U39 111.74,81.34 v2(111.24,81.84) ; C1664.2 v3(219.16,98.19) ; U142.G13 v2(76.32,110.17) ; U1.D5 v2(98.24,46.84) ; v2(117.24,47.84) U1.AC6 ; J22.A36 v1(62.48,158.24) ; U1.AJ7 v2(124.24,48.84) ; J2.C29 v1(141.38,160.78) ; U1.T10 v2(110.24,51.84) ; U1.P44 v2(108.24,86.84) ; J2.B27 v1(143.92,159.51) ; U1.AJ34 v2(124.24,76.84) ; v2(127.24,50.84) U1.AM9 ; U142.B4 v2(81.32,120.17) ; U142.D8 v2(79.32,115.17) ; U142.G1 v2(76.32,123.17) ; J22.D22 v1(80.26,162.05) ; U137.K9 v4(161.96,80.55) ; U1.M19 v2(106.24,60.84) ; U142.K12 v2(72.32,111.17) ; J22.F30 v1(70.1,164.59) ; J22.E14 v1(90.42,163.32) ; U142.G6 v2(76.32,118.17) ; U1.C44 v2(97.24,86.84) ; v2(109.24,42.84) 109.74,43.34 U1.R1 ; J22.D35 v1(63.75,162.05) ; J22.G26 v1(75.18,165.86) ; C1485.2 v1(121.13,101.77) ; U141.E13 v2(100.23,119.32) ; U1.G41 v2(101.24,83.84) ; v2(139.24,50.84) U1.BD9 ; U136.H9 v4(160.36,66.46) ; EMICAGE1.4 v1(172.48,79.78) ; U135.D2 v4(157.16,45.96) ; U1.AM15 v2(127.24,56.84) ; U1.AB4 116.74,46.34 v2(116.24,45.84) ; J2.K21 v1(151.54,169.67) ; C955.2 C1139.2 ; R58.2 v1(50.95,139.64) ; U1.P23 v2(108.24,64.84) ; J2.F15 v1(159.16,164.59) ; J22.A13 v1(91.69,158.24) ; U1.U18 v2(111.24,59.84) ; J2.J26 v1(145.19,168.4) ; J2.D25 v1(146.46,162.05) ; U1.AE34 v2(120.24,76.84) ; U1.P10 v2(108.24,51.84) ; J22.Z10 v1(95.5,156.97) ; J22.A4 v1(103.12,158.24) ; U136.H1 v4(160.36,59.26) ; v2(115.24,74.84) U1.AA32 ; U142.A12 v2(82.32,111.17) ; J22.A5 v1(101.85,158.24) ; v2(115.24,86.84) U1.AA44 ; U1.AU44 v2(132.24,86.84) ; J2.E5 v1(171.86,163.32) ; J2.C17 v1(156.62,160.78) ; J2.K3 v1(174.4,169.67) ; J2.F39 v1(128.68,164.59) ; R123.2 v1(214.96,159.82) ; R120.2 v1(209.11,159.82) ; J22.Y17 v1(86.61,155.7) ; J2.J23 v1(149,168.4) ; U1.BA6 v2(136.24,47.84) ; v2(102.24,86.84) U1.H44 ; J22.C40 v1(57.4,160.78) ; U1.R5 v2(109.24,46.84) ; C1303.2 v1(144.12,21.14) ; v1(105.66,170.94) J22.L2 ; U111.P2 v5(10.7,139.77) ; U142.D2 v2(79.32,122.17) ; J22.J40 v1(57.4,168.4) ; U1.AB29 v2(116.24,71.84) ; C128.2 v1(195.96,62.92) ; J2.K9 v1(166.78,169.67) ; U136.E3 v4(157.96,61.66) ; J22.B19 v1(84.07,159.51) ; J22.F36 v1(62.48,164.59) ; v1(57.68,117.12) 57.46,117.34 C1342.2 ; U1.R44 v2(109.24,86.84) ; U137.T1 v4(167.56,73.35) ; J2.C12 v1(162.97,160.78) ; X5.2 v1(80.04,30.43) ; J22.A33 v1(66.29,158.24) ; U1.AG11 v2(122.24,52.84) ; J2.A25 v1(146.46,158.24) ; U141.B12 v2(99.23,122.32) ; U1.AU30 v2(132.24,72.84) ; U1.AF23 v2(121.24,64.84) ; J2.H6 v1(170.59,167.13) ; L35.1 v1(7.8,67.87) ; J22.A28 v1(72.64,158.24) ; U1.AR44 v2(130.24,86.84) ; J22.C34 v1(65.02,160.78) ; U142.K6 v2(72.32,118.17) ; U111.H6 v5(15.5,136.57) ; U1.AD21 v2(119.24,62.84) ; C1593.2 v3(217.64,97.15) ; J22.M1 v1(106.93,172.21) ; U138.D8 v4(157.16,93.85) ; J22.Y33 v1(66.29,155.7) ; U1.U24 v2(111.24,66.84) ; v2(115.24,46.84) U1.AA5 ; J22.L38 v1(59.94,170.94) ; J2.B35 v1(133.76,159.51) ; U136.C9 v4(156.36,66.46) ; J2.B30 v1(140.11,159.51) ; U1.AK4 v2(125.24,45.84) ; J22.L39 v1(58.67,170.94) ; U1.BB35 v2(137.24,77.84) ; J22.Z26 v1(75.18,156.97) ; J2.A37 v1(131.22,158.24) ; U1.AN22 v2(128.24,63.84) ; C143.2 v1(31.75,145.19) ; v2(115.24,52.84) U1.AA11 ; v2(102.24,62.84) U1.H21 ; J22.C13 v1(91.69,160.78) ; v2(127.24,51.84) U1.AM10 ; U1.AG5 v2(122.24,46.84) ; C700.2 C755.2 ; J2.D13 v1(161.7,162.05) ; J22.H36 v1(62.48,167.13) ; v2(112.24,51.84) U1.V10 ; U142.D12 v2(79.32,111.17) ; U137.A8 v4(154.76,79.75) ; U1.AG22 v2(122.24,63.84) ; U135.A8 v4(154.76,51.56) ; U141.E1 v2(87.23,119.32) ; U136.A8 v4(154.76,65.66) ; U111.F6 v5(17.9,136.57) ; U1.AM4 v2(127.24,45.84) ; U1.N44 v2(107.24,86.84) ; J2.A1 v1(176.94,158.24) ; U1.AB25 v2(116.24,67.84) ; U1.BB45 v2(137.24,87.84) ; J2.J5 v1(171.86,168.4) ; J22.G11 v1(94.23,165.86) ; J2.E29 v1(141.38,163.32) ; J2.H27 v1(143.92,167.13) ; R379.2 v1(82.93,67.11) ; J2.H33 v1(136.3,167.13) ; J22.J20 v1(82.8,168.4) ; U1.M44 v2(106.24,86.84) ; J22.A29 v1(71.37,158.24) ; J2.J4 v1(173.13,168.4) ; J2.A8 v1(168.05,158.24) ; v2(99.24,49.84) U1.E8 ; v2(114.24,50.84) U1.Y9 ; U137.B2 v4(155.56,74.15) ; v2(116.24,75.84) 116.74,75.34 ; C1476.2 v1(111.83,101.77) ; Q6.2 v1(219.73,155.21) ; U141.A2 v2(88.23,123.32) ; J22.A8 v1(98.04,158.24) ; v2(102.24,49.84) U1.H8 ; C550.2 v1(203.59,145.98) ; U139.B2 v4(155.56,31.61) ; EMICAGE1.8 v1(217.84,78.74) ; C134.2 v1(45.08,138.93) ; J2.F33 v1(136.3,164.59) ; J22.C24 v1(77.72,160.78) ; U1.AE37 v2(120.24,79.84) ; J22.B30 v1(70.1,159.51) ; U142.M12 v2(70.32,111.17) ; U142.C9 v2(80.32,114.17) ; J22.B11 v1(94.23,159.51) ; R202.2 v1(41.2,145.23) ; U1.AH5 v2(123.24,46.84) ; 139.41,128.38 C1732.2 139.45,129.39 v1(140.44,129.39) 141.28,129.39 C1419.2 141.32,128.38 v1(140.44,128.38) 139.41,128.38
  TOP w0.508: 55.11,103.62 J33.5 ; J33.5 56.41,104.08 ; J33.5 54.65,102.32 ; J33.5 55.11,101.02 ; J33.5 57.71,103.62 ; 68.07,133.27 J35.4 ; J35.4 69.37,136.34 ; J35.4 68.07,135.87 ; J35.4 67.6,134.57 ; J35.4 70.67,135.87 ; J34.2 86.39,136.34 ; J34.2 88.15,134.57 ; J34.2 87.68,133.27 ; J34.2 87.68,135.87 ; J34.2 85.09,135.87 ; 54.65,97.24 J33.4 ; J33.4 57.71,95.94 ; J33.4 55.11,95.94 ; J33.4 56.41,95.47 ; J33.4 55.11,98.54 ; J30.2 33.71,101.02 ; J30.2 32.41,104.08 ; J30.2 34.18,102.32 ; J30.2 31.11,103.62 ; J30.2 33.71,103.62 ; 79.54,129.49 J34.5 ; J34.5 81.31,127.73 ; J34.5 80.01,128.19 ; J34.5 82.6,128.19 ; 20.47,95.47 J31.3 ; J31.3 22.24,97.24 ; J31.3 19.17,95.94 ; J31.3 21.77,98.54 ; J31.3 21.77,95.94 ; 68.07,130.79 J35.2 70.67,128.19 ; J34.4 87.68,128.19 ; J34.4 87.68,130.79 ; J34.4 85.09,128.19 ; J34.4 86.39,127.73 ; J34.4 88.15,129.49 ; 15.39,95.47 J31.2 ; J31.2 14.09,95.94 ; J31.2 14.09,98.54 ; J31.2 13.63,97.24 ; J31.2 16.69,95.94 ; J35.5 75.75,135.87 ; J35.5 76.21,134.57 ; J35.5 74.45,136.34 ; J35.5 73.15,135.87 ; J35.5 75.75,133.27 ; 60.19,115.55 J32.4 ; J32.4 62.79,115.55 ; J32.4 63.26,114.25 ; J32.4 61.49,116.02 ; J32.4 62.79,112.95 ; J32.5 62.79,110.47 ; J32.5 60.19,107.87 ; J32.5 62.79,107.87 ; J32.5 61.49,107.41 ; J32.5 63.26,109.17 ; 31.11,95.94 J30.4 ; J30.4 33.71,98.54 ; J30.4 33.71,95.94 ; J30.4 32.41,95.47 ; J30.5 28.63,95.94 ; J30.5 26.03,98.54 ; J30.5 26.03,95.94 ; J30.5 27.33,95.47 ; J30.5 25.57,97.24 ; 60.19,103.62 J33.3 61.49,104.08 ; J31.5 21.77,101.02 ; J31.5 21.77,103.62 ; J31.5 19.17,103.62 ; J31.5 22.24,102.32 ; J31.5 20.47,104.08 ; 79.54,134.57 J34.3 ; J34.3 81.31,136.34 ; J34.3 80.01,135.87 ; J34.3 82.6,135.87 ; J34.3 80.01,133.27 ; 56.41,116.02 J32.2 57.71,115.55 ; 57.71,107.87 J32.3 56.41,107.41 ; 26.03,103.62 J30.3 ; J30.3 26.03,101.02 ; J30.3 25.57,102.32 ; J30.3 28.63,103.62 ; J30.3 27.33,104.08 ; 14.09,103.62 J31.4 ; J31.4 15.39,104.08 ; J31.4 16.69,103.62 ; J31.4 13.63,102.32 ; J31.4 14.09,101.02 ; J35.3 76.21,129.49 ; J35.3 73.15,128.19 ; J35.3 74.45,127.73 ; J35.3 75.75,128.19
  02_GND w0.381: J1.10 17.63,60.71 ; J1.10 15.37,60.71 ; J1.10 16.5,59.58 ; J1.10 15.65,59.86 ; J1.10 15.65,61.56 ; J1.10 17.35,61.56 ; J1.10 17.35,59.86 ; J1.10 16.5,61.84 ; 48.85,15.28 J96.4 ; J96.4 50.55,16.98 ; J96.4 50.55,15.28 ; J96.4 50.83,16.13 ; J96.4 48.85,16.98 ; J96.4 49.7,15 ; J96.4 49.7,17.26 ; J96.4 48.57,16.13 ; 20.15,16.98 J96.7 ; J96.7 20.15,15.28 ; J96.7 21,17.26 ; J96.7 21.85,16.98 ; J96.7 21,15 ; J96.7 19.87,16.13 ; J96.7 21.85,15.28 ; J96.7 22.13,16.13 ; J105.6 104.13,129.14 ; J105.6 103.87,129.95 ; J105.6 103.07,130.21 ; J105.6 102.26,129.95 ; J105.6 102.26,128.34 ; J105.6 102,129.14 ; J105.6 103.07,128.07 ; J105.6 103.87,128.34 ; 171.91,144.45 J24.1 ; J24.1 174.04,144.45 ; J24.1 173.78,143.64 ; J24.1 172.17,143.64 ; J24.1 172.17,145.25 ; J24.1 172.97,145.52 ; J24.1 172.97,143.38 ; J24.1 173.78,145.25 ; 45.2,34 J96.1 ; J96.1 44.07,35.13 ; J96.1 44.35,35.98 ; J96.1 46.05,34.28 ; J96.1 44.35,34.28 ; J96.1 45.2,36.26 ; J96.1 46.33,35.13 ; J96.1 46.05,35.98 ; J1.6 30,42.84 ; J1.6 28.87,41.71 ; J1.6 30.85,40.86 ; J1.6 30,40.58 ; J1.6 31.13,41.71 ; J1.6 30.85,42.56 ; J1.6 29.15,42.56 ; J1.6 29.15,40.86 ; 54.04,31.48 J96.2 ; J96.2 54.89,29.5 ; J96.2 53.76,30.63 ; J96.2 55.74,31.48 ; J96.2 54.04,29.78 ; J96.2 56.02,30.63 ; J96.2 54.89,31.76 ; J96.2 55.74,29.78 ; 231.9,32.28 J39.6 ; J39.6 233.77,33.09 ; J39.6 232.97,33.35 ; J39.6 234.03,32.28 ; J39.6 232.97,31.21 ; J39.6 233.77,31.48 ; J39.6 232.16,33.09 ; J39.6 232.16,31.48 ; 42.88,173.84 J10.SH1 ; J10.SH1 46.17,172.45 ; J10.SH1 46.67,173.84 ; 7.5,34 J96.9 ; J96.9 6.65,35.98 ; J96.9 6.65,34.28 ; J96.9 8.63,35.13 ; J96.9 6.37,35.13 ; J96.9 8.35,35.98 ; J96.9 7.5,36.26 ; J96.9 8.35,34.28 ; 6.65,61.56 J1.9 ; J1.9 8.35,61.56 ; J1.9 8.35,59.86 ; J1.9 7.5,61.84 ; J1.9 6.37,60.71 ; J1.9 7.5,59.58 ; J1.9 6.65,59.86 ; J1.9 8.63,60.71 ; J96.12 35.35,35.98 ; J96.12 34.5,34 ; J96.12 33.65,34.28 ; J96.12 35.35,34.28 ; J96.12 35.63,35.13 ; J96.12 34.5,36.26 ; J96.12 33.65,35.98 ; J96.12 33.37,35.13 ; 5.74,11.07 MH6.1 ; MH6.1 9.24,11.07 ; MH6.1 5.74,7.57 ; MH6.1 5.09,9.32 ; MH6.1 9.89,9.32 ; MH6.1 7.49,11.72 ; MH6.1 9.24,7.57 ; MH6.1 7.49,6.92 ; J53.9 237.08,81.46 ; J53.9 236.02,80.39 ; J53.9 236.82,82.26 ; J53.9 235.21,80.65 ; J53.9 234.95,81.46 ; J53.9 235.21,82.26 ; J53.9 236.02,82.52 ; J53.9 236.82,80.65 ; 129.57,23.13 MH3.1 ; MH3.1 133.07,23.13 ; MH3.1 131.32,18.99 ; MH3.1 128.92,21.39 ; MH3.1 133.07,19.64 ; MH3.1 133.72,21.39 ; MH3.1 129.57,19.64 ; MH3.1 131.32,23.79 ; 232.97,41.37 J39.14 ; J39.14 232.16,43.25 ; J39.14 233.77,41.64 ; J39.14 234.03,42.44 ; J39.14 231.9,42.44 ; J39.14 232.97,43.51 ; J39.14 233.77,43.25 ; J39.14 232.16,41.64 ; 232.97,36.29 J39.10 ; J39.10 233.77,36.56 ; J39.10 233.77,38.17 ; J39.10 234.03,37.36 ; J39.10 231.9,37.36 ; J39.10 232.16,36.56 ; J39.10 232.16,38.17 ; J39.10 232.97,38.43 ; 25.5,59.58 25.5,60.71 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 24.65,61.56 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 24.65,59.86 ; 25.5,60.71 26.63,60.71 ; J82.2 11.88,105.4 ; J82.2 12.14,104.59 ; J82.2 11.07,103.53 ; J82.2 10.27,105.4 ; J82.2 10.27,103.79 ; J82.2 11.07,105.66 ; J82.2 11.88,103.79 ; J82.2 10.01,104.59 ; J1.3 55.74,49.86 ; J1.3 55.74,48.16 ; J1.3 56.02,49.01 ; J1.3 54.04,49.86 ; J1.3 54.89,50.14 ; J1.3 53.76,49.01 ; J1.3 54.89,47.88 ; J1.3 54.04,48.16 ; J1.4 50.83,41.71 ; J1.4 49.7,40.58 ; J1.4 50.55,40.86 ; J1.4 48.85,42.56 ; J1.4 48.57,41.71 ; J1.4 50.55,42.56 ; J1.4 49.7,42.84 ; J1.4 48.85,40.86 ; 27.9,67.15 J36.1 ; J36.1 27.9,65.54 ; J36.1 28.7,65.28 ; J36.1 29.51,65.54 ; J36.1 29.51,67.15 ; J36.1 28.7,67.41 ; J36.1 27.64,66.34 ; J36.1 29.77,66.34 ; MH1.1 236.22,173.01 ; MH1.1 236.22,168.21 ; MH1.1 234.47,172.36 ; MH1.1 237.97,172.36 ; MH1.1 234.47,168.86 ; MH1.1 237.97,168.86 ; MH1.1 238.62,170.61 ; MH1.1 233.82,170.61 ; J110.2 26.94,129.24 ; J110.2 26.94,127.11 ; J110.2 27.74,128.98 ; J110.2 26.13,127.37 ; J110.2 28,128.18 ; J110.2 25.87,128.18 ; J110.2 26.13,128.98 ; J110.2 27.74,127.37 ; MH4.1 7.86,146.11 ; MH4.1 7.21,144.37 ; MH4.1 5.46,143.71 ; MH4.1 3.71,147.86 ; MH4.1 7.21,147.86 ; MH4.1 3.71,144.37 ; MH4.1 3.06,146.11 ; MH4.1 5.46,148.51 ; 213.38,137.06 U16.5 ; U16.5 215.51,137.97 ; U16.5 214.59,138.28 ; U16.5 213.68,137.97 ; U16.5 215.51,136.15 ; U16.5 215.81,137.06 ; U16.5 213.68,136.15 ; U16.5 214.59,135.84 ; 222,61.21 J23.1 ; J23.1 222.8,61.48 ; J23.1 223.06,62.28 ; J23.1 220.93,62.28 ; J23.1 221.19,63.09 ; J23.1 222.8,63.09 ; J23.1 221.19,61.48 ; J23.1 222,63.35 ; 227.85,64.18 J52.9 ; J52.9 229.46,64.18 ; J52.9 228.65,63.92 ; J52.9 227.85,65.8 ; J52.9 228.65,66.06 ; J52.9 229.46,65.8 ; J52.9 227.58,64.99 ; J52.9 229.72,64.99 ; 232.97,38.83 J39.12 ; J39.12 232.16,39.1 ; J39.12 234.03,39.9 ; J39.12 233.77,40.71 ; J39.12 231.9,39.9 ; J39.12 232.97,40.97 ; J39.12 233.77,39.1 ; J39.12 232.16,40.71 ; 232.16,34.02 J39.8 ; J39.8 233.77,34.02 ; J39.8 232.97,35.89 ; J39.8 232.97,33.75 ; J39.8 231.9,34.82 ; J39.8 233.77,35.63 ; J39.8 234.03,34.82 ; J39.8 232.16,35.63 ; J1.12 35.63,60.71 ; J1.12 33.65,59.86 ; J1.12 35.35,61.56 ; J1.12 34.5,59.58 ; J1.12 34.5,61.84 ; J1.12 35.35,59.86 ; J1.12 33.37,60.71 ; J1.12 33.65,61.56 ; 24.65,35.98 25.5,35.13 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 24.65,34.28 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 25.5,34 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 26.35,34.28 ; J26.1 200.32,130.14 ; J26.1 198.71,130.14 ; J26.1 199.52,130.4 ; J26.1 198.71,128.53 ; J26.1 200.58,129.34 ; J26.1 199.52,128.27 ; J26.1 200.32,128.53 ; J26.1 198.45,129.34 ; MH2.1 120.37,135.84 ; MH2.1 118.62,135.19 ; MH2.1 116.87,139.34 ; MH2.1 118.62,139.99 ; MH2.1 116.87,135.84 ; MH2.1 116.22,137.59 ; MH2.1 120.37,139.34 ; MH2.1 121.02,137.59 ; J1.8 12,42.84 ; J1.8 11.15,42.56 ; J1.8 12,40.58 ; J1.8 10.87,41.71 ; J1.8 12.85,42.56 ; J1.8 12.85,40.86 ; J1.8 11.15,40.86 ; J1.8 13.13,41.71 ; J52.10 232,65.8 ; J52.10 230.39,65.8 ; J52.10 232,64.18 ; J52.10 230.12,64.99 ; J52.10 230.39,64.18 ; J52.10 231.19,63.92 ; J52.10 232.26,64.99 ; J52.10 231.19,66.06 ; 47.96,98.77 J27.1 ; J27.1 49.57,98.77 ; J27.1 47.96,97.16 ; J27.1 49.57,97.16 ; J27.1 49.83,97.97 ; J27.1 48.77,99.03 ; J27.1 48.77,96.9 ; J27.1 47.7,97.97 ; 38.15,15.28 J96.5 ; J96.5 40.13,16.13 ; J96.5 39.85,15.28 ; J96.5 37.87,16.13 ; J96.5 39,15 ; J5.3 199.05,16.35 ; J5.3 198.25,14.48 ; J5.3 197.44,16.35 ; J5.3 199.31,15.54 ; J5.3 199.05,14.74 ; J5.3 198.25,16.61 ; J5.3 197.44,14.74 ; J96.6 30,17.26 ; J96.6 29.15,16.98 ; J96.6 29.15,15.28 ; J96.6 31.13,16.13 ; J96.6 30,15 ; J96.6 30.85,15.28 ; J96.6 28.87,16.13 ; J96.6 30.85,16.98 ; 10.87,16.13 J96.8 ; J96.8 12.85,15.28 ; J96.8 11.15,15.28 ; J96.8 13.13,16.13 ; J96.8 12,17.26 ; J96.8 11.15,16.98 ; J96.8 12,15 ; J96.8 12.85,16.98 ; 237.49,81.46 J53.10 ; J53.10 237.75,82.26 ; J53.10 239.36,82.26 ; J53.10 239.36,80.65 ; J53.10 239.62,81.46 ; J53.10 237.75,80.65 ; J53.10 238.56,80.39 ; J53.10 238.56,82.52 ; 20.15,40.86 J1.7 ; J1.7 19.87,41.71 ; J1.7 20.15,42.56 ; J1.7 21.85,42.56 ; J1.7 21.85,40.86 ; J1.7 22.13,41.71 ; J1.7 21,42.84 ; J1.7 21,40.58 ; 211.18,135.47 U16.6 ; U16.6 213.31,134.56 ; U16.6 212.09,135.78 ; U16.6 212.09,133.34 ; U16.6 213.01,133.65 ; U16.6 211.18,133.65 ; U16.6 213.01,135.47 ; U16.6 210.88,134.56 ; J1.2 54.89,57.34 ; J1.2 55.74,57.06 ; J1.2 53.76,56.21 ; J1.2 55.74,55.36 ; J1.2 54.04,57.06 ; J1.2 54.04,55.36 ; J1.2 54.89,55.08 ; 199.21,35.61 J38.1 ; J38.1 201.08,34.81 ; J38.1 199.47,34.81 ; J38.1 200.28,34.54 ; J38.1 199.47,36.42 ; J38.1 201.35,35.61 ; J38.1 200.28,36.68 ; J38.1 201.08,36.42 ; U16.7 208.01,133.65 ; U16.7 207.09,133.34 ; U16.7 207.09,135.78 ; U16.7 208.31,134.56 ; U16.7 205.88,134.56 ; U16.7 208.01,135.47 ; U16.7 206.18,135.47 ; U16.7 206.18,133.65 ; 37.87,41.71 J1.5 ; J1.5 38.15,40.86 ; J1.5 39,40.58 ; J1.5 39.85,40.86 ; J1.5 40.13,41.71 ; J96.10 17.35,35.98 ; J96.10 17.63,35.13 ; J96.10 16.5,36.26 ; J96.10 15.65,35.98 ; J96.10 17.35,34.28 ; J96.10 16.5,34 ; J96.10 15.65,34.28 ; J96.10 15.37,35.13 ; 44.35,61.56 J1.1 ; J1.1 46.33,60.71 ; J1.1 46.05,61.56 ; J1.1 46.05,59.86 ; J1.1 45.2,59.58 ; J1.1 44.35,59.86 ; J1.1 44.07,60.71 ; J1.1 45.2,61.84 ; J39.16 232.97,46.05 ; J39.16 234.03,44.98 ; J39.16 232.16,45.79 ; J39.16 232.16,44.18 ; J39.16 232.97,43.91 ; J39.16 233.77,45.79 ; J39.16 233.77,44.18 ; J39.16 231.9,44.98 ; 24.17,89.52 J78.4 ; J78.4 25.78,89.52 ; J78.4 24.17,91.13 ; J78.4 24.97,91.39 ; J78.4 23.9,90.32 ; J78.4 25.78,91.13 ; J78.4 24.97,89.26 ; J78.4 26.04,90.32 ; J25.1 225.48,16.69 ; J25.1 223.6,17.49 ; J25.1 223.34,16.69 ; J25.1 225.21,15.88 ; J25.1 224.41,15.62 ; J25.1 225.21,17.49 ; J25.1 223.6,15.88 ; J25.1 224.41,17.75 ; MH7.1 9.24,92.97 ; MH7.1 7.49,92.32 ; MH7.1 5.74,92.97 ; MH7.1 5.74,96.46 ; MH7.1 9.24,96.46 ; MH7.1 7.49,97.12 ; MH7.1 5.09,94.72 ; MH7.1 9.89,94.72 ; C499.2 197.5,135.05 ; C499.2 197.24,135.86 ; C499.2 195.63,135.86 ; C499.2 197.24,134.25 ; C499.2 196.43,136.12 ; C499.2 196.43,133.98 ; C499.2 195.37,135.05 ; C499.2 195.63,134.25 ; 232.16,30.55 J39.4 ; J39.4 232.16,28.94 ; J39.4 233.77,30.55 ; J39.4 232.97,28.67 ; J39.4 234.03,29.74 ; J39.4 233.77,28.94 ; J39.4 231.9,29.74 ; J39.4 232.97,30.81 ; 54.04,24.28 J96.3 ; J96.3 55.74,24.28 ; J96.3 54.89,22.3 ; J96.3 55.74,22.58 ; J96.3 54.04,22.58 ; J96.3 53.76,23.43 ; J96.3 54.89,24.56 ; J96.3 56.02,23.43 ; 233.82,16.59 MH5.1 ; MH5.1 237.97,14.84 ; MH5.1 238.62,16.59 ; MH5.1 234.47,18.33 ; MH5.1 234.47,14.84 ; MH5.1 236.22,14.19 ; MH5.1 237.97,18.33 ; MH5.1 236.22,18.99 ; 27.04,172.45 J10.SH2 ; J10.SH2 30.32,173.84 ; J10.SH2 26.53,173.84
  02_GND w0.508: 61.49,107.85 J32.5 ; J32.5 61.49,110.49 ; J32.5 60.51,110.16 ; J32.5 60.51,108.19 ; J32.5 62.48,110.16 ; J32.5 60.17,109.17 ; J32.5 62.81,109.17 ; J32.5 62.48,108.19 ; J31.2 16.38,98.22 ; J31.2 15.39,98.56 ; J31.2 16.71,97.24 ; J31.2 16.38,96.25 ; J31.2 15.39,95.92 ; J31.2 14.41,96.25 ; J31.2 14.07,97.24 ; J31.2 14.41,98.22 ; 85.4,128.51 J34.4 ; J34.4 87.71,129.49 ; J34.4 87.37,128.51 ; J34.4 86.39,130.81 ; J34.4 87.37,130.48 ; J34.4 86.39,128.17 ; J34.4 85.4,130.48 ; J34.4 85.07,129.49 ; 68.38,128.51 J35.2 ; J35.2 69.37,128.17 ; J35.2 68.38,130.48 ; J35.2 70.35,128.51 ; J35.2 68.05,129.49 ; J35.2 70.35,130.48 ; J35.2 69.37,130.81 ; J35.2 70.69,129.49 ; J33.5 56.41,103.64 ; J33.5 56.41,101 ; J33.5 57.4,103.3 ; J33.5 55.43,101.33 ; J33.5 57.73,102.32 ; J33.5 57.4,101.33 ; J33.5 55.43,103.3 ; J33.5 55.09,102.32 ; J32.2 57.73,114.25 ; J32.2 56.41,112.93 ; J32.2 55.09,114.25 ; J32.2 55.43,115.24 ; J32.2 57.4,113.27 ; J32.2 55.43,113.27 ; J32.2 56.41,115.57 ; J32.2 57.4,115.24 ; J30.2 33.73,102.32 ; J30.2 33.4,101.33 ; J30.2 33.4,103.3 ; J30.2 31.09,102.32 ; J30.2 32.41,101 ; J30.2 32.41,103.64 ; J30.2 31.43,103.3 ; J30.2 31.43,101.33 ; J35.4 70.69,134.57 ; J35.4 68.38,133.59 ; J35.4 68.38,135.56 ; J35.4 69.37,133.25 ; J35.4 70.35,135.56 ; J35.4 70.35,133.59 ; J35.4 69.37,135.89 ; J35.4 68.05,134.57 ; J35.3 74.45,130.81 ; J35.3 75.43,130.48 ; J35.3 73.13,129.49 ; J35.3 74.45,128.17 ; J35.3 75.43,128.51 ; J35.3 73.46,130.48 ; J35.3 73.46,128.51 ; J35.3 75.77,129.49 ; J35.5 75.43,135.56 ; J35.5 74.45,133.25 ; J35.5 73.46,135.56 ; J35.5 73.13,134.57 ; J35.5 74.45,135.89 ; J35.5 75.43,133.59 ; J35.5 73.46,133.59 ; J35.5 75.77,134.57 ; J30.5 27.33,98.56 ; J30.5 26.35,96.25 ; J30.5 28.32,98.22 ; J30.5 26.35,98.22 ; J30.5 27.33,95.92 ; J30.5 28.32,96.25 ; J30.5 26.01,97.24 ; J30.5 28.65,97.24 ; 14.07,102.32 J31.4 ; J31.4 14.41,103.3 ; J31.4 16.38,103.3 ; J31.4 14.41,101.33 ; J31.4 15.39,103.64 ; J31.4 16.38,101.33 ; J31.4 16.71,102.32 ; J31.4 15.39,101 ; 55.43,110.16 J32.3 ; J32.3 57.73,109.17 ; J32.3 57.4,110.16 ; J32.3 56.41,110.49 ; J32.3 55.09,109.17 ; J32.3 57.4,108.19 ; J32.3 55.43,108.19 ; J32.3 56.41,107.85 ; J33.4 57.73,97.24 ; J33.4 56.41,98.56 ; J33.4 56.41,95.92 ; J33.4 57.4,98.22 ; J33.4 55.09,97.24 ; J33.4 57.4,96.25 ; J33.4 55.43,98.22 ; J33.4 55.43,96.25 ; J34.5 82.29,130.48 ; J34.5 81.31,128.17 ; J34.5 82.63,129.49 ; J34.5 81.31,130.81 ; J34.5 80.32,130.48 ; J34.5 82.29,128.51 ; J34.5 80.32,128.51 ; J34.5 79.99,129.49 ; 60.51,101.33 J33.3 ; J33.3 62.81,102.32 ; J33.3 61.49,101 ; J33.3 62.48,101.33 ; J33.3 61.49,103.64 ; J33.3 62.48,103.3 ; J33.3 60.51,103.3 ; J33.3 60.17,102.32 ; 60.17,97.24 J33.2 ; J33.2 62.48,96.25 ; J33.2 60.51,96.25 ; J33.2 61.49,95.92 ; J33.2 62.81,97.24 ; J33.2 60.51,98.22 ; J33.2 62.48,98.22 ; J33.2 61.49,98.56 ; 26.35,103.3 J30.3 ; J30.3 27.33,103.64 ; J30.3 28.32,101.33 ; J30.3 28.32,103.3 ; J30.3 26.01,102.32 ; J30.3 26.35,101.33 ; J30.3 27.33,101 ; J30.3 28.65,102.32 ; 85.4,133.59 J34.2 ; J34.2 86.39,135.89 ; J34.2 85.07,134.57 ; J34.2 87.71,134.57 ; J34.2 85.4,135.56 ; J34.2 87.37,135.56 ; J34.2 87.37,133.59 ; J34.2 86.39,133.25 ; 19.49,101.33 J31.5 ; J31.5 19.15,102.32 ; J31.5 19.49,103.3 ; J31.5 21.79,102.32 ; J31.5 20.47,103.64 ; J31.5 21.46,101.33 ; J31.5 21.46,103.3 ; J31.5 20.47,101 ; J31.3 21.79,97.24 ; J31.3 20.47,98.56 ; J31.3 19.49,98.22 ; J31.3 20.47,95.92 ; J31.3 21.46,98.22 ; J31.3 19.15,97.24 ; J31.3 21.46,96.25 ; J31.3 19.49,96.25 ; 81.31,133.25 J34.3 ; J34.3 82.29,135.56 ; J34.3 81.31,135.89 ; J34.3 80.32,135.56 ; J34.3 82.63,134.57 ; J34.3 80.32,133.59 ; J34.3 82.29,133.59 ; J34.3 79.99,134.57 ; 61.49,112.93 J32.4 ; J32.4 60.17,114.25 ; J32.4 61.49,115.57 ; J32.4 60.51,113.27 ; J32.4 62.48,113.27 ; J32.4 62.48,115.24 ; J32.4 60.51,115.24 ; J32.4 62.81,114.25 ; J30.4 33.73,97.24 ; J30.4 31.43,96.25 ; J30.4 33.4,96.25 ; J30.4 32.41,98.56 ; J30.4 31.43,98.22 ; J30.4 32.41,95.92 ; J30.4 33.4,98.22 ; J30.4 31.09,97.24
  03_SIG1 w0.381: 9.35,39.06 J1.8 ; J1.8 8.33,41.71 ; J1.8 12,45.38 ; J1.8 9.35,44.35 ; J1.8 14.65,44.35 ; J1.8 15.67,41.71 ; J1.8 12,38.04 ; J1.8 14.65,39.06 ; J96.9 10.15,37.78 ; J96.9 7.5,38.8 ; J96.9 11.17,35.13 ; J96.9 4.85,37.78 ; J96.9 10.15,32.49 ; J96.9 7.5,31.46 ; J96.9 3.83,35.13 ; J96.9 4.85,32.49 ; 16.5,57.04 J1.10 ; J1.10 13.85,58.06 ; J1.10 19.15,58.06 ; J1.10 12.83,60.71 ; 16.5,31.46 J96.10 ; J96.10 16.5,38.8 ; J96.10 12.83,35.13 ; J96.10 19.15,37.78 ; J96.10 13.85,32.49 ; J96.10 20.17,35.13 ; J96.10 13.85,37.78 ; J96.10 19.15,32.49 ; 21.83,35.13 25.5,35.13 ; 25.5,35.13 28.15,37.78 ; 25.5,35.13 25.5,38.8 ; 25.5,35.13 25.5,31.46 ; 25.5,35.13 22.85,32.49 ; 25.5,35.13 28.15,32.49 ; 25.5,35.13 22.85,37.78 ; 4.85,63.35 J1.9 ; J1.9 7.5,57.04 ; J1.9 10.15,58.06 ; J1.9 4.85,58.06 ; J1.9 11.17,60.71 ; J1.9 3.83,60.71 ; 36.35,13.49 J96.5 ; J96.5 41.65,13.49 ; J96.5 39,12.46 ; J96.5 35.33,16.13 ; 27.35,18.78 J96.6 ; J96.6 30,19.8 ; J96.6 26.33,16.13 ; J96.6 33.67,16.13 ; J96.6 32.65,18.78 ; 7.49,89.78 MH7.1 ; MH7.1 3.95,91.17 ; MH7.1 2.55,94.72 ; MH7.1 3.95,98.26 ; MH7.1 11.04,91.17 ; MH5.1 239.76,20.13 ; MH5.1 231.28,16.59 ; MH5.1 232.68,20.13 ; MH5.1 236.22,21.53 ; J1.7 21,45.38 ; J1.7 18.35,44.35 ; J1.7 21,38.04 ; J1.7 23.65,44.35 ; J1.7 17.33,41.71 ; J1.7 24.67,41.71 ; J1.7 23.65,39.06 ; J1.7 18.35,39.06 ; 197.68,38.21 J38.1 200.28,39.22 ; J25.1 228.02,16.69 ; J25.1 227.01,14.09 ; J25.1 227.01,19.29 ; J25.1 224.41,20.29 ; MH6.1 11.04,5.78 ; MH6.1 2.55,9.32 ; MH6.1 3.95,12.87 ; MH6.1 3.95,5.78 ; MH6.1 7.49,14.26 ; MH6.1 12.43,9.32 ; 25.24,170.65 J10.SH2 23.99,173.84 ; 27.35,39.06 J1.6 ; J1.6 26.33,41.71 ; J1.6 27.35,44.35 ; 8.33,16.13 J96.8 ; J96.8 15.67,16.13 ; J96.8 12,12.46 ; J96.8 9.35,18.78 ; J96.8 14.65,18.78 ; J96.8 12,19.8 ; J96.7 24.67,16.13 ; J96.7 17.33,16.13 ; J96.7 21,19.8 ; J96.7 18.35,18.78 ; J96.7 23.65,18.78 ; 25.5,57.04 25.5,60.71 22.85,58.06 ; 232.68,174.16 MH1.1 239.76,174.16
  04_GND w0.381: J25.1 225.21,15.88 ; J25.1 225.48,16.69 ; J25.1 224.41,15.62 ; J25.1 223.34,16.69 ; J25.1 223.6,15.88 ; J25.1 223.6,17.49 ; J25.1 225.21,17.49 ; J25.1 224.41,17.75 ; J1.8 12.85,42.56 ; J1.8 12,42.84 ; J1.8 11.15,40.86 ; J1.8 12,40.58 ; J1.8 13.13,41.71 ; J1.8 10.87,41.71 ; J1.8 11.15,42.56 ; J1.8 12.85,40.86 ; J38.1 201.35,35.61 ; J38.1 199.47,36.42 ; J38.1 201.08,36.42 ; J38.1 199.47,34.81 ; J38.1 200.28,36.68 ; J38.1 200.28,34.54 ; J38.1 199.21,35.61 ; J38.1 201.08,34.81 ; J39.4 233.77,30.55 ; J39.4 232.16,30.55 ; J39.4 232.16,28.94 ; J39.4 231.9,29.74 ; J39.4 232.97,28.67 ; J39.4 233.77,28.94 ; J39.4 234.03,29.74 ; J39.4 232.97,30.81 ; J96.7 21.85,16.98 ; J96.7 20.15,16.98 ; J96.7 21,17.26 ; J96.7 19.87,16.13 ; J96.7 20.15,15.28 ; J96.7 21,15 ; J96.7 21.85,15.28 ; J96.7 22.13,16.13 ; 10.27,103.79 J82.2 ; J82.2 12.14,104.59 ; J82.2 11.88,105.4 ; J82.2 10.01,104.59 ; J82.2 11.88,103.79 ; J82.2 10.27,105.4 ; J82.2 11.07,105.66 ; J82.2 11.07,103.53 ; 44.35,59.86 J1.1 ; J1.1 46.05,59.86 ; J1.1 45.2,59.58 ; J1.1 46.05,61.56 ; J1.1 45.2,61.84 ; J1.1 44.07,60.71 ; J1.1 46.33,60.71 ; J1.1 44.35,61.56 ; 54.04,22.58 J96.3 ; J96.3 54.89,24.56 ; J96.3 54.04,24.28 ; J96.3 54.89,22.3 ; J96.3 55.74,24.28 ; J96.3 53.76,23.43 ; J96.3 55.74,22.58 ; J96.3 56.02,23.43 ; 214.59,135.84 U16.5 ; U16.5 215.51,136.15 ; U16.5 214.59,138.28 ; U16.5 215.51,137.97 ; U16.5 213.38,137.06 ; U16.5 213.68,137.97 ; U16.5 213.68,136.15 ; U16.5 215.81,137.06 ; 195.63,134.25 C499.2 ; C499.2 195.37,135.05 ; C499.2 197.24,135.86 ; C499.2 197.5,135.05 ; C499.2 197.24,134.25 ; C499.2 195.63,135.86 ; C499.2 196.43,133.98 ; C499.2 196.43,136.12 ; 221.19,63.09 J23.1 ; J23.1 223.06,62.28 ; J23.1 221.19,61.48 ; J23.1 220.93,62.28 ; J23.1 222,63.35 ; J23.1 222.8,61.48 ; J23.1 222,61.21 ; J23.1 222.8,63.09 ; MH6.1 9.24,11.07 ; MH6.1 7.49,11.72 ; MH6.1 9.89,9.32 ; MH6.1 5.74,11.07 ; MH6.1 5.09,9.32 ; MH6.1 5.74,7.57 ; MH6.1 7.49,6.92 ; MH6.1 9.24,7.57 ; J1.6 30,42.84 ; J1.6 30.85,42.56 ; J1.6 28.87,41.71 ; J1.6 29.15,40.86 ; J1.6 31.13,41.71 ; J1.6 30.85,40.86 ; J1.6 29.15,42.56 ; J1.6 30,40.58 ; J52.10 232.26,64.99 ; J52.10 231.19,66.06 ; J52.10 232,65.8 ; J52.10 231.19,63.92 ; J52.10 230.39,65.8 ; J52.10 230.12,64.99 ; J52.10 232,64.18 ; J52.10 230.39,64.18 ; 24.65,34.28 25.5,35.13 ; 25.5,35.13 25.5,34 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 24.65,35.98 ; J39.6 234.03,32.28 ; J39.6 232.16,33.09 ; J39.6 232.97,31.21 ; J39.6 232.97,33.35 ; J39.6 232.16,31.48 ; J39.6 233.77,31.48 ; J39.6 233.77,33.09 ; J39.6 231.9,32.28 ; 48.85,16.98 J96.4 ; J96.4 48.85,15.28 ; J96.4 50.83,16.13 ; J96.4 49.7,15 ; J96.4 49.7,17.26 ; J96.4 50.55,15.28 ; J96.4 50.55,16.98 ; J96.4 48.57,16.13 ; J36.1 29.77,66.34 ; J36.1 27.9,67.15 ; J36.1 29.51,67.15 ; J36.1 28.7,65.28 ; J36.1 27.64,66.34 ; J36.1 29.51,65.54 ; J36.1 27.9,65.54 ; J36.1 28.7,67.41 ; 26.94,127.11 J110.2 ; J110.2 26.13,127.37 ; J110.2 26.13,128.98 ; J110.2 28,128.18 ; J110.2 27.74,127.37 ; J110.2 25.87,128.18 ; J110.2 26.94,129.24 ; J110.2 27.74,128.98 ; 212.09,133.34 U16.6 ; U16.6 211.18,133.65 ; U16.6 210.88,134.56 ; U16.6 213.01,133.65 ; U16.6 213.31,134.56 ; U16.6 212.09,135.78 ; U16.6 213.01,135.47 ; U16.6 211.18,135.47 ; J105.6 103.87,129.95 ; J105.6 104.13,129.14 ; J105.6 102.26,129.95 ; J105.6 103.87,128.34 ; J105.6 102.26,128.34 ; J105.6 103.07,130.21 ; J105.6 102,129.14 ; J105.6 103.07,128.07 ; 131.32,18.99 MH3.1 ; MH3.1 128.92,21.39 ; MH3.1 133.07,23.13 ; MH3.1 129.57,19.64 ; MH3.1 133.07,19.64 ; MH3.1 133.72,21.39 ; MH3.1 131.32,23.79 ; MH3.1 129.57,23.13 ; J1.7 21.85,42.56 ; J1.7 20.15,42.56 ; J1.7 21,40.58 ; J1.7 20.15,40.86 ; J1.7 22.13,41.71 ; J1.7 19.87,41.71 ; J1.7 21.85,40.86 ; J1.7 21,42.84 ; 236.22,14.19 MH5.1 ; MH5.1 236.22,18.99 ; MH5.1 233.82,16.59 ; MH5.1 237.97,18.33 ; MH5.1 237.97,14.84 ; MH5.1 234.47,18.33 ; MH5.1 234.47,14.84 ; MH5.1 238.62,16.59 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 25.5,59.58 ; 25.5,60.71 24.65,61.56 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 24.65,59.86 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 24.37,60.71 ; 207.09,133.34 U16.7 ; U16.7 205.88,134.56 ; U16.7 208.31,134.56 ; U16.7 206.18,135.47 ; U16.7 208.01,135.47 ; U16.7 208.01,133.65 ; U16.7 206.18,133.65 ; U16.7 207.09,135.78 ; J96.9 8.35,35.98 ; J96.9 8.63,35.13 ; J96.9 6.37,35.13 ; J96.9 7.5,36.26 ; J96.9 7.5,34 ; J96.9 8.35,34.28 ; J96.9 6.65,35.98 ; J96.9 6.65,34.28 ; J96.8 12,17.26 ; J96.8 12.85,15.28 ; J96.8 12,15 ; J96.8 11.15,16.98 ; J96.8 11.15,15.28 ; J96.8 10.87,16.13 ; J96.8 12.85,16.98 ; J96.8 13.13,16.13 ; 54.04,57.06 J1.2 ; J1.2 54.04,55.36 ; J1.2 55.74,57.06 ; J1.2 55.74,55.36 ; J1.2 54.89,57.34 ; J1.2 54.89,55.08 ; J1.2 53.76,56.21 ; 5.09,94.72 MH7.1 ; MH7.1 7.49,97.12 ; MH7.1 9.24,96.46 ; MH7.1 7.49,92.32 ; MH7.1 5.74,92.97 ; MH7.1 5.74,96.46 ; MH7.1 9.89,94.72 ; MH7.1 9.24,92.97 ; J39.10 232.97,38.43 ; J39.10 233.77,38.17 ; J39.10 232.16,36.56 ; J39.10 234.03,37.36 ; J39.10 232.97,36.29 ; J39.10 231.9,37.36 ; J39.10 233.77,36.56 ; J39.10 232.16,38.17 ; J39.14 232.97,43.51 ; J39.14 233.77,43.25 ; J39.14 233.77,41.64 ; J39.14 231.9,42.44 ; J39.14 232.16,41.64 ; J39.14 232.16,43.25 ; J39.14 234.03,42.44 ; J39.14 232.97,41.37 ; 44.35,35.98 J96.1 ; J96.1 44.07,35.13 ; J96.1 45.2,36.26 ; J96.1 46.05,35.98 ; J96.1 45.2,34 ; J96.1 46.33,35.13 ; J96.1 44.35,34.28 ; J96.1 46.05,34.28 ; J1.4 49.7,42.84 ; J1.4 50.83,41.71 ; J1.4 49.7,40.58 ; J1.4 50.55,40.86 ; J1.4 48.57,41.71 ; J1.4 50.55,42.56 ; J1.4 48.85,40.86 ; J1.4 48.85,42.56 ; J39.8 234.03,34.82 ; J39.8 233.77,34.02 ; J39.8 232.16,35.63 ; J39.8 233.77,35.63 ; J39.8 232.97,35.89 ; J39.8 231.9,34.82 ; J39.8 232.97,33.75 ; J39.8 232.16,34.02 ; J96.12 35.35,34.28 ; J96.12 33.65,35.98 ; J96.12 35.63,35.13 ; J96.12 33.37,35.13 ; J96.12 34.5,36.26 ; J96.12 34.5,34 ; J96.12 35.35,35.98 ; J96.12 33.65,34.28 ; MH4.1 7.21,147.86 ; MH4.1 3.71,147.86 ; MH4.1 3.71,144.37 ; MH4.1 7.86,146.11 ; MH4.1 5.46,148.51 ; MH4.1 3.06,146.11 ; MH4.1 5.46,143.71 ; MH4.1 7.21,144.37 ; 23.9,90.32 J78.4 ; J78.4 24.17,91.13 ; J78.4 24.17,89.52 ; J78.4 24.97,91.39 ; J78.4 25.78,91.13 ; J78.4 24.97,89.26 ; J78.4 25.78,89.52 ; J78.4 26.04,90.32 ; 54.04,48.16 J1.3 ; J1.3 55.74,48.16 ; J1.3 54.89,47.88 ; J1.3 54.89,50.14 ; J1.3 56.02,49.01 ; J1.3 55.74,49.86 ; J1.3 54.04,49.86 ; J1.3 53.76,49.01 ; J39.16 232.97,46.05 ; J39.16 233.77,45.79 ; J39.16 231.9,44.98 ; J39.16 233.77,44.18 ; J39.16 234.03,44.98 ; J39.16 232.97,43.91 ; J39.16 232.16,45.79 ; J39.16 232.16,44.18 ; 53.76,30.63 J96.2 ; J96.2 54.89,31.76 ; J96.2 56.02,30.63 ; J96.2 55.74,31.48 ; J96.2 54.04,31.48 ; J96.2 54.04,29.78 ; J96.2 55.74,29.78 ; J96.2 54.89,29.5 ; J96.6 30.85,15.28 ; J96.6 30,15 ; J96.6 28.87,16.13 ; J96.6 29.15,15.28 ; J96.6 30,17.26 ; J96.6 31.13,16.13 ; J96.6 30.85,16.98 ; J96.6 29.15,16.98 ; 198.45,129.34 J26.1 ; J26.1 199.52,130.4 ; J26.1 200.58,129.34 ; J26.1 199.52,128.27 ; J26.1 200.32,128.53 ; J26.1 200.32,130.14 ; J26.1 198.71,128.53 ; J26.1 198.71,130.14 ; 38.15,40.86 J1.5 ; J1.5 39,40.58 ; J1.5 40.13,41.71 ; J1.5 39.85,40.86 ; J1.5 37.87,41.71 ; 237.49,81.46 J53.10 ; J53.10 237.75,80.65 ; J53.10 237.75,82.26 ; J53.10 239.36,82.26 ; J53.10 238.56,80.39 ; J53.10 239.36,80.65 ; J53.10 239.62,81.46 ; J53.10 238.56,82.52 ; J53.9 236.82,80.65 ; J53.9 236.82,82.26 ; J53.9 235.21,82.26 ; J53.9 236.02,80.39 ; J53.9 236.02,82.52 ; J53.9 235.21,80.65 ; J53.9 234.95,81.46 ; J53.9 237.08,81.46 ; 197.44,14.74 J5.3 ; J5.3 198.25,14.48 ; J5.3 197.44,16.35 ; J5.3 198.25,16.61 ; J5.3 199.05,14.74 ; J5.3 199.31,15.54 ; J5.3 199.05,16.35 ; MH2.1 118.62,139.99 ; MH2.1 120.37,135.84 ; MH2.1 116.87,135.84 ; MH2.1 116.87,139.34 ; MH2.1 121.02,137.59 ; MH2.1 116.22,137.59 ; MH2.1 118.62,135.19 ; MH2.1 120.37,139.34 ; J24.1 173.78,145.25 ; J24.1 171.91,144.45 ; J24.1 172.17,143.64 ; J24.1 173.78,143.64 ; J24.1 172.17,145.25 ; J24.1 172.97,143.38 ; J24.1 174.04,144.45 ; J24.1 172.97,145.52 ; 16.5,34 J96.10 ; J96.10 15.65,35.98 ; J96.10 17.35,34.28 ; J96.10 17.63,35.13 ; J96.10 17.35,35.98 ; J96.10 15.37,35.13 ; J96.10 15.65,34.28 ; J96.10 16.5,36.26 ; 15.65,59.86 J1.10 ; J1.10 17.35,59.86 ; J1.10 17.63,60.71 ; J1.10 16.5,59.58 ; J1.10 15.65,61.56 ; J1.10 15.37,60.71 ; J1.10 17.35,61.56 ; J1.10 16.5,61.84 ; J10.SH1 46.67,173.84 ; J10.SH1 46.17,172.45 ; J10.SH1 42.88,173.84 ; J52.9 228.65,66.06 ; J52.9 229.46,65.8 ; J52.9 227.58,64.99 ; J52.9 229.46,64.18 ; J52.9 228.65,63.92 ; J52.9 227.85,65.8 ; J52.9 227.85,64.18 ; J52.9 229.72,64.99 ; 234.47,168.86 MH1.1 ; MH1.1 234.47,172.36 ; MH1.1 238.62,170.61 ; MH1.1 237.97,172.36 ; MH1.1 236.22,168.21 ; MH1.1 236.22,173.01 ; MH1.1 237.97,168.86 ; MH1.1 233.82,170.61 ; J27.1 49.57,97.16 ; J27.1 47.7,97.97 ; J27.1 48.77,96.9 ; J27.1 48.77,99.03 ; J27.1 47.96,98.77 ; J27.1 47.96,97.16 ; J27.1 49.57,98.77 ; J27.1 49.83,97.97 ; J1.12 35.35,59.86 ; J1.12 33.65,59.86 ; J1.12 34.5,61.84 ; J1.12 33.65,61.56 ; J1.12 35.63,60.71 ; J1.12 34.5,59.58 ; J1.12 35.35,61.56 ; J1.12 33.37,60.71 ; 26.53,173.84 J10.SH2 ; J10.SH2 27.04,172.45 ; J10.SH2 30.32,173.84 ; J39.12 233.77,39.1 ; J39.12 231.9,39.9 ; J39.12 232.16,39.1 ; J39.12 234.03,39.9 ; J39.12 233.77,40.71 ; J39.12 232.97,40.97 ; J39.12 232.97,38.83 ; J39.12 232.16,40.71 ; 39,15 J96.5 ; J96.5 38.15,15.28 ; J96.5 40.13,16.13 ; J96.5 39.85,15.28 ; J96.5 37.87,16.13 ; J1.9 7.5,61.84 ; J1.9 8.63,60.71 ; J1.9 7.5,59.58 ; J1.9 6.37,60.71 ; J1.9 6.65,59.86 ; J1.9 6.65,61.56 ; J1.9 8.35,61.56 ; J1.9 8.35,59.86
  04_GND w0.508: 55.43,96.25 J33.4 ; J33.4 56.41,95.92 ; J33.4 57.4,96.25 ; J33.4 56.41,98.56 ; J33.4 57.73,97.24 ; J33.4 57.4,98.22 ; J33.4 55.43,98.22 ; J33.4 55.09,97.24 ; 61.49,101 J33.3 ; J33.3 60.51,103.3 ; J33.3 61.49,103.64 ; J33.3 62.48,103.3 ; J33.3 60.51,101.33 ; J33.3 62.48,101.33 ; J33.3 62.81,102.32 ; J33.3 60.17,102.32 ; 73.46,130.48 J35.3 ; J35.3 73.13,129.49 ; J35.3 74.45,130.81 ; J35.3 73.46,128.51 ; J35.3 75.43,128.51 ; J35.3 74.45,128.17 ; J35.3 75.77,129.49 ; J35.3 75.43,130.48 ; J33.5 57.4,101.33 ; J33.5 55.43,103.3 ; J33.5 57.4,103.3 ; J33.5 55.43,101.33 ; J33.5 55.09,102.32 ; J33.5 56.41,101 ; J33.5 56.41,103.64 ; J33.5 57.73,102.32 ; 27.33,101 J30.3 ; J30.3 26.35,101.33 ; J30.3 27.33,103.64 ; J30.3 28.65,102.32 ; J30.3 28.32,101.33 ; J30.3 26.35,103.3 ; J30.3 28.32,103.3 ; J30.3 26.01,102.32 ; 20.47,95.92 J31.3 ; J31.3 21.46,96.25 ; J31.3 21.46,98.22 ; J31.3 19.49,96.25 ; J31.3 20.47,98.56 ; J31.3 21.79,97.24 ; J31.3 19.15,97.24 ; J31.3 19.49,98.22 ; J32.3 57.4,110.16 ; J32.3 55.43,110.16 ; J32.3 56.41,110.49 ; J32.3 55.43,108.19 ; J32.3 57.4,108.19 ; J32.3 55.09,109.17 ; J32.3 56.41,107.85 ; J32.3 57.73,109.17 ; J32.5 62.81,109.17 ; J32.5 61.49,107.85 ; J32.5 62.48,110.16 ; J32.5 62.48,108.19 ; J32.5 60.51,110.16 ; J32.5 61.49,110.49 ; J32.5 60.17,109.17 ; J32.5 60.51,108.19 ; 31.43,98.22 J30.4 ; J30.4 32.41,98.56 ; J30.4 33.73,97.24 ; J30.4 32.41,95.92 ; J30.4 33.4,98.22 ; J30.4 31.09,97.24 ; J30.4 31.43,96.25 ; J30.4 33.4,96.25 ; 19.49,103.3 J31.5 ; J31.5 21.46,101.33 ; J31.5 19.15,102.32 ; J31.5 21.46,103.3 ; J31.5 20.47,101 ; J31.5 19.49,101.33 ; J31.5 20.47,103.64 ; J31.5 21.79,102.32 ; 27.33,95.92 J30.5 ; J30.5 26.01,97.24 ; J30.5 28.65,97.24 ; J30.5 28.32,96.25 ; J30.5 26.35,98.22 ; J30.5 28.32,98.22 ; J30.5 26.35,96.25 ; J30.5 27.33,98.56 ; J34.5 82.29,130.48 ; J34.5 82.29,128.51 ; J34.5 80.32,128.51 ; J34.5 80.32,130.48 ; J34.5 81.31,128.17 ; J34.5 81.31,130.81 ; J34.5 82.63,129.49 ; J34.5 79.99,129.49 ; J33.2 62.81,97.24 ; J33.2 60.51,96.25 ; J33.2 61.49,95.92 ; J33.2 60.51,98.22 ; J33.2 62.48,98.22 ; J33.2 62.48,96.25 ; J33.2 61.49,98.56 ; J33.2 60.17,97.24 ; 69.37,128.17 J35.2 ; J35.2 70.69,129.49 ; J35.2 68.05,129.49 ; J35.2 70.35,130.48 ; J35.2 68.38,130.48 ; J35.2 69.37,130.81 ; J35.2 68.38,128.51 ; J35.2 70.35,128.51 ; J30.2 33.4,101.33 ; J30.2 31.43,101.33 ; J30.2 31.09,102.32 ; J30.2 32.41,101 ; J30.2 33.73,102.32 ; J30.2 32.41,103.64 ; J30.2 33.4,103.3 ; J30.2 31.43,103.3 ; 14.41,98.22 J31.2 ; J31.2 16.38,98.22 ; J31.2 15.39,98.56 ; J31.2 14.41,96.25 ; J31.2 15.39,95.92 ; J31.2 16.71,97.24 ; J31.2 16.38,96.25 ; J31.2 14.07,97.24 ; J34.2 86.39,135.89 ; J34.2 87.71,134.57 ; J34.2 85.07,134.57 ; J34.2 85.4,135.56 ; J34.2 86.39,133.25 ; J34.2 87.37,133.59 ; J34.2 87.37,135.56 ; J34.2 85.4,133.59 ; J34.4 86.39,130.81 ; J34.4 87.37,130.48 ; J34.4 85.4,128.51 ; J34.4 85.07,129.49 ; J34.4 85.4,130.48 ; J34.4 86.39,128.17 ; J34.4 87.71,129.49 ; J34.4 87.37,128.51 ; J32.4 62.81,114.25 ; J32.4 62.48,113.27 ; J32.4 61.49,115.57 ; J32.4 60.17,114.25 ; J32.4 60.51,113.27 ; J32.4 62.48,115.24 ; J32.4 60.51,115.24 ; J32.4 61.49,112.93 ; 81.31,133.25 J34.3 ; J34.3 82.29,133.59 ; J34.3 82.63,134.57 ; J34.3 80.32,135.56 ; J34.3 81.31,135.89 ; J34.3 80.32,133.59 ; J34.3 79.99,134.57 ; J34.3 82.29,135.56 ; 74.45,133.25 J35.5 ; J35.5 75.77,134.57 ; J35.5 74.45,135.89 ; J35.5 75.43,135.56 ; J35.5 73.46,133.59 ; J35.5 75.43,133.59 ; J35.5 73.46,135.56 ; J35.5 73.13,134.57 ; 14.41,103.3 J31.4 ; J31.4 16.38,101.33 ; J31.4 14.41,101.33 ; J31.4 16.38,103.3 ; J31.4 16.71,102.32 ; J31.4 15.39,101 ; J31.4 14.07,102.32 ; J31.4 15.39,103.64 ; J32.2 57.73,114.25 ; J32.2 57.4,113.27 ; J32.2 57.4,115.24 ; J32.2 55.43,113.27 ; J32.2 55.09,114.25 ; J32.2 55.43,115.24 ; J32.2 56.41,112.93 ; J32.2 56.41,115.57 ; J35.4 70.35,135.56 ; J35.4 68.38,133.59 ; J35.4 68.38,135.56 ; J35.4 70.69,134.57 ; J35.4 70.35,133.59 ; J35.4 68.05,134.57 ; J35.4 69.37,133.25 ; J35.4 69.37,135.89
  05_SIG2 w0.381: 9.35,39.06 J1.8 ; J1.8 8.33,41.71 ; J1.8 15.67,41.71 ; J1.8 9.35,44.35 ; J1.8 12,45.38 ; J1.8 12,38.04 ; J1.8 14.65,39.06 ; J1.8 14.65,44.35 ; 3.95,12.87 MH6.1 ; MH6.1 11.04,5.78 ; MH6.1 12.43,9.32 ; MH6.1 2.55,9.32 ; MH6.1 3.95,5.78 ; MH6.1 7.49,14.26 ; 26.33,41.71 J1.6 ; J1.6 30,45.38 ; J1.6 32.65,39.06 ; J1.6 27.35,44.35 ; J1.6 27.35,39.06 ; J1.6 33.67,41.71 ; J1.6 32.65,44.35 ; J1.6 30,38.04 ; 13.85,32.49 J96.10 ; J96.10 16.5,38.8 ; J96.10 19.15,37.78 ; J96.10 20.17,35.13 ; J96.10 12.83,35.13 ; J96.10 16.5,31.46 ; J96.10 19.15,32.49 ; J96.10 13.85,37.78 ; 22.85,32.49 25.5,35.13 ; 25.5,35.13 28.15,32.49 ; 25.5,35.13 25.5,31.46 ; 25.5,35.13 28.15,37.78 ; 25.5,35.13 21.83,35.13 ; 25.5,35.13 22.85,37.78 ; 25.5,35.13 25.5,38.8 ; 25.5,35.13 29.17,35.13 ; J96.9 10.15,32.49 ; J96.9 4.85,37.78 ; J96.9 10.15,37.78 ; J96.9 3.83,35.13 ; J96.9 4.85,32.49 ; J96.9 7.5,38.8 ; J96.9 11.17,35.13 ; J96.9 7.5,31.46 ; 4.85,63.35 J1.9 ; J1.9 10.15,58.06 ; J1.9 3.83,60.71 ; J1.9 7.5,57.04 ; J1.9 11.17,60.71 ; J1.9 4.85,58.06 ; 52.37,97.97 J27.1 46.17,100.57 ; 30.83,35.13 J96.12 ; J96.12 31.85,37.78 ; J96.12 37.15,32.49 ; J96.12 31.85,32.49 ; J96.12 34.5,31.46 ; 49.7,38.04 J1.4 47.05,39.06 ; 16.5,57.04 J1.10 ; J1.10 12.83,60.71 ; J1.10 13.85,58.06 ; J1.10 19.15,58.06 ; J25.1 224.41,20.29 ; J25.1 227.01,19.29 ; J25.1 227.01,14.09 ; J25.1 228.02,16.69 ; 25.5,60.71 29.17,60.71 ; 25.5,60.71 25.5,57.04 ; 25.5,60.71 22.85,58.06 ; 25.5,60.71 28.15,58.06 ; J96.6 32.65,18.78 ; J96.6 27.35,18.78 ; J96.6 30,19.8 ; J96.6 26.33,16.13 ; J96.6 33.67,16.13 ; 239.76,174.16 MH1.1 232.68,174.16 ; 231.28,16.59 MH5.1 ; MH5.1 232.68,20.13 ; MH5.1 236.22,21.53 ; MH5.1 239.76,20.13 ; 3.95,98.26 MH7.1 ; MH7.1 7.49,89.78 ; MH7.1 3.95,91.17 ; MH7.1 2.55,94.72 ; J96.7 24.67,16.13 ; J96.7 18.35,18.78 ; J96.7 23.65,18.78 ; J96.7 21,19.8 ; J96.7 17.33,16.13 ; 35.33,16.13 J96.5 ; J96.5 41.65,13.49 ; J96.5 39,12.46 ; J96.5 36.35,13.49 ; J96.8 14.65,18.78 ; J96.8 9.35,18.78 ; J96.8 8.33,16.13 ; J96.8 12,12.46 ; J96.8 15.67,16.13 ; J96.8 12,19.8 ; J1.7 23.65,44.35 ; J1.7 18.35,39.06 ; J1.7 23.65,39.06 ; J1.7 18.35,44.35 ; J1.7 24.67,41.71 ; J1.7 17.33,41.71 ; J1.7 21,38.04 ; J1.7 21,45.38 ; 31.85,58.06 J1.12 ; J1.12 30.83,60.71 ; J1.12 34.5,57.04 ; 23.99,173.84 J10.SH2 25.24,170.65 ; 48.87,35.13 J96.1 47.85,37.78
  06_GND w0.381: J1.1 45.2,61.84 ; J1.1 44.35,59.86 ; J1.1 46.05,61.56 ; J1.1 45.2,59.58 ; J1.1 44.07,60.71 ; J1.1 44.35,61.56 ; J1.1 46.05,59.86 ; J1.1 46.33,60.71 ; MH6.1 7.49,11.72 ; MH6.1 5.74,11.07 ; MH6.1 9.24,7.57 ; MH6.1 9.89,9.32 ; MH6.1 5.09,9.32 ; MH6.1 7.49,6.92 ; MH6.1 9.24,11.07 ; MH6.1 5.74,7.57 ; J39.14 233.77,41.64 ; J39.14 232.97,43.51 ; J39.14 232.16,41.64 ; J39.14 233.77,43.25 ; J39.14 232.97,41.37 ; J39.14 231.9,42.44 ; J39.14 232.16,43.25 ; J39.14 234.03,42.44 ; 24.65,61.56 25.5,60.71 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 25.5,59.58 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 24.65,59.86 ; J1.4 49.7,42.84 ; J1.4 50.83,41.71 ; J1.4 49.7,40.58 ; J1.4 50.55,42.56 ; J1.4 48.85,42.56 ; J1.4 48.85,40.86 ; J1.4 48.57,41.71 ; J1.4 50.55,40.86 ; U16.5 215.51,137.97 ; U16.5 214.59,135.84 ; U16.5 213.68,137.97 ; U16.5 215.51,136.15 ; U16.5 215.81,137.06 ; U16.5 213.68,136.15 ; U16.5 213.38,137.06 ; U16.5 214.59,138.28 ; C499.2 197.5,135.05 ; C499.2 195.37,135.05 ; C499.2 197.24,134.25 ; C499.2 195.63,135.86 ; C499.2 195.63,134.25 ; C499.2 197.24,135.86 ; C499.2 196.43,133.98 ; C499.2 196.43,136.12 ; J96.12 35.35,34.28 ; J96.12 35.63,35.13 ; J96.12 33.65,34.28 ; J96.12 33.65,35.98 ; J96.12 34.5,36.26 ; J96.12 33.37,35.13 ; J96.12 34.5,34 ; J96.12 35.35,35.98 ; 235.21,80.65 J53.9 ; J53.9 237.08,81.46 ; J53.9 236.02,80.39 ; J53.9 235.21,82.26 ; J53.9 236.82,80.65 ; J53.9 234.95,81.46 ; J53.9 236.82,82.26 ; J53.9 236.02,82.52 ; 10.27,105.4 J82.2 ; J82.2 10.27,103.79 ; J82.2 11.88,103.79 ; J82.2 12.14,104.59 ; J82.2 11.07,103.53 ; J82.2 11.07,105.66 ; J82.2 11.88,105.4 ; J82.2 10.01,104.59 ; 237.75,80.65 J53.10 ; J53.10 238.56,82.52 ; J53.10 238.56,80.39 ; J53.10 237.49,81.46 ; J53.10 237.75,82.26 ; J53.10 239.36,82.26 ; J53.10 239.62,81.46 ; J53.10 239.36,80.65 ; J24.1 173.78,143.64 ; J24.1 173.78,145.25 ; J24.1 172.17,143.64 ; J24.1 172.97,145.52 ; J24.1 171.91,144.45 ; J24.1 172.97,143.38 ; J24.1 174.04,144.45 ; J24.1 172.17,145.25 ; 210.88,134.56 U16.6 ; U16.6 211.18,133.65 ; U16.6 213.31,134.56 ; U16.6 213.01,135.47 ; U16.6 212.09,133.34 ; U16.6 211.18,135.47 ; U16.6 212.09,135.78 ; U16.6 213.01,133.65 ; J96.7 21,17.26 ; J96.7 19.87,16.13 ; J96.7 21.85,15.28 ; J96.7 22.13,16.13 ; J96.7 21.85,16.98 ; J96.7 21,15 ; J96.7 20.15,15.28 ; J96.7 20.15,16.98 ; 232.97,43.91 J39.16 ; J39.16 234.03,44.98 ; J39.16 232.16,44.18 ; J39.16 231.9,44.98 ; J39.16 232.16,45.79 ; J39.16 233.77,44.18 ; J39.16 232.97,46.05 ; J39.16 233.77,45.79 ; 53.76,49.01 J1.3 ; J1.3 54.89,50.14 ; J1.3 55.74,49.86 ; J1.3 56.02,49.01 ; J1.3 55.74,48.16 ; J1.3 54.89,47.88 ; J1.3 54.04,49.86 ; J1.3 54.04,48.16 ; J110.2 26.94,129.24 ; J110.2 27.74,128.98 ; J110.2 26.94,127.11 ; J110.2 26.13,128.98 ; J110.2 26.13,127.37 ; J110.2 27.74,127.37 ; J110.2 25.87,128.18 ; J110.2 28,128.18 ; J39.4 234.03,29.74 ; J39.4 232.16,30.55 ; J39.4 232.97,28.67 ; J39.4 233.77,28.94 ; J39.4 232.16,28.94 ; J39.4 231.9,29.74 ; J39.4 233.77,30.55 ; J39.4 232.97,30.81 ; 232.16,39.1 J39.12 ; J39.12 232.16,40.71 ; J39.12 233.77,39.1 ; J39.12 231.9,39.9 ; J39.12 233.77,40.71 ; J39.12 234.03,39.9 ; J39.12 232.97,40.97 ; J39.12 232.97,38.83 ; 44.35,35.98 J96.1 ; J96.1 46.05,35.98 ; J96.1 46.05,34.28 ; J96.1 44.07,35.13 ; J96.1 46.33,35.13 ; J96.1 44.35,34.28 ; J96.1 45.2,36.26 ; J96.1 45.2,34 ; 232.97,33.75 J39.8 ; J39.8 232.97,35.89 ; J39.8 233.77,35.63 ; J39.8 232.16,35.63 ; J39.8 234.03,34.82 ; J39.8 231.9,34.82 ; J39.8 232.16,34.02 ; J39.8 233.77,34.02 ; 7.5,59.58 J1.9 ; J1.9 8.35,59.86 ; J1.9 8.63,60.71 ; J1.9 7.5,61.84 ; J1.9 6.65,61.56 ; J1.9 8.35,61.56 ; J1.9 6.37,60.71 ; J1.9 6.65,59.86 ; 24.17,89.52 J78.4 ; J78.4 24.97,91.39 ; J78.4 25.78,89.52 ; J78.4 25.78,91.13 ; J78.4 26.04,90.32 ; J78.4 24.97,89.26 ; J78.4 23.9,90.32 ; J78.4 24.17,91.13 ; 232.97,31.21 J39.6 ; J39.6 232.16,33.09 ; J39.6 234.03,32.28 ; J39.6 232.97,33.35 ; J39.6 232.16,31.48 ; J39.6 233.77,33.09 ; J39.6 233.77,31.48 ; J39.6 231.9,32.28 ; J1.8 12.85,40.86 ; J1.8 12,40.58 ; J1.8 11.15,42.56 ; J1.8 11.15,40.86 ; J1.8 10.87,41.71 ; J1.8 13.13,41.71 ; J1.8 12.85,42.56 ; J1.8 12,42.84 ; 16.5,34 J96.10 ; J96.10 17.63,35.13 ; J96.10 16.5,36.26 ; J96.10 15.65,34.28 ; J96.10 15.37,35.13 ; J96.10 17.35,35.98 ; J96.10 15.65,35.98 ; J96.10 17.35,34.28 ; J96.6 30.85,15.28 ; J96.6 30.85,16.98 ; J96.6 28.87,16.13 ; J96.6 30,17.26 ; J96.6 29.15,15.28 ; J96.6 31.13,16.13 ; J96.6 30,15 ; J96.6 29.15,16.98 ; 54.89,55.08 J1.2 ; J1.2 55.74,55.36 ; J1.2 54.04,55.36 ; J1.2 54.89,57.34 ; J1.2 53.76,56.21 ; J1.2 55.74,57.06 ; J1.2 54.04,57.06 ; 116.87,139.34 MH2.1 ; MH2.1 121.02,137.59 ; MH2.1 120.37,135.84 ; MH2.1 116.87,135.84 ; MH2.1 116.22,137.59 ; MH2.1 120.37,139.34 ; MH2.1 118.62,135.19 ; MH2.1 118.62,139.99 ; 12,15 J96.8 ; J96.8 13.13,16.13 ; J96.8 11.15,16.98 ; J96.8 12,17.26 ; J96.8 12.85,15.28 ; J96.8 12.85,16.98 ; J96.8 10.87,16.13 ; J96.8 11.15,15.28 ; 197.44,14.74 J5.3 ; J5.3 199.05,16.35 ; J5.3 198.25,16.61 ; J5.3 199.31,15.54 ; J5.3 198.25,14.48 ; J5.3 199.05,14.74 ; J5.3 197.44,16.35 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 24.65,35.98 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 24.65,34.28 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 25.5,34 ; 5.46,143.71 MH4.1 ; MH4.1 7.21,144.37 ; MH4.1 3.71,147.86 ; MH4.1 5.46,148.51 ; MH4.1 7.21,147.86 ; MH4.1 3.71,144.37 ; MH4.1 3.06,146.11 ; MH4.1 7.86,146.11 ; 6.65,35.98 J96.9 ; J96.9 8.63,35.13 ; J96.9 6.37,35.13 ; J96.9 6.65,34.28 ; J96.9 7.5,36.26 ; J96.9 7.5,34 ; J96.9 8.35,34.28 ; J96.9 8.35,35.98 ; J105.6 103.07,130.21 ; J105.6 103.07,128.07 ; J105.6 102.26,129.95 ; J105.6 102,129.14 ; J105.6 104.13,129.14 ; J105.6 102.26,128.34 ; J105.6 103.87,129.95 ; J105.6 103.87,128.34 ; 199.21,35.61 J38.1 ; J38.1 200.28,34.54 ; J38.1 199.47,34.81 ; J38.1 200.28,36.68 ; J38.1 201.08,36.42 ; J38.1 201.08,34.81 ; J38.1 199.47,36.42 ; J38.1 201.35,35.61 ; 220.93,62.28 J23.1 ; J23.1 222,63.35 ; J23.1 221.19,61.48 ; J23.1 222,61.21 ; J23.1 222.8,61.48 ; J23.1 223.06,62.28 ; J23.1 221.19,63.09 ; J23.1 222.8,63.09 ; J96.2 55.74,31.48 ; J96.2 54.04,29.78 ; J96.2 54.89,31.76 ; J96.2 54.89,29.5 ; J96.2 53.76,30.63 ; J96.2 54.04,31.48 ; J96.2 55.74,29.78 ; J96.2 56.02,30.63 ; J96.4 50.55,15.28 ; J96.4 49.7,15 ; J96.4 50.83,16.13 ; J96.4 48.85,16.98 ; J96.4 50.55,16.98 ; J96.4 48.85,15.28 ; J96.4 48.57,16.13 ; J96.4 49.7,17.26 ; 198.71,130.14 J26.1 ; J26.1 199.52,130.4 ; J26.1 200.32,130.14 ; J26.1 198.45,129.34 ; J26.1 199.52,128.27 ; J26.1 200.32,128.53 ; J26.1 198.71,128.53 ; J26.1 200.58,129.34 ; 37.87,41.71 J1.5 ; J1.5 39.85,40.86 ; J1.5 39,40.58 ; J1.5 38.15,40.86 ; J1.5 40.13,41.71 ; MH1.1 236.22,173.01 ; MH1.1 233.82,170.61 ; MH1.1 234.47,172.36 ; MH1.1 237.97,168.86 ; MH1.1 238.62,170.61 ; MH1.1 234.47,168.86 ; MH1.1 236.22,168.21 ; MH1.1 237.97,172.36 ; J1.12 35.35,59.86 ; J1.12 33.65,61.56 ; J1.12 35.63,60.71 ; J1.12 33.65,59.86 ; J1.12 33.37,60.71 ; J1.12 34.5,61.84 ; J1.12 35.35,61.56 ; J1.12 34.5,59.58 ; J10.SH2 30.32,173.84 ; J10.SH2 26.53,173.84 ; J10.SH2 27.04,172.45 ; J52.9 229.72,64.99 ; J52.9 229.46,64.18 ; J52.9 227.85,65.8 ; J52.9 229.46,65.8 ; J52.9 227.85,64.18 ; J52.9 228.65,66.06 ; J52.9 227.58,64.99 ; J52.9 228.65,63.92 ; 47.96,98.77 J27.1 ; J27.1 49.57,98.77 ; J27.1 47.7,97.97 ; J27.1 48.77,96.9 ; J27.1 49.57,97.16 ; J27.1 49.83,97.97 ; J27.1 47.96,97.16 ; J27.1 48.77,99.03 ; J1.6 30.85,42.56 ; J1.6 29.15,42.56 ; J1.6 28.87,41.71 ; J1.6 30,42.84 ; J1.6 29.15,40.86 ; J1.6 30,40.58 ; J1.6 31.13,41.71 ; J1.6 30.85,40.86 ; MH5.1 237.97,14.84 ; MH5.1 237.97,18.33 ; MH5.1 234.47,18.33 ; MH5.1 236.22,14.19 ; MH5.1 234.47,14.84 ; MH5.1 233.82,16.59 ; MH5.1 236.22,18.99 ; MH5.1 238.62,16.59 ; J1.7 21,42.84 ; J1.7 21,40.58 ; J1.7 21.85,40.86 ; J1.7 21.85,42.56 ; J1.7 20.15,40.86 ; J1.7 20.15,42.56 ; J1.7 22.13,41.71 ; J1.7 19.87,41.71 ; 128.92,21.39 MH3.1 ; MH3.1 129.57,23.13 ; MH3.1 133.07,23.13 ; MH3.1 131.32,18.99 ; MH3.1 133.72,21.39 ; MH3.1 131.32,23.79 ; MH3.1 133.07,19.64 ; MH3.1 129.57,19.64 ; 5.09,94.72 MH7.1 ; MH7.1 7.49,92.32 ; MH7.1 7.49,97.12 ; MH7.1 9.24,96.46 ; MH7.1 5.74,92.97 ; MH7.1 9.24,92.97 ; MH7.1 5.74,96.46 ; MH7.1 9.89,94.72 ; 42.88,173.84 J10.SH1 ; J10.SH1 46.67,173.84 ; J10.SH1 46.17,172.45 ; U16.7 208.01,133.65 ; U16.7 208.31,134.56 ; U16.7 205.88,134.56 ; U16.7 207.09,135.78 ; U16.7 207.09,133.34 ; U16.7 206.18,135.47 ; U16.7 208.01,135.47 ; U16.7 206.18,133.65 ; 230.12,64.99 J52.10 ; J52.10 232.26,64.99 ; J52.10 232,64.18 ; J52.10 230.39,64.18 ; J52.10 230.39,65.8 ; J52.10 231.19,66.06 ; J52.10 231.19,63.92 ; J52.10 232,65.8 ; J25.1 225.21,17.49 ; J25.1 225.21,15.88 ; J25.1 223.34,16.69 ; J25.1 223.6,15.88 ; J25.1 224.41,17.75 ; J25.1 223.6,17.49 ; J25.1 225.48,16.69 ; J25.1 224.41,15.62 ; 232.16,36.56 J39.10 ; J39.10 233.77,36.56 ; J39.10 232.97,36.29 ; J39.10 232.16,38.17 ; J39.10 234.03,37.36 ; J39.10 233.77,38.17 ; J39.10 232.97,38.43 ; J39.10 231.9,37.36 ; J96.3 54.89,24.56 ; J96.3 56.02,23.43 ; J96.3 55.74,22.58 ; J96.3 54.04,22.58 ; J96.3 54.04,24.28 ; J96.3 53.76,23.43 ; J96.3 55.74,24.28 ; J96.3 54.89,22.3 ; 27.64,66.34 J36.1 ; J36.1 28.7,67.41 ; J36.1 27.9,65.54 ; J36.1 29.51,65.54 ; J36.1 29.77,66.34 ; J36.1 28.7,65.28 ; J36.1 27.9,67.15 ; J36.1 29.51,67.15 ; 16.5,59.58 J1.10 ; J1.10 15.65,61.56 ; J1.10 17.35,59.86 ; J1.10 16.5,61.84 ; J1.10 17.63,60.71 ; J1.10 17.35,61.56 ; J1.10 15.65,59.86 ; J1.10 15.37,60.71 ; 39,15 J96.5 ; J96.5 40.13,16.13 ; J96.5 39.85,15.28 ; J96.5 38.15,15.28 ; J96.5 37.87,16.13
  06_GND w0.508: 85.4,135.56 J34.2 ; J34.2 85.4,133.59 ; J34.2 86.39,135.89 ; J34.2 87.37,133.59 ; J34.2 85.07,134.57 ; J34.2 87.71,134.57 ; J34.2 86.39,133.25 ; J34.2 87.37,135.56 ; J34.4 87.37,130.48 ; J34.4 87.71,129.49 ; J34.4 87.37,128.51 ; J34.4 85.07,129.49 ; J34.4 85.4,130.48 ; J34.4 85.4,128.51 ; J34.4 86.39,128.17 ; J34.4 86.39,130.81 ; J32.4 62.48,115.24 ; J32.4 60.17,114.25 ; J32.4 62.48,113.27 ; J32.4 61.49,115.57 ; J32.4 60.51,115.24 ; J32.4 60.51,113.27 ; J32.4 62.81,114.25 ; J32.4 61.49,112.93 ; 81.31,133.25 J34.3 ; J34.3 82.29,135.56 ; J34.3 79.99,134.57 ; J34.3 80.32,133.59 ; J34.3 81.31,135.89 ; J34.3 82.29,133.59 ; J34.3 82.63,134.57 ; J34.3 80.32,135.56 ; J31.2 16.71,97.24 ; J31.2 16.38,98.22 ; J31.2 14.41,98.22 ; J31.2 16.38,96.25 ; J31.2 14.41,96.25 ; J31.2 15.39,95.92 ; J31.2 14.07,97.24 ; J31.2 15.39,98.56 ; 26.35,96.25 J30.5 ; J30.5 28.32,96.25 ; J30.5 27.33,95.92 ; J30.5 28.65,97.24 ; J30.5 26.35,98.22 ; J30.5 28.32,98.22 ; J30.5 26.01,97.24 ; J30.5 27.33,98.56 ; J35.3 74.45,130.81 ; J35.3 75.43,128.51 ; J35.3 75.43,130.48 ; J35.3 75.77,129.49 ; J35.3 73.46,128.51 ; J35.3 74.45,128.17 ; J35.3 73.46,130.48 ; J35.3 73.13,129.49 ; J30.4 32.41,98.56 ; J30.4 32.41,95.92 ; J30.4 33.4,98.22 ; J30.4 31.43,98.22 ; J30.4 33.4,96.25 ; J30.4 31.43,96.25 ; J30.4 31.09,97.24 ; J30.4 33.73,97.24 ; J35.4 70.35,135.56 ; J35.4 68.38,133.59 ; J35.4 69.37,135.89 ; J35.4 68.05,134.57 ; J35.4 68.38,135.56 ; J35.4 70.35,133.59 ; J35.4 70.69,134.57 ; J35.4 69.37,133.25 ; J30.2 32.41,103.64 ; J30.2 31.09,102.32 ; J30.2 33.73,102.32 ; J30.2 33.4,101.33 ; J30.2 32.41,101 ; J30.2 31.43,101.33 ; J30.2 33.4,103.3 ; J30.2 31.43,103.3 ; 55.43,110.16 J32.3 ; J32.3 55.43,108.19 ; J32.3 56.41,110.49 ; J32.3 57.4,108.19 ; J32.3 57.4,110.16 ; J32.3 55.09,109.17 ; J32.3 57.73,109.17 ; J32.3 56.41,107.85 ; 80.32,128.51 J34.5 ; J34.5 82.29,130.48 ; J34.5 82.63,129.49 ; J34.5 81.31,128.17 ; J34.5 80.32,130.48 ; J34.5 79.99,129.49 ; J34.5 81.31,130.81 ; J34.5 82.29,128.51 ; J33.5 57.4,103.3 ; J33.5 57.73,102.32 ; J33.5 55.09,102.32 ; J33.5 55.43,103.3 ; J33.5 56.41,101 ; J33.5 56.41,103.64 ; J33.5 55.43,101.33 ; J33.5 57.4,101.33 ; J33.4 57.73,97.24 ; J33.4 55.09,97.24 ; J33.4 56.41,95.92 ; J33.4 55.43,96.25 ; J33.4 56.41,98.56 ; J33.4 57.4,96.25 ; J33.4 55.43,98.22 ; J33.4 57.4,98.22 ; J32.5 62.48,108.19 ; J32.5 60.17,109.17 ; J32.5 62.81,109.17 ; J32.5 62.48,110.16 ; J32.5 60.51,108.19 ; J32.5 61.49,110.49 ; J32.5 61.49,107.85 ; J32.5 60.51,110.16 ; J32.2 57.4,113.27 ; J32.2 55.43,115.24 ; J32.2 57.4,115.24 ; J32.2 56.41,115.57 ; J32.2 57.73,114.25 ; J32.2 55.09,114.25 ; J32.2 56.41,112.93 ; J32.2 55.43,113.27 ; 20.47,95.92 J31.3 ; J31.3 20.47,98.56 ; J31.3 19.15,97.24 ; J31.3 19.49,96.25 ; J31.3 21.79,97.24 ; J31.3 19.49,98.22 ; J31.3 21.46,98.22 ; J31.3 21.46,96.25 ; 60.17,97.24 J33.2 ; J33.2 62.48,98.22 ; J33.2 62.81,97.24 ; J33.2 60.51,96.25 ; J33.2 62.48,96.25 ; J33.2 61.49,98.56 ; J33.2 60.51,98.22 ; J33.2 61.49,95.92 ; 60.17,102.32 J33.3 ; J33.3 60.51,101.33 ; J33.3 62.81,102.32 ; J33.3 60.51,103.3 ; J33.3 62.48,103.3 ; J33.3 62.48,101.33 ; J33.3 61.49,101 ; J33.3 61.49,103.64 ; J31.5 21.79,102.32 ; J31.5 19.15,102.32 ; J31.5 20.47,101 ; J31.5 21.46,101.33 ; J31.5 20.47,103.64 ; J31.5 21.46,103.3 ; J31.5 19.49,101.33 ; J31.5 19.49,103.3 ; 26.35,103.3 J30.3 ; J30.3 27.33,103.64 ; J30.3 28.65,102.32 ; J30.3 27.33,101 ; J30.3 28.32,103.3 ; J30.3 28.32,101.33 ; J30.3 26.01,102.32 ; J30.3 26.35,101.33 ; J31.4 15.39,103.64 ; J31.4 16.71,102.32 ; J31.4 14.41,103.3 ; J31.4 14.07,102.32 ; J31.4 15.39,101 ; J31.4 16.38,103.3 ; J31.4 16.38,101.33 ; J31.4 14.41,101.33 ; 74.45,133.25 J35.5 ; J35.5 74.45,135.89 ; J35.5 73.13,134.57 ; J35.5 75.43,135.56 ; J35.5 75.43,133.59 ; J35.5 73.46,135.56 ; J35.5 75.77,134.57 ; J35.5 73.46,133.59 ; 68.05,129.49 J35.2 ; J35.2 69.37,130.81 ; J35.2 70.35,130.48 ; J35.2 68.38,130.48 ; J35.2 68.38,128.51 ; J35.2 70.69,129.49 ; J35.2 70.35,128.51 ; J35.2 69.37,128.17
  07_SIG3 w0.381: 22.08,35.13 25.5,35.13 ; 25.5,35.13 23.03,32.67 ; 25.5,35.13 25.5,31.72 ; 25.5,35.13 23.03,37.6 ; 25.5,35.13 27.97,32.67 ; 21,38.29 J1.7 ; J1.7 21,45.12 ; J1.7 23.47,39.24 ; J1.7 18.53,39.24 ; J1.7 18.53,44.17 ; J1.7 17.58,41.71 ; J1.7 23.47,44.17 ; MH5.1 236.22,21.27 ; MH5.1 239.58,19.95 ; MH5.1 231.53,16.59 ; MH5.1 232.86,19.95 ; J96.8 15.42,16.13 ; J96.8 9.53,13.67 ; J96.8 14.47,18.6 ; J96.8 9.53,18.6 ; J96.8 12,12.72 ; J96.8 8.58,16.13 ; J96.8 12,19.55 ; J96.8 14.47,13.67 ; J96.10 19.92,35.13 ; J96.10 13.08,35.13 ; J96.10 18.97,37.6 ; J96.10 14.03,37.6 ; J96.10 14.03,32.67 ; J96.10 18.97,32.67 ; J96.10 16.5,31.72 ; J96.10 16.5,38.55 ; 197.86,33.19 J38.1 ; J38.1 197.86,38.03 ; J38.1 196.93,35.61 ; J38.1 200.28,38.96 ; MH6.1 12.18,9.32 ; MH6.1 4.13,5.96 ; MH6.1 2.81,9.32 ; MH6.1 4.13,12.69 ; MH6.1 10.86,12.69 ; MH6.1 10.86,5.96 ; MH6.1 7.49,14.01 ; 16.5,57.29 J1.10 ; J1.10 14.03,58.24 ; J1.10 13.08,60.71 ; J1.10 18.97,58.24 ; 5.03,63.17 J1.9 ; J1.9 9.97,58.24 ; J1.9 9.97,63.17 ; J1.9 10.92,60.71 ; J1.9 5.03,58.24 ; J1.9 7.5,57.29 ; J1.9 4.08,60.71 ; 26.58,16.13 J96.6 ; J96.6 33.42,16.13 ; J96.6 27.53,18.6 ; J96.6 27.53,13.67 ; J96.6 30,19.55 ; J96.6 32.47,13.67 ; J96.6 32.47,18.6 ; J1.8 14.47,39.24 ; J1.8 9.53,44.17 ; J1.8 9.53,39.24 ; J1.8 14.47,44.17 ; J1.8 12,38.29 ; J1.8 8.58,41.71 ; J1.8 15.42,41.71 ; J1.8 12,45.12 ; 23.03,58.24 25.5,60.71 22.08,60.71 ; 239.58,173.98 MH1.1 232.86,173.98 ; 221.99,19.11 J25.1 ; J25.1 227.76,16.69 ; J25.1 226.83,14.27 ; J25.1 226.83,19.11 ; J25.1 224.41,20.04 ; 24.25,173.84 J10.SH2 25.42,170.83 ; J96.7 21,19.55 ; J96.7 23.47,13.67 ; J96.7 24.42,16.13 ; J96.7 18.53,18.6 ; J96.7 18.53,13.67 ; J96.7 23.47,18.6 ; J96.7 17.58,16.13 ; 5.03,32.67 J96.9 ; J96.9 5.03,37.6 ; J96.9 7.5,38.55 ; J96.9 9.97,32.67 ; J96.9 4.08,35.13 ; J96.9 9.97,37.6 ; J96.9 7.5,31.72 ; J96.9 10.92,35.13 ; 48.95,173.84 J10.SH1 47.78,170.83 ; 7.49,90.03 MH7.1 ; MH7.1 2.81,94.72 ; MH7.1 4.13,91.35 ; MH7.1 4.13,98.08 ; 36.53,13.67 J96.5 ; J96.5 39,12.72 ; J96.5 41.47,13.67 ; J96.5 35.58,16.13
  07_SIG3 w0.508: J35.5 77.05,137.18 ; J35.5 71.85,137.18 ; J35.5 74.45,138.18
  08_GND w0.381: J82.2 11.07,105.66 ; J82.2 11.88,105.4 ; J82.2 10.27,105.4 ; J82.2 10.27,103.79 ; J82.2 11.07,103.53 ; J82.2 12.14,104.59 ; J82.2 11.88,103.79 ; J82.2 10.01,104.59 ; 29.15,16.98 J96.6 ; J96.6 30,17.26 ; J96.6 30,15 ; J96.6 28.87,16.13 ; J96.6 31.13,16.13 ; J96.6 29.15,15.28 ; J96.6 30.85,16.98 ; J96.6 30.85,15.28 ; 232.16,43.25 J39.14 ; J39.14 232.97,43.51 ; J39.14 231.9,42.44 ; J39.14 232.97,41.37 ; J39.14 234.03,42.44 ; J39.14 233.77,41.64 ; J39.14 233.77,43.25 ; J39.14 232.16,41.64 ; J110.2 28,128.18 ; J110.2 25.87,128.18 ; J110.2 26.13,127.37 ; J110.2 26.13,128.98 ; J110.2 27.74,127.37 ; J110.2 27.74,128.98 ; J110.2 26.94,127.11 ; J110.2 26.94,129.24 ; J1.10 17.63,60.71 ; J1.10 17.35,59.86 ; J1.10 16.5,61.84 ; J1.10 16.5,59.58 ; J1.10 15.65,61.56 ; J1.10 15.65,59.86 ; J1.10 15.37,60.71 ; J1.10 17.35,61.56 ; J25.1 225.21,15.88 ; J25.1 223.6,17.49 ; J25.1 225.21,17.49 ; J25.1 224.41,17.75 ; J25.1 224.41,15.62 ; J25.1 223.34,16.69 ; J25.1 223.6,15.88 ; J25.1 225.48,16.69 ; MH4.1 7.21,144.37 ; MH4.1 5.46,148.51 ; MH4.1 7.86,146.11 ; MH4.1 7.21,147.86 ; MH4.1 5.46,143.71 ; MH4.1 3.71,144.37 ; MH4.1 3.71,147.86 ; MH4.1 3.06,146.11 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 24.65,59.86 ; 25.5,60.71 25.5,59.58 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 24.65,61.56 ; J39.16 233.77,44.18 ; J39.16 232.97,43.91 ; J39.16 232.16,44.18 ; J39.16 232.97,46.05 ; J39.16 234.03,44.98 ; J39.16 233.77,45.79 ; J39.16 232.16,45.79 ; J39.16 231.9,44.98 ; 29.15,42.56 J1.6 ; J1.6 28.87,41.71 ; J1.6 30.85,40.86 ; J1.6 30,40.58 ; J1.6 30.85,42.56 ; J1.6 29.15,40.86 ; J1.6 30,42.84 ; J1.6 31.13,41.71 ; J27.1 49.57,98.77 ; J27.1 48.77,99.03 ; J27.1 47.96,97.16 ; J27.1 47.7,97.97 ; J27.1 49.57,97.16 ; J27.1 49.83,97.97 ; J27.1 47.96,98.77 ; J27.1 48.77,96.9 ; MH5.1 237.97,18.33 ; MH5.1 234.47,14.84 ; MH5.1 238.62,16.59 ; MH5.1 236.22,18.99 ; MH5.1 233.82,16.59 ; MH5.1 237.97,14.84 ; MH5.1 234.47,18.33 ; MH5.1 236.22,14.19 ; 11.15,15.28 J96.8 ; J96.8 13.13,16.13 ; J96.8 11.15,16.98 ; J96.8 10.87,16.13 ; J96.8 12,17.26 ; J96.8 12.85,16.98 ; J96.8 12,15 ; J96.8 12.85,15.28 ; J1.2 55.74,55.36 ; J1.2 55.74,57.06 ; J1.2 54.04,57.06 ; J1.2 53.76,56.21 ; J1.2 54.89,55.08 ; J1.2 54.89,57.34 ; J1.2 54.04,55.36 ; J26.1 200.32,130.14 ; J26.1 199.52,130.4 ; J26.1 200.32,128.53 ; J26.1 198.71,128.53 ; J26.1 198.71,130.14 ; J26.1 200.58,129.34 ; J26.1 199.52,128.27 ; J26.1 198.45,129.34 ; 210.88,134.56 U16.6 ; U16.6 212.09,135.78 ; U16.6 213.01,133.65 ; U16.6 211.18,135.47 ; U16.6 212.09,133.34 ; U16.6 213.31,134.56 ; U16.6 213.01,135.47 ; U16.6 211.18,133.65 ; J1.4 50.55,40.86 ; J1.4 48.85,40.86 ; J1.4 48.85,42.56 ; J1.4 49.7,42.84 ; J1.4 48.57,41.71 ; J1.4 49.7,40.58 ; J1.4 50.55,42.56 ; J1.4 50.83,41.71 ; J39.12 232.97,40.97 ; J39.12 231.9,39.9 ; J39.12 233.77,40.71 ; J39.12 233.77,39.1 ; J39.12 234.03,39.9 ; J39.12 232.16,40.71 ; J39.12 232.97,38.83 ; J39.12 232.16,39.1 ; 234.47,168.86 MH1.1 ; MH1.1 237.97,172.36 ; MH1.1 236.22,173.01 ; MH1.1 237.97,168.86 ; MH1.1 238.62,170.61 ; MH1.1 233.82,170.61 ; MH1.1 234.47,172.36 ; MH1.1 236.22,168.21 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 24.65,35.98 ; 25.5,35.13 25.5,34 ; 25.5,35.13 24.65,34.28 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 26.35,34.28 ; J1.5 40.13,41.71 ; J1.5 39.85,40.86 ; J1.5 37.87,41.71 ; J1.5 38.15,40.86 ; J1.5 39,40.58 ; 232.16,34.02 J39.8 ; J39.8 232.97,33.75 ; J39.8 233.77,35.63 ; J39.8 231.9,34.82 ; J39.8 234.03,34.82 ; J39.8 233.77,34.02 ; J39.8 232.97,35.89 ; J39.8 232.16,35.63 ; J36.1 28.7,67.41 ; J36.1 27.9,65.54 ; J36.1 29.77,66.34 ; J36.1 29.51,65.54 ; J36.1 28.7,65.28 ; J36.1 29.51,67.15 ; J36.1 27.64,66.34 ; J36.1 27.9,67.15 ; 129.57,19.64 MH3.1 ; MH3.1 129.57,23.13 ; MH3.1 133.07,23.13 ; MH3.1 131.32,23.79 ; MH3.1 133.07,19.64 ; MH3.1 128.92,21.39 ; MH3.1 131.32,18.99 ; MH3.1 133.72,21.39 ; 199.47,34.81 J38.1 ; J38.1 200.28,34.54 ; J38.1 201.08,34.81 ; J38.1 201.08,36.42 ; J38.1 200.28,36.68 ; J38.1 201.35,35.61 ; J38.1 199.47,36.42 ; J38.1 199.21,35.61 ; 45.2,59.58 J1.1 ; J1.1 46.05,59.86 ; J1.1 44.35,61.56 ; J1.1 46.05,61.56 ; J1.1 45.2,61.84 ; J1.1 46.33,60.71 ; J1.1 44.07,60.71 ; J1.1 44.35,59.86 ; J23.1 222.8,61.48 ; J23.1 222,63.35 ; J23.1 221.19,63.09 ; J23.1 222,61.21 ; J23.1 222.8,63.09 ; J23.1 220.93,62.28 ; J23.1 221.19,61.48 ; J23.1 223.06,62.28 ; 230.12,64.99 J52.10 ; J52.10 230.39,65.8 ; J52.10 231.19,66.06 ; J52.10 232,65.8 ; J52.10 231.19,63.92 ; J52.10 232,64.18 ; J52.10 230.39,64.18 ; J52.10 232.26,64.99 ; 53.76,49.01 J1.3 ; J1.3 54.04,49.86 ; J1.3 54.04,48.16 ; J1.3 55.74,49.86 ; J1.3 55.74,48.16 ; J1.3 54.89,50.14 ; J1.3 54.89,47.88 ; J1.3 56.02,49.01 ; J39.6 233.77,33.09 ; J39.6 231.9,32.28 ; J39.6 233.77,31.48 ; J39.6 232.97,31.21 ; J39.6 232.16,31.48 ; J39.6 232.97,33.35 ; J39.6 234.03,32.28 ; J39.6 232.16,33.09 ; J53.10 238.56,82.52 ; J53.10 237.75,82.26 ; J53.10 239.36,80.65 ; J53.10 239.62,81.46 ; J53.10 238.56,80.39 ; J53.10 239.36,82.26 ; J53.10 237.49,81.46 ; J53.10 237.75,80.65 ; MH2.1 120.37,139.34 ; MH2.1 116.87,135.84 ; MH2.1 116.87,139.34 ; MH2.1 118.62,135.19 ; MH2.1 120.37,135.84 ; MH2.1 121.02,137.59 ; MH2.1 116.22,137.59 ; MH2.1 118.62,139.99 ; J96.3 55.74,24.28 ; J96.3 54.89,24.56 ; J96.3 56.02,23.43 ; J96.3 55.74,22.58 ; J96.3 54.04,24.28 ; J96.3 53.76,23.43 ; J96.3 54.04,22.58 ; J96.3 54.89,22.3 ; J96.4 50.55,15.28 ; J96.4 48.85,15.28 ; J96.4 48.57,16.13 ; J96.4 50.55,16.98 ; J96.4 49.7,15 ; J96.4 50.83,16.13 ; J96.4 49.7,17.26 ; J96.4 48.85,16.98 ; 236.02,80.39 J53.9 ; J53.9 234.95,81.46 ; J53.9 235.21,82.26 ; J53.9 235.21,80.65 ; J53.9 236.82,80.65 ; J53.9 236.82,82.26 ; J53.9 236.02,82.52 ; J53.9 237.08,81.46 ; MH7.1 9.24,96.46 ; MH7.1 7.49,92.32 ; MH7.1 5.74,96.46 ; MH7.1 7.49,97.12 ; MH7.1 5.09,94.72 ; MH7.1 9.24,92.97 ; MH7.1 9.89,94.72 ; MH7.1 5.74,92.97 ; U16.7 208.01,133.65 ; U16.7 206.18,133.65 ; U16.7 206.18,135.47 ; U16.7 208.01,135.47 ; U16.7 205.88,134.56 ; U16.7 207.09,133.34 ; U16.7 207.09,135.78 ; U16.7 208.31,134.56 ; MH6.1 9.24,11.07 ; MH6.1 7.49,6.92 ; MH6.1 7.49,11.72 ; MH6.1 9.24,7.57 ; MH6.1 5.09,9.32 ; MH6.1 9.89,9.32 ; MH6.1 5.74,7.57 ; MH6.1 5.74,11.07 ; 44.35,34.28 J96.1 ; J96.1 44.35,35.98 ; J96.1 46.33,35.13 ; J96.1 45.2,36.26 ; J96.1 46.05,34.28 ; J96.1 45.2,34 ; J96.1 46.05,35.98 ; J96.1 44.07,35.13 ; 213.38,137.06 U16.5 ; U16.5 215.51,137.97 ; U16.5 214.59,135.84 ; U16.5 215.51,136.15 ; U16.5 215.81,137.06 ; U16.5 213.68,137.97 ; U16.5 213.68,136.15 ; U16.5 214.59,138.28 ; J96.12 35.35,34.28 ; J96.12 35.35,35.98 ; J96.12 33.65,34.28 ; J96.12 34.5,34 ; J96.12 35.63,35.13 ; J96.12 34.5,36.26 ; J96.12 33.65,35.98 ; J96.12 33.37,35.13 ; 54.04,31.48 J96.2 ; J96.2 54.04,29.78 ; J96.2 56.02,30.63 ; J96.2 53.76,30.63 ; J96.2 54.89,29.5 ; J96.2 55.74,29.78 ; J96.2 55.74,31.48 ; J96.2 54.89,31.76 ; J39.4 233.77,30.55 ; J39.4 232.97,28.67 ; J39.4 232.16,30.55 ; J39.4 232.16,28.94 ; J39.4 233.77,28.94 ; J39.4 231.9,29.74 ; J39.4 232.97,30.81 ; J39.4 234.03,29.74 ; J1.7 21,42.84 ; J1.7 20.15,42.56 ; J1.7 21.85,40.86 ; J1.7 22.13,41.71 ; J1.7 20.15,40.86 ; J1.7 21,40.58 ; J1.7 21.85,42.56 ; J1.7 19.87,41.71 ; J78.4 25.78,91.13 ; J78.4 24.97,91.39 ; J78.4 26.04,90.32 ; J78.4 24.17,91.13 ; J78.4 25.78,89.52 ; J78.4 24.97,89.26 ; J78.4 24.17,89.52 ; J78.4 23.9,90.32 ; 198.25,14.48 J5.3 ; J5.3 199.31,15.54 ; J5.3 199.05,14.74 ; J5.3 197.44,14.74 ; J5.3 199.05,16.35 ; J5.3 197.44,16.35 ; J5.3 198.25,16.61 ; J24.1 172.97,145.52 ; J24.1 171.91,144.45 ; J24.1 172.17,145.25 ; J24.1 172.97,143.38 ; J24.1 173.78,143.64 ; J24.1 172.17,143.64 ; J24.1 174.04,144.45 ; J24.1 173.78,145.25 ; J10.SH2 30.32,173.84 ; J10.SH2 26.53,173.84 ; J10.SH2 27.04,172.45 ; J96.10 17.63,35.13 ; J96.10 15.65,35.98 ; J96.10 17.35,35.98 ; J96.10 17.35,34.28 ; J96.10 15.65,34.28 ; J96.10 16.5,36.26 ; J96.10 15.37,35.13 ; J96.10 16.5,34 ; J1.12 34.5,61.84 ; J1.12 35.35,61.56 ; J1.12 33.65,61.56 ; J1.12 34.5,59.58 ; J1.12 33.65,59.86 ; J1.12 35.35,59.86 ; J1.12 35.63,60.71 ; J1.12 33.37,60.71 ; 227.58,64.99 J52.9 ; J52.9 227.85,65.8 ; J52.9 229.72,64.99 ; J52.9 227.85,64.18 ; J52.9 228.65,66.06 ; J52.9 229.46,65.8 ; J52.9 228.65,63.92 ; J52.9 229.46,64.18 ; C499.2 197.5,135.05 ; C499.2 195.63,135.86 ; C499.2 197.24,134.25 ; C499.2 195.37,135.05 ; C499.2 196.43,136.12 ; C499.2 196.43,133.98 ; C499.2 195.63,134.25 ; C499.2 197.24,135.86 ; J1.9 8.35,61.56 ; J1.9 6.37,60.71 ; J1.9 8.35,59.86 ; J1.9 7.5,59.58 ; J1.9 6.65,61.56 ; J1.9 6.65,59.86 ; J1.9 7.5,61.84 ; J1.9 8.63,60.71 ; 38.15,15.28 J96.5 ; J96.5 40.13,16.13 ; J96.5 39,15 ; J96.5 37.87,16.13 ; J96.5 39.85,15.28 ; 20.15,16.98 J96.7 ; J96.7 19.87,16.13 ; J96.7 21,17.26 ; J96.7 20.15,15.28 ; J96.7 21,15 ; J96.7 21.85,16.98 ; J96.7 22.13,16.13 ; J96.7 21.85,15.28 ; 231.9,37.36 J39.10 ; J39.10 232.97,36.29 ; J39.10 233.77,36.56 ; J39.10 234.03,37.36 ; J39.10 232.16,36.56 ; J39.10 232.97,38.43 ; J39.10 233.77,38.17 ; J39.10 232.16,38.17 ; J1.8 12.85,42.56 ; J1.8 11.15,40.86 ; J1.8 12.85,40.86 ; J1.8 13.13,41.71 ; J1.8 12,40.58 ; J1.8 10.87,41.71 ; J1.8 12,42.84 ; J1.8 11.15,42.56 ; J10.SH1 46.67,173.84 ; J10.SH1 42.88,173.84 ; J10.SH1 46.17,172.45 ; J105.6 103.87,129.95 ; J105.6 103.07,128.07 ; J105.6 102,129.14 ; J105.6 102.26,129.95 ; J105.6 104.13,129.14 ; J105.6 102.26,128.34 ; J105.6 103.87,128.34 ; J105.6 103.07,130.21 ; 6.65,34.28 J96.9 ; J96.9 8.35,35.98 ; J96.9 6.65,35.98 ; J96.9 8.63,35.13 ; J96.9 6.37,35.13 ; J96.9 8.35,34.28 ; J96.9 7.5,34 ; J96.9 7.5,36.26
  08_GND w0.508: J33.4 56.41,98.56 ; J33.4 57.4,98.22 ; J33.4 55.43,98.22 ; J33.4 57.4,96.25 ; J33.4 55.09,97.24 ; J33.4 57.73,97.24 ; J33.4 56.41,95.92 ; J33.4 55.43,96.25 ; J35.4 70.35,133.59 ; J35.4 69.37,135.89 ; J35.4 68.38,133.59 ; J35.4 69.37,133.25 ; J35.4 70.69,134.57 ; J35.4 70.35,135.56 ; J35.4 68.05,134.57 ; J35.4 68.38,135.56 ; J34.4 86.39,130.81 ; J34.4 86.39,128.17 ; J34.4 87.71,129.49 ; J34.4 85.07,129.49 ; J34.4 85.4,130.48 ; J34.4 87.37,130.48 ; J34.4 85.4,128.51 ; J34.4 87.37,128.51 ; J31.5 21.46,101.33 ; J31.5 20.47,103.64 ; J31.5 19.49,103.3 ; J31.5 19.15,102.32 ; J31.5 21.46,103.3 ; J31.5 20.47,101 ; J31.5 19.49,101.33 ; J31.5 21.79,102.32 ; J32.2 57.4,115.24 ; J32.2 55.09,114.25 ; J32.2 57.4,113.27 ; J32.2 56.41,115.57 ; J32.2 55.43,113.27 ; J32.2 55.43,115.24 ; J32.2 57.73,114.25 ; J32.2 56.41,112.93 ; J33.2 61.49,98.56 ; J33.2 61.49,95.92 ; J33.2 60.51,96.25 ; J33.2 62.81,97.24 ; J33.2 60.51,98.22 ; J33.2 60.17,97.24 ; J33.2 62.48,98.22 ; J33.2 62.48,96.25 ; J30.2 33.4,103.3 ; J30.2 32.41,101 ; J30.2 32.41,103.64 ; J30.2 31.09,102.32 ; J30.2 31.43,101.33 ; J30.2 33.73,102.32 ; J30.2 31.43,103.3 ; J30.2 33.4,101.33 ; 56.41,101 J33.5 ; J33.5 57.4,101.33 ; J33.5 57.4,103.3 ; J33.5 55.43,101.33 ; J33.5 57.73,102.32 ; J33.5 55.09,102.32 ; J33.5 56.41,103.64 ; J33.5 55.43,103.3 ; 73.46,130.48 J35.3 ; J35.3 75.43,130.48 ; J35.3 74.45,130.81 ; J35.3 73.46,128.51 ; J35.3 75.43,128.51 ; J35.3 75.77,129.49 ; J35.3 73.13,129.49 ; J35.3 74.45,128.17 ; 68.38,130.48 J35.2 ; J35.2 70.35,128.51 ; J35.2 69.37,128.17 ; J35.2 68.38,128.51 ; J35.2 69.37,130.81 ; J35.2 68.05,129.49 ; J35.2 70.35,130.48 ; J35.2 70.69,129.49 ; J34.2 87.37,133.59 ; J34.2 86.39,133.25 ; J34.2 85.07,134.57 ; J34.2 87.37,135.56 ; J34.2 87.71,134.57 ; J34.2 85.4,135.56 ; J34.2 85.4,133.59 ; J34.2 86.39,135.89 ; 27.33,101 J30.3 ; J30.3 28.32,101.33 ; J30.3 28.32,103.3 ; J30.3 26.01,102.32 ; J30.3 27.33,103.64 ; J30.3 26.35,101.33 ; J30.3 26.35,103.3 ; J30.3 28.65,102.32 ; J31.3 20.47,98.56 ; J31.3 19.49,96.25 ; J31.3 21.46,96.25 ; J31.3 21.46,98.22 ; J31.3 21.79,97.24 ; J31.3 20.47,95.92 ; J31.3 19.49,98.22 ; J31.3 19.15,97.24 ; 73.46,133.59 J35.5 ; J35.5 75.43,135.56 ; J35.5 74.45,135.89 ; J35.5 75.77,134.57 ; J35.5 73.46,135.56 ; J35.5 74.45,133.25 ; J35.5 73.13,134.57 ; J35.5 75.43,133.59 ; J30.5 27.33,98.56 ; J30.5 28.32,98.22 ; J30.5 26.35,96.25 ; J30.5 26.01,97.24 ; J30.5 27.33,95.92 ; J30.5 28.32,96.25 ; J30.5 26.35,98.22 ; J30.5 28.65,97.24 ; 55.43,108.19 J32.3 ; J32.3 56.41,107.85 ; J32.3 57.73,109.17 ; J32.3 55.09,109.17 ; J32.3 57.4,108.19 ; J32.3 57.4,110.16 ; J32.3 55.43,110.16 ; J32.3 56.41,110.49 ; 15.39,101 J31.4 ; J31.4 16.38,101.33 ; J31.4 16.38,103.3 ; J31.4 14.41,101.33 ; J31.4 14.41,103.3 ; J31.4 16.71,102.32 ; J31.4 14.07,102.32 ; J31.4 15.39,103.64 ; 60.51,108.19 J32.5 ; J32.5 60.51,110.16 ; J32.5 60.17,109.17 ; J32.5 62.81,109.17 ; J32.5 61.49,107.85 ; J32.5 61.49,110.49 ; J32.5 62.48,110.16 ; J32.5 62.48,108.19 ; 80.32,130.48 J34.5 ; J34.5 82.29,130.48 ; J34.5 79.99,129.49 ; J34.5 81.31,128.17 ; J34.5 82.63,129.49 ; J34.5 81.31,130.81 ; J34.5 80.32,128.51 ; J34.5 82.29,128.51 ; 14.07,97.24 J31.2 ; J31.2 14.41,98.22 ; J31.2 14.41,96.25 ; J31.2 15.39,95.92 ; J31.2 16.38,96.25 ; J31.2 16.71,97.24 ; J31.2 15.39,98.56 ; J31.2 16.38,98.22 ; J30.4 33.4,96.25 ; J30.4 33.4,98.22 ; J30.4 32.41,95.92 ; J30.4 31.09,97.24 ; J30.4 33.73,97.24 ; J30.4 32.41,98.56 ; J30.4 31.43,96.25 ; J30.4 31.43,98.22 ; J32.4 62.48,115.24 ; J32.4 62.48,113.27 ; J32.4 60.51,115.24 ; J32.4 62.81,114.25 ; J32.4 61.49,112.93 ; J32.4 60.51,113.27 ; J32.4 60.17,114.25 ; J32.4 61.49,115.57 ; 60.51,101.33 J33.3 ; J33.3 62.81,102.32 ; J33.3 61.49,101 ; J33.3 62.48,101.33 ; J33.3 62.48,103.3 ; J33.3 61.49,103.64 ; J33.3 60.17,102.32 ; J33.3 60.51,103.3 ; 79.99,134.57 J34.3 ; J34.3 81.31,135.89 ; J34.3 82.29,133.59 ; J34.3 82.29,135.56 ; J34.3 81.31,133.25 ; J34.3 82.63,134.57 ; J34.3 80.32,133.59 ; J34.3 80.32,135.56
  10_GND w0.381: 29.15,16.98 J96.6 ; J96.6 29.15,15.28 ; J96.6 30.85,16.98 ; J96.6 30,15 ; J96.6 30.85,15.28 ; J96.6 31.13,16.13 ; J96.6 30,17.26 ; J96.6 28.87,16.13 ; J26.1 200.32,130.14 ; J26.1 199.52,130.4 ; J26.1 200.58,129.34 ; J26.1 198.71,128.53 ; J26.1 198.45,129.34 ; J26.1 199.52,128.27 ; J26.1 198.71,130.14 ; J26.1 200.32,128.53 ; 116.22,137.59 MH2.1 ; MH2.1 121.02,137.59 ; MH2.1 116.87,139.34 ; MH2.1 120.37,139.34 ; MH2.1 118.62,139.99 ; MH2.1 120.37,135.84 ; MH2.1 116.87,135.84 ; MH2.1 118.62,135.19 ; 24.37,35.13 25.5,35.13 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 24.65,34.28 ; 25.5,35.13 24.65,35.98 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 25.5,34 ; U16.7 208.31,134.56 ; U16.7 207.09,135.78 ; U16.7 206.18,133.65 ; U16.7 205.88,134.56 ; U16.7 208.01,135.47 ; U16.7 206.18,135.47 ; U16.7 208.01,133.65 ; U16.7 207.09,133.34 ; J10.SH2 30.32,173.84 ; J10.SH2 27.04,172.45 ; J10.SH2 26.53,173.84 ; J5.3 199.05,16.35 ; J5.3 197.44,16.35 ; J5.3 199.05,14.74 ; J5.3 198.25,16.61 ; J5.3 198.25,14.48 ; J5.3 199.31,15.54 ; J5.3 197.44,14.74 ; MH4.1 7.21,144.37 ; MH4.1 3.71,147.86 ; MH4.1 7.21,147.86 ; MH4.1 3.06,146.11 ; MH4.1 5.46,143.71 ; MH4.1 5.46,148.51 ; MH4.1 7.86,146.11 ; MH4.1 3.71,144.37 ; J23.1 223.06,62.28 ; J23.1 221.19,63.09 ; J23.1 220.93,62.28 ; J23.1 222.8,61.48 ; J23.1 222,61.21 ; J23.1 222.8,63.09 ; J23.1 221.19,61.48 ; J23.1 222,63.35 ; 27.9,67.15 J36.1 ; J36.1 29.51,65.54 ; J36.1 28.7,65.28 ; J36.1 29.77,66.34 ; J36.1 27.9,65.54 ; J36.1 28.7,67.41 ; J36.1 29.51,67.15 ; J36.1 27.64,66.34 ; J38.1 200.28,36.68 ; J38.1 199.47,36.42 ; J38.1 200.28,34.54 ; J38.1 201.08,34.81 ; J38.1 201.08,36.42 ; J38.1 201.35,35.61 ; J38.1 199.47,34.81 ; J38.1 199.21,35.61 ; J96.12 35.35,35.98 ; J96.12 35.63,35.13 ; J96.12 33.65,34.28 ; J96.12 33.37,35.13 ; J96.12 35.35,34.28 ; J96.12 33.65,35.98 ; J96.12 34.5,34 ; J96.12 34.5,36.26 ; J53.10 239.62,81.46 ; J53.10 238.56,82.52 ; J53.10 237.75,82.26 ; J53.10 237.75,80.65 ; J53.10 239.36,80.65 ; J53.10 237.49,81.46 ; J53.10 239.36,82.26 ; J53.10 238.56,80.39 ; 48.85,16.98 J96.4 ; J96.4 48.57,16.13 ; J96.4 50.55,16.98 ; J96.4 48.85,15.28 ; J96.4 49.7,15 ; J96.4 50.83,16.13 ; J96.4 49.7,17.26 ; J96.4 50.55,15.28 ; 232.97,38.83 J39.12 ; J39.12 232.97,40.97 ; J39.12 233.77,39.1 ; J39.12 233.77,40.71 ; J39.12 231.9,39.9 ; J39.12 232.16,40.71 ; J39.12 232.16,39.1 ; J39.12 234.03,39.9 ; 230.12,64.99 J52.10 ; J52.10 231.19,66.06 ; J52.10 232.26,64.99 ; J52.10 230.39,64.18 ; J52.10 231.19,63.92 ; J52.10 230.39,65.8 ; J52.10 232,65.8 ; J52.10 232,64.18 ; J39.10 233.77,36.56 ; J39.10 232.16,38.17 ; J39.10 234.03,37.36 ; J39.10 232.97,36.29 ; J39.10 231.9,37.36 ; J39.10 233.77,38.17 ; J39.10 232.16,36.56 ; J39.10 232.97,38.43 ; 234.47,18.33 MH5.1 ; MH5.1 236.22,18.99 ; MH5.1 236.22,14.19 ; MH5.1 233.82,16.59 ; MH5.1 238.62,16.59 ; MH5.1 237.97,18.33 ; MH5.1 237.97,14.84 ; MH5.1 234.47,14.84 ; MH7.1 9.89,94.72 ; MH7.1 7.49,92.32 ; MH7.1 9.24,92.97 ; MH7.1 5.74,96.46 ; MH7.1 5.09,94.72 ; MH7.1 5.74,92.97 ; MH7.1 7.49,97.12 ; MH7.1 9.24,96.46 ; 227.58,64.99 J52.9 ; J52.9 228.65,63.92 ; J52.9 229.72,64.99 ; J52.9 227.85,64.18 ; J52.9 227.85,65.8 ; J52.9 228.65,66.06 ; J52.9 229.46,65.8 ; J52.9 229.46,64.18 ; 48.85,42.56 J1.4 ; J1.4 50.55,42.56 ; J1.4 50.55,40.86 ; J1.4 48.57,41.71 ; J1.4 50.83,41.71 ; J1.4 48.85,40.86 ; J1.4 49.7,42.84 ; J1.4 49.7,40.58 ; J1.9 8.63,60.71 ; J1.9 8.35,59.86 ; J1.9 6.65,61.56 ; J1.9 7.5,59.58 ; J1.9 6.37,60.71 ; J1.9 8.35,61.56 ; J1.9 7.5,61.84 ; J1.9 6.65,59.86 ; C499.2 197.5,135.05 ; C499.2 197.24,135.86 ; C499.2 195.63,135.86 ; C499.2 197.24,134.25 ; C499.2 195.37,135.05 ; C499.2 196.43,133.98 ; C499.2 196.43,136.12 ; C499.2 195.63,134.25 ; 12,40.58 J1.8 ; J1.8 11.15,40.86 ; J1.8 12.85,42.56 ; J1.8 10.87,41.71 ; J1.8 12.85,40.86 ; J1.8 13.13,41.71 ; J1.8 11.15,42.56 ; J1.8 12,42.84 ; U2.A12 58.65,5.49 59.23,6.07 59.23,6.34 v6(59.61,6.72) ; J24.1 173.78,143.64 ; J24.1 171.91,144.45 ; J24.1 173.78,145.25 ; J24.1 172.17,143.64 ; J24.1 172.17,145.25 ; J24.1 172.97,145.52 ; J24.1 172.97,143.38 ; J24.1 174.04,144.45 ; J53.9 236.82,80.65 ; J53.9 234.95,81.46 ; J53.9 237.08,81.46 ; J53.9 235.21,82.26 ; J53.9 236.02,82.52 ; J53.9 235.21,80.65 ; J53.9 236.02,80.39 ; J53.9 236.82,82.26 ; J39.4 233.77,30.55 ; J39.4 232.97,30.81 ; J39.4 232.16,30.55 ; J39.4 232.16,28.94 ; J39.4 232.97,28.67 ; J39.4 233.77,28.94 ; J39.4 234.03,29.74 ; J39.4 231.9,29.74 ; J1.6 30.85,40.86 ; J1.6 28.87,41.71 ; J1.6 30,42.84 ; J1.6 29.15,42.56 ; J1.6 31.13,41.71 ; J1.6 30,40.58 ; J1.6 29.15,40.86 ; J1.6 30.85,42.56 ; 54.89,22.3 J96.3 ; J96.3 54.04,24.28 ; J96.3 55.74,24.28 ; J96.3 55.74,22.58 ; J96.3 53.76,23.43 ; J96.3 54.89,24.56 ; J96.3 56.02,23.43 ; J96.3 54.04,22.58 ; 54.04,57.06 J1.2 ; J1.2 54.89,55.08 ; J1.2 55.74,55.36 ; J1.2 53.76,56.21 ; J1.2 54.89,57.34 ; J1.2 54.04,55.36 ; J1.2 55.74,57.06 ; 47.7,97.97 J27.1 ; J27.1 48.77,96.9 ; J27.1 49.83,97.97 ; J27.1 49.57,98.77 ; J27.1 49.57,97.16 ; J27.1 47.96,98.77 ; J27.1 48.77,99.03 ; J27.1 47.96,97.16 ; 33.65,59.86 J1.12 ; J1.12 34.5,59.58 ; J1.12 33.65,61.56 ; J1.12 34.5,61.84 ; J1.12 35.35,59.86 ; J1.12 35.63,60.71 ; J1.12 35.35,61.56 ; J1.12 33.37,60.71 ; 223.6,17.49 J25.1 ; J25.1 225.21,17.49 ; J25.1 225.21,15.88 ; J25.1 223.34,16.69 ; J25.1 225.48,16.69 ; J25.1 224.41,17.75 ; J25.1 223.6,15.88 ; J25.1 224.41,15.62 ; MH1.1 236.22,173.01 ; MH1.1 236.22,168.21 ; MH1.1 233.82,170.61 ; MH1.1 234.47,172.36 ; MH1.1 238.62,170.61 ; MH1.1 234.47,168.86 ; MH1.1 237.97,172.36 ; MH1.1 237.97,168.86 ; 24.65,61.56 25.5,60.71 ; 25.5,60.71 24.65,59.86 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 25.5,59.58 ; 25.5,60.71 26.63,60.71 ; 232.97,31.21 J39.6 ; J39.6 233.77,33.09 ; J39.6 231.9,32.28 ; J39.6 232.16,31.48 ; J39.6 233.77,31.48 ; J39.6 232.97,33.35 ; J39.6 234.03,32.28 ; J39.6 232.16,33.09 ; MH6.1 9.89,9.32 ; MH6.1 7.49,6.92 ; MH6.1 9.24,7.57 ; MH6.1 5.09,9.32 ; MH6.1 5.74,11.07 ; MH6.1 5.74,7.57 ; MH6.1 7.49,11.72 ; MH6.1 9.24,11.07 ; 39,40.58 J1.5 ; J1.5 39.85,40.86 ; J1.5 40.13,41.71 ; J1.5 37.87,41.71 ; J1.5 38.15,40.86 ; 214.59,135.84 U16.5 ; U16.5 213.68,137.97 ; U16.5 215.51,136.15 ; U16.5 213.68,136.15 ; U16.5 213.38,137.06 ; U16.5 215.81,137.06 ; U16.5 214.59,138.28 ; U16.5 215.51,137.97 ; 15.65,35.98 J96.10 ; J96.10 17.35,34.28 ; J96.10 16.5,36.26 ; J96.10 17.63,35.13 ; J96.10 15.37,35.13 ; J96.10 16.5,34 ; J96.10 15.65,34.28 ; J96.10 17.35,35.98 ; J96.8 12,17.26 ; J96.8 12.85,15.28 ; J96.8 10.87,16.13 ; J96.8 12,15 ; J96.8 12.85,16.98 ; J96.8 13.13,16.13 ; J96.8 11.15,16.98 ; J96.8 11.15,15.28 ; 231.9,34.82 J39.8 ; J39.8 232.97,35.89 ; J39.8 232.97,33.75 ; J39.8 232.16,34.02 ; J39.8 233.77,34.02 ; J39.8 233.77,35.63 ; J39.8 232.16,35.63 ; J39.8 234.03,34.82 ; MH3.1 133.07,19.64 ; MH3.1 129.57,23.13 ; MH3.1 131.32,23.79 ; MH3.1 133.07,23.13 ; MH3.1 129.57,19.64 ; MH3.1 131.32,18.99 ; MH3.1 128.92,21.39 ; MH3.1 133.72,21.39 ; J1.10 17.63,60.71 ; J1.10 17.35,61.56 ; J1.10 15.37,60.71 ; J1.10 16.5,59.58 ; J1.10 16.5,61.84 ; J1.10 15.65,59.86 ; J1.10 17.35,59.86 ; J1.10 15.65,61.56 ; J1.3 54.89,50.14 ; J1.3 54.04,48.16 ; J1.3 54.04,49.86 ; J1.3 56.02,49.01 ; J1.3 55.74,48.16 ; J1.3 53.76,49.01 ; J1.3 54.89,47.88 ; J1.3 55.74,49.86 ; 24.97,89.26 J78.4 ; J78.4 24.17,89.52 ; J78.4 25.78,89.52 ; J78.4 24.97,91.39 ; J78.4 24.17,91.13 ; J78.4 23.9,90.32 ; J78.4 25.78,91.13 ; J78.4 26.04,90.32 ; J39.16 232.97,46.05 ; J39.16 233.77,45.79 ; J39.16 231.9,44.98 ; J39.16 232.97,43.91 ; J39.16 233.77,44.18 ; J39.16 234.03,44.98 ; J39.16 232.16,44.18 ; J39.16 232.16,45.79 ; J1.1 46.05,61.56 ; J1.1 45.2,59.58 ; J1.1 44.35,59.86 ; J1.1 46.33,60.71 ; J1.1 44.35,61.56 ; J1.1 46.05,59.86 ; J1.1 44.07,60.71 ; J1.1 45.2,61.84 ; U16.6 213.31,134.56 ; U16.6 212.09,133.34 ; U16.6 210.88,134.56 ; U16.6 213.01,133.65 ; U16.6 211.18,135.47 ; U16.6 213.01,135.47 ; U16.6 212.09,135.78 ; U16.6 211.18,133.65 ; v6(77.15,5.99) 77.65,5.49 arc(77.65,5.49) 77.65,5.49 U2.A31 ; U2.A82 128.65,5.49 127.77,6.37 v6(127.77,6.63) ; J96.1 46.05,34.28 ; J96.1 46.33,35.13 ; J96.1 44.35,35.98 ; J96.1 45.2,36.26 ; J96.1 44.07,35.13 ; J96.1 45.2,34 ; J96.1 46.05,35.98 ; J96.1 44.35,34.28 ; J96.7 22.13,16.13 ; J96.7 20.15,16.98 ; J96.7 21,15 ; J96.7 21.85,16.98 ; J96.7 21.85,15.28 ; J96.7 20.15,15.28 ; J96.7 19.87,16.13 ; J96.7 21,17.26 ; U2.A18 64.65,5.49 v6(64.15,5.99) ; v6(62.15,5.99) 61.65,5.49 U2.A15 ; 38.15,15.28 J96.5 ; J96.5 37.87,16.13 ; J96.5 40.13,16.13 ; J96.5 39,15 ; J96.5 39.85,15.28 ; J96.9 8.35,34.28 ; J96.9 8.35,35.98 ; J96.9 6.65,34.28 ; J96.9 7.5,36.26 ; J96.9 6.65,35.98 ; J96.9 6.37,35.13 ; J96.9 7.5,34 ; J96.9 8.63,35.13 ; J82.2 11.88,103.79 ; J82.2 10.01,104.59 ; J82.2 12.14,104.59 ; J82.2 11.07,103.53 ; J82.2 10.27,105.4 ; J82.2 10.27,103.79 ; J82.2 11.07,105.66 ; J82.2 11.88,105.4 ; v6(96.15,5.99) 95.65,5.49 95.65,3.49 ; 232.16,43.25 J39.14 ; J39.14 231.9,42.44 ; J39.14 234.03,42.44 ; J39.14 232.97,43.51 ; J39.14 233.77,41.64 ; J39.14 233.77,43.25 ; J39.14 232.97,41.37 ; J39.14 232.16,41.64 ; J96.2 56.02,30.63 ; J96.2 55.74,31.48 ; J96.2 53.76,30.63 ; J96.2 54.04,29.78 ; J96.2 54.89,29.5 ; J96.2 54.89,31.76 ; J96.2 55.74,29.78 ; J96.2 54.04,31.48 ; J1.7 21,42.84 ; J1.7 21,40.58 ; J1.7 20.15,40.86 ; J1.7 21.85,40.86 ; J1.7 20.15,42.56 ; J1.7 22.13,41.71 ; J1.7 19.87,41.71 ; J1.7 21.85,42.56 ; 26.13,127.37 J110.2 ; J110.2 28,128.18 ; J110.2 26.94,127.11 ; J110.2 26.13,128.98 ; J110.2 27.74,127.37 ; J110.2 27.74,128.98 ; J110.2 25.87,128.18 ; J110.2 26.94,129.24 ; J10.SH1 46.67,173.84 ; J10.SH1 46.17,172.45 ; J10.SH1 42.88,173.84 ; v6(98.15,5.99) 97.65,5.49 U2.A51 ; U2.A34 80.65,5.49 v6(81.15,5.99) ; v6(67.15,5.99) 66.65,5.49 U2.A20 ; U2.A4 v6(48.65,7.13)
  10_GND w0.508: 55.43,113.27 J32.2 ; J32.2 56.41,112.93 ; J32.2 55.43,115.24 ; J32.2 57.73,114.25 ; J32.2 57.4,113.27 ; J32.2 57.4,115.24 ; J32.2 55.09,114.25 ; J32.2 56.41,115.57 ; 14.41,103.3 J31.4 ; J31.4 14.41,101.33 ; J31.4 16.38,101.33 ; J31.4 14.07,102.32 ; J31.4 15.39,103.64 ; J31.4 15.39,101 ; J31.4 16.71,102.32 ; J31.4 16.38,103.3 ; 60.51,103.3 J33.3 ; J33.3 62.48,101.33 ; J33.3 61.49,101 ; J33.3 62.81,102.32 ; J33.3 61.49,103.64 ; J33.3 62.48,103.3 ; J33.3 60.51,101.33 ; J33.3 60.17,102.32 ; J34.3 82.29,135.56 ; J34.3 81.31,133.25 ; J34.3 80.32,133.59 ; J34.3 81.31,135.89 ; J34.3 82.29,133.59 ; J34.3 82.63,134.57 ; J34.3 80.32,135.56 ; J34.3 79.99,134.57 ; J35.5 75.77,134.57 ; J35.5 73.46,133.59 ; J35.5 73.13,134.57 ; J35.5 75.43,133.59 ; J35.5 74.45,133.25 ; J35.5 74.45,135.89 ; J35.5 75.43,135.56 ; J35.5 73.46,135.56 ; J31.5 21.79,102.32 ; J31.5 19.15,102.32 ; J31.5 21.46,103.3 ; J31.5 20.47,101 ; J31.5 19.49,101.33 ; J31.5 20.47,103.64 ; J31.5 19.49,103.3 ; J31.5 21.46,101.33 ; 26.35,103.3 J30.3 ; J30.3 27.33,103.64 ; J30.3 28.32,101.33 ; J30.3 28.65,102.32 ; J30.3 28.32,103.3 ; J30.3 26.01,102.32 ; J30.3 27.33,101 ; J30.3 26.35,101.33 ; 55.09,97.24 J33.4 ; J33.4 57.73,97.24 ; J33.4 57.4,98.22 ; J33.4 56.41,98.56 ; J33.4 56.41,95.92 ; J33.4 57.4,96.25 ; J33.4 55.43,98.22 ; J33.4 55.43,96.25 ; 31.43,96.25 J30.4 ; J30.4 32.41,98.56 ; J30.4 33.4,98.22 ; J30.4 33.73,97.24 ; J30.4 33.4,96.25 ; J30.4 31.43,98.22 ; J30.4 32.41,95.92 ; J30.4 31.09,97.24 ; 60.17,109.17 J32.5 ; J32.5 62.81,109.17 ; J32.5 61.49,110.49 ; J32.5 60.51,110.16 ; J32.5 62.48,110.16 ; J32.5 60.51,108.19 ; J32.5 61.49,107.85 ; J32.5 62.48,108.19 ; 26.35,98.22 J30.5 ; J30.5 28.32,96.25 ; J30.5 26.35,96.25 ; J30.5 28.65,97.24 ; J30.5 27.33,98.56 ; J30.5 27.33,95.92 ; J30.5 28.32,98.22 ; J30.5 26.01,97.24 ; 73.13,129.49 J35.3 ; J35.3 75.77,129.49 ; J35.3 74.45,128.17 ; J35.3 73.46,130.48 ; J35.3 73.46,128.51 ; J35.3 75.43,128.51 ; J35.3 74.45,130.81 ; J35.3 75.43,130.48 ; J30.2 33.4,101.33 ; J30.2 32.41,103.64 ; J30.2 31.43,103.3 ; J30.2 31.43,101.33 ; J30.2 33.4,103.3 ; J30.2 31.09,102.32 ; J30.2 32.41,101 ; J30.2 33.73,102.32 ; 80.32,128.51 J34.5 ; J34.5 82.29,130.48 ; J34.5 81.31,128.17 ; J34.5 82.63,129.49 ; J34.5 81.31,130.81 ; J34.5 79.99,129.49 ; J34.5 80.32,130.48 ; J34.5 82.29,128.51 ; J35.2 70.35,128.51 ; J35.2 68.05,129.49 ; J35.2 69.37,128.17 ; J35.2 69.37,130.81 ; J35.2 68.38,128.51 ; J35.2 70.69,129.49 ; J35.2 68.38,130.48 ; J35.2 70.35,130.48 ; 68.05,134.57 J35.4 ; J35.4 68.38,135.56 ; J35.4 70.35,135.56 ; J35.4 69.37,133.25 ; J35.4 70.69,134.57 ; J35.4 68.38,133.59 ; J35.4 70.35,133.59 ; J35.4 69.37,135.89 ; 55.09,102.32 J33.5 ; J33.5 57.4,101.33 ; J33.5 55.43,103.3 ; J33.5 57.4,103.3 ; J33.5 55.43,101.33 ; J33.5 57.73,102.32 ; J33.5 56.41,101 ; J33.5 56.41,103.64 ; J31.3 21.46,98.22 ; J31.3 19.49,98.22 ; J31.3 20.47,98.56 ; J31.3 21.79,97.24 ; J31.3 21.46,96.25 ; J31.3 20.47,95.92 ; J31.3 19.15,97.24 ; J31.3 19.49,96.25 ; J33.2 62.81,97.24 ; J33.2 62.48,96.25 ; J33.2 61.49,95.92 ; J33.2 60.17,97.24 ; J33.2 60.51,96.25 ; J33.2 62.48,98.22 ; J33.2 60.51,98.22 ; J33.2 61.49,98.56 ; J31.2 16.38,96.25 ; J31.2 15.39,95.92 ; J31.2 14.41,96.25 ; J31.2 14.41,98.22 ; J31.2 16.38,98.22 ; J31.2 15.39,98.56 ; J31.2 16.71,97.24 ; J31.2 14.07,97.24 ; J32.4 62.48,115.24 ; J32.4 61.49,115.57 ; J32.4 60.51,113.27 ; J32.4 61.49,112.93 ; J32.4 62.81,114.25 ; J32.4 62.48,113.27 ; J32.4 60.51,115.24 ; J32.4 60.17,114.25 ; 56.41,107.85 J32.3 ; J32.3 57.4,108.19 ; J32.3 55.43,110.16 ; J32.3 56.41,110.49 ; J32.3 55.09,109.17 ; J32.3 57.4,110.16 ; J32.3 57.73,109.17 ; J32.3 55.43,108.19 ; 85.07,134.57 J34.2 ; J34.2 86.39,135.89 ; J34.2 85.4,135.56
  12_PWR3 w0.152: v1(137.74,30.91) 137.3,31.36 131.57,31.36 128.84,28.63 120.5,28.63 119.51,29.62 117.74,29.62 116.47,28.35 110.33,28.35 108.5,30.18 84.39,30.18 82.78,31.79 82.78,43.98 82.7,44.06 82.7,45.33 85.1,47.73 91.49,47.73 92.65,48.89 94.31,48.89 94.75,49.34 99.39,49.34 99.73,49.67 99.73,51.09 99.95,51.31 103.35,51.31 103.71,51.66 103.71,59.14 103.92,59.35 104.57,59.35 104.74,59.53 104.74,60.11 104.98,60.35 105.54,60.35 105.75,60.55 105.75,65.64 105.46,65.93 105.07,65.93 104.73,66.28 104.73,67.35 v2(104.24,67.84)
  13_GND w0.381: 44.35,35.98 J96.1 ; J96.1 44.35,34.28 ; J96.1 44.07,35.13 ; J96.1 46.05,35.98 ; J96.1 46.33,35.13 ; J96.1 45.2,36.26 ; J96.1 45.2,34 ; J96.1 46.05,34.28 ; J96.4 49.7,17.26 ; J96.4 50.55,15.28 ; J96.4 48.57,16.13 ; J96.4 50.55,16.98 ; J96.4 50.83,16.13 ; J96.4 48.85,15.28 ; J96.4 49.7,15 ; J96.4 48.85,16.98 ; 228.65,63.92 J52.9 ; J52.9 227.85,64.18 ; J52.9 227.58,64.99 ; J52.9 228.65,66.06 ; J52.9 229.72,64.99 ; J52.9 229.46,64.18 ; J52.9 227.85,65.8 ; J52.9 229.46,65.8 ; 129.57,19.64 MH3.1 ; MH3.1 128.92,21.39 ; MH3.1 129.57,23.13 ; MH3.1 131.32,23.79 ; MH3.1 133.07,19.64 ; MH3.1 131.32,18.99 ; MH3.1 133.72,21.39 ; MH3.1 133.07,23.13 ; 53.76,30.63 J96.2 ; J96.2 54.04,29.78 ; J96.2 54.89,29.5 ; J96.2 56.02,30.63 ; J96.2 55.74,29.78 ; J96.2 55.74,31.48 ; J96.2 54.89,31.76 ; J96.2 54.04,31.48 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 24.65,61.56 ; 25.5,60.71 25.5,59.58 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 24.65,59.86 ; 28.87,41.71 J1.6 ; J1.6 29.15,42.56 ; J1.6 29.15,40.86 ; J1.6 30.85,42.56 ; J1.6 30,42.84 ; J1.6 31.13,41.71 ; J1.6 30,40.58 ; J1.6 30.85,40.86 ; 116.87,139.34 MH2.1 ; MH2.1 120.37,135.84 ; MH2.1 118.62,139.99 ; MH2.1 116.22,137.59 ; MH2.1 121.02,137.59 ; MH2.1 116.87,135.84 ; MH2.1 120.37,139.34 ; MH2.1 118.62,135.19 ; 232.97,43.91 J39.16 ; J39.16 232.16,44.18 ; J39.16 231.9,44.98 ; J39.16 234.03,44.98 ; J39.16 233.77,44.18 ; J39.16 233.77,45.79 ; J39.16 232.97,46.05 ; J39.16 232.16,45.79 ; J23.1 222.8,61.48 ; J23.1 221.19,63.09 ; J23.1 223.06,62.28 ; J23.1 221.19,61.48 ; J23.1 222,61.21 ; J23.1 220.93,62.28 ; J23.1 222.8,63.09 ; J23.1 222,63.35 ; J105.6 104.13,129.14 ; J105.6 103.07,128.07 ; J105.6 102.26,128.34 ; J105.6 103.87,129.95 ; J105.6 102,129.14 ; J105.6 103.87,128.34 ; J105.6 102.26,129.95 ; J105.6 103.07,130.21 ; 38.15,15.28 J96.5 ; J96.5 39.85,15.28 ; J96.5 39,15 ; J96.5 40.13,16.13 ; J96.5 37.87,16.13 ; MH6.1 9.89,9.32 ; MH6.1 9.24,7.57 ; MH6.1 5.74,7.57 ; MH6.1 7.49,6.92 ; MH6.1 9.24,11.07 ; MH6.1 5.09,9.32 ; MH6.1 7.49,11.72 ; MH6.1 5.74,11.07 ; J1.8 13.13,41.71 ; J1.8 12.85,42.56 ; J1.8 12,40.58 ; J1.8 11.15,40.86 ; J1.8 11.15,42.56 ; J1.8 10.87,41.71 ; J1.8 12,42.84 ; J1.8 12.85,40.86 ; J39.10 234.03,37.36 ; J39.10 232.97,38.43 ; J39.10 232.16,38.17 ; J39.10 231.9,37.36 ; J39.10 233.77,36.56 ; J39.10 232.97,36.29 ; J39.10 233.77,38.17 ; J39.10 232.16,36.56 ; 15.65,34.28 J96.10 ; J96.10 17.63,35.13 ; J96.10 17.35,35.98 ; J96.10 15.37,35.13 ; J96.10 16.5,34 ; J96.10 16.5,36.26 ; J96.10 17.35,34.28 ; J96.10 15.65,35.98 ; J1.1 46.05,61.56 ; J1.1 45.2,59.58 ; J1.1 44.35,59.86 ; J1.1 45.2,61.84 ; J1.1 44.07,60.71 ; J1.1 46.05,59.86 ; J1.1 46.33,60.71 ; J1.1 44.35,61.56 ; 26.53,173.84 J10.SH2 ; J10.SH2 27.04,172.45 ; J10.SH2 30.32,173.84 ; 48.85,40.86 J1.4 ; J1.4 50.55,42.56 ; J1.4 49.7,42.84 ; J1.4 50.55,40.86 ; J1.4 48.85,42.56 ; J1.4 49.7,40.58 ; J1.4 48.57,41.71 ; J1.4 50.83,41.71 ; 238.56,80.39 J53.10 ; J53.10 237.49,81.46 ; J53.10 237.75,82.26 ; J53.10 239.36,82.26 ; J53.10 237.75,80.65 ; J53.10 238.56,82.52 ; J53.10 239.36,80.65 ; J53.10 239.62,81.46 ; 232.16,41.64 J39.14 ; J39.14 232.16,43.25 ; J39.14 232.97,43.51 ; J39.14 233.77,43.25 ; J39.14 233.77,41.64 ; J39.14 234.03,42.44 ; J39.14 231.9,42.44 ; J39.14 232.97,41.37 ; J24.1 173.78,145.25 ; J24.1 172.17,143.64 ; J24.1 174.04,144.45 ; J24.1 172.17,145.25 ; J24.1 172.97,143.38 ; J24.1 173.78,143.64 ; J24.1 172.97,145.52 ; J24.1 171.91,144.45 ; J26.1 200.32,128.53 ; J26.1 199.52,128.27 ; J26.1 198.45,129.34 ; J26.1 199.52,130.4 ; J26.1 198.71,128.53 ; J26.1 198.71,130.14 ; J26.1 200.58,129.34 ; J26.1 200.32,130.14 ; 231.9,34.82 J39.8 ; J39.8 233.77,35.63 ; J39.8 232.16,34.02 ; J39.8 233.77,34.02 ; J39.8 232.16,35.63 ; J39.8 232.97,35.89 ; J39.8 232.97,33.75 ; J39.8 234.03,34.82 ; 33.37,60.71 J1.12 ; J1.12 35.35,59.86 ; J1.12 35.63,60.71 ; J1.12 35.35,61.56 ; J1.12 34.5,59.58 ; J1.12 33.65,61.56 ; J1.12 34.5,61.84 ; J1.12 33.65,59.86 ; 28.87,16.13 J96.6 ; J96.6 30.85,15.28 ; J96.6 29.15,15.28 ; J96.6 30,15 ; J96.6 31.13,16.13 ; J96.6 30,17.26 ; J96.6 29.15,16.98 ; J96.6 30.85,16.98 ; J39.12 234.03,39.9 ; J39.12 232.97,38.83 ; J39.12 233.77,40.71 ; J39.12 233.77,39.1 ; J39.12 232.97,40.97 ; J39.12 232.16,40.71 ; J39.12 232.16,39.1 ; J39.12 231.9,39.9 ; 28.7,65.28 J36.1 ; J36.1 29.51,67.15 ; J36.1 29.51,65.54 ; J36.1 27.64,66.34 ; J36.1 27.9,65.54 ; J36.1 28.7,67.41 ; J36.1 29.77,66.34 ; J36.1 27.9,67.15 ; 199.21,35.61 J38.1 ; J38.1 199.47,36.42 ; J38.1 201.08,36.42 ; J38.1 200.28,36.68 ; J38.1 201.08,34.81 ; J38.1 199.47,34.81 ; J38.1 200.28,34.54 ; J38.1 201.35,35.61 ; J39.6 234.03,32.28 ; J39.6 232.97,31.21 ; J39.6 231.9,32.28 ; J39.6 232.16,33.09 ; J39.6 233.77,33.09 ; J39.6 233.77,31.48 ; J39.6 232.97,33.35 ; J39.6 232.16,31.48 ; 7.49,92.32 MH7.1 ; MH7.1 5.09,94.72 ; MH7.1 9.89,94.72 ; MH7.1 5.74,96.46 ; MH7.1 5.74,92.97 ; MH7.1 9.24,92.97 ; MH7.1 9.24,96.46 ; MH7.1 7.49,97.12 ; J110.2 27.74,127.37 ; J110.2 27.74,128.98 ; J110.2 26.94,129.24 ; J110.2 26.13,127.37 ; J110.2 26.13,128.98 ; J110.2 26.94,127.11 ; J110.2 28,128.18 ; J110.2 25.87,128.18 ; 6.37,60.71 J1.9 ; J1.9 7.5,61.84 ; J1.9 8.35,59.86 ; J1.9 6.65,61.56 ; J1.9 8.35,61.56 ; J1.9 6.65,59.86 ; J1.9 7.5,59.58 ; J1.9 8.63,60.71 ; 3.71,147.86 MH4.1 ; MH4.1 5.46,148.51 ; MH4.1 3.71,144.37 ; MH4.1 7.21,144.37 ; MH4.1 3.06,146.11 ; MH4.1 5.46,143.71 ; MH4.1 7.21,147.86 ; MH4.1 7.86,146.11 ; 24.17,89.52 J78.4 ; J78.4 25.78,89.52 ; J78.4 24.97,89.26 ; J78.4 26.04,90.32 ; J78.4 24.17,91.13 ; J78.4 24.97,91.39 ; J78.4 25.78,91.13 ; J78.4 23.9,90.32 ; 223.6,17.49 J25.1 ; J25.1 223.6,15.88 ; J25.1 225.21,17.49 ; J25.1 223.34,16.69 ; J25.1 225.48,16.69 ; J25.1 224.41,17.75 ; J25.1 225.21,15.88 ; J25.1 224.41,15.62 ; J96.12 35.63,35.13 ; J96.12 33.65,34.28 ; J96.12 33.37,35.13 ; J96.12 34.5,34 ; J96.12 34.5,36.26 ; J96.12 35.35,34.28 ; J96.12 33.65,35.98 ; J96.12 35.35,35.98 ; J27.1 48.77,99.03 ; J27.1 49.83,97.97 ; J27.1 47.7,97.97 ; J27.1 47.96,98.77 ; J27.1 49.57,98.77 ; J27.1 47.96,97.16 ; J27.1 49.57,97.16 ; J27.1 48.77,96.9 ; 235.21,82.26 J53.9 ; J53.9 236.02,80.39 ; J53.9 237.08,81.46 ; J53.9 236.82,80.65 ; J53.9 236.82,82.26 ; J53.9 235.21,80.65 ; J53.9 234.95,81.46 ; J53.9 236.02,82.52 ; 198.25,14.48 J5.3 ; J5.3 199.31,15.54 ; J5.3 199.05,16.35 ; J5.3 198.25,16.61 ; J5.3 197.44,16.35 ; J5.3 199.05,14.74 ; J5.3 197.44,14.74 ; U16.6 213.01,133.65 ; U16.6 213.31,134.56 ; U16.6 211.18,133.65 ; U16.6 213.01,135.47 ; U16.6 210.88,134.56 ; U16.6 212.09,135.78 ; U16.6 212.09,133.34 ; U16.6 211.18,135.47 ; 10.27,105.4 J82.2 ; J82.2 11.88,103.79 ; J82.2 11.07,105.66 ; J82.2 11.07,103.53 ; J82.2 11.88,105.4 ; J82.2 10.27,103.79 ; J82.2 12.14,104.59 ; J82.2 10.01,104.59 ; 15.65,59.86 J1.10 ; J1.10 16.5,59.58 ; J1.10 15.65,61.56 ; J1.10 17.63,60.71 ; J1.10 15.37,60.71 ; J1.10 16.5,61.84 ; J1.10 17.35,61.56 ; J1.10 17.35,59.86 ; 24.65,34.28 25.5,35.13 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 24.65,35.98 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 25.5,34 ; J52.10 232.26,64.99 ; J52.10 230.12,64.99 ; J52.10 230.39,64.18 ; J52.10 231.19,66.06 ; J52.10 232,65.8 ; J52.10 231.19,63.92 ; J52.10 230.39,65.8 ; J52.10 232,64.18 ; 196.43,133.98 C499.2 ; C499.2 195.63,135.86 ; C499.2 197.5,135.05 ; C499.2 196.43,136.12 ; C499.2 195.37,135.05 ; C499.2 197.24,135.86 ; C499.2 197.24,134.25 ; C499.2 195.63,134.25 ; 54.04,55.36 J1.2 ; J1.2 53.76,56.21 ; J1.2 55.74,57.06 ; J1.2 54.04,57.06 ; J1.2 54.89,55.08 ; J1.2 54.89,57.34 ; J1.2 55.74,55.36 ; J10.SH1 46.17,172.45 ; J10.SH1 46.67,173.84 ; J10.SH1 42.88,173.84 ; 21,15 J96.7 ; J96.7 22.13,16.13 ; J96.7 21.85,16.98 ; J96.7 21,17.26 ; J96.7 19.87,16.13 ; J96.7 20.15,15.28 ; J96.7 20.15,16.98 ; J96.7 21.85,15.28 ; 54.04,48.16 J1.3 ; J1.3 55.74,49.86 ; J1.3 54.04,49.86 ; J1.3 55.74,48.16 ; J1.3 56.02,49.01 ; J1.3 53.76,49.01 ; J1.3 54.89,50.14 ; J1.3 54.89,47.88 ; MH5.1 237.97,18.33 ; MH5.1 237.97,14.84 ; MH5.1 233.82,16.59 ; MH5.1 238.62,16.59 ; MH5.1 236.22,18.99 ; MH5.1 234.47,18.33 ; MH5.1 236.22,14.19 ; MH5.1 234.47,14.84 ; 39,40.58 J1.5 ; J1.5 38.15,40.86 ; J1.5 37.87,41.71 ; J1.5 40.13,41.71 ; J1.5 39.85,40.86 ; J1.7 21,42.84 ; J1.7 21.85,42.56 ; J1.7 19.87,41.71 ; J1.7 20.15,42.56 ; J1.7 20.15,40.86 ; J1.7 21,40.58 ; J1.7 21.85,40.86 ; J1.7 22.13,41.71 ; 53.76,23.43 J96.3 ; J96.3 54.89,24.56 ; J96.3 54.89,22.3 ; J96.3 54.04,22.58 ; J96.3 56.02,23.43 ; J96.3 55.74,22.58 ; J96.3 55.74,24.28 ; J96.3 54.04,24.28 ; MH1.1 237.97,172.36 ; MH1.1 237.97,168.86 ; MH1.1 233.82,170.61 ; MH1.1 236.22,168.21 ; MH1.1 238.62,170.61 ; MH1.1 234.47,168.86 ; MH1.1 234.47,172.36 ; MH1.1 236.22,173.01 ; J39.4 233.77,30.55 ; J39.4 233.77,28.94 ; J39.4 232.16,30.55 ; J39.4 232.97,30.81 ; J39.4 234.03,29.74 ; J39.4 232.97,28.67 ; J39.4 232.16,28.94 ; J39.4 231.9,29.74 ; J96.9 8.35,35.98 ; J96.9 6.65,35.98 ; J96.9 6.65,34.28 ; J96.9 7.5,34 ; J96.9 6.37,35.13 ; J96.9 8.63,35.13 ; J96.9 7.5,36.26 ; J96.9 8.35,34.28 ; 10.87,16.13 J96.8 ; J96.8 11.15,16.98 ; J96.8 13.13,16.13 ; J96.8 12.85,15.28 ; J96.8 12,15 ; J96.8 12,17.26 ; J96.8 11.15,15.28 ; J96.8 12.85,16.98 ; 205.88,134.56 U16.7 ; U16.7 206.18,133.65 ; U16.7 206.18,135.47 ; U16.7 207.09,135.78 ; U16.7 208.01,135.47 ; U16.7 207.09,133.34 ; U16.7 208.31,134.56 ; U16.7 208.01,133.65 ; 213.38,137.06 U16.5 ; U16.5 213.68,136.15 ; U16.5 215.51,136.15 ; U16.5 214.59,135.84 ; U16.5 213.68,137.97 ; U16.5 215.51,137.97 ; U16.5 215.81,137.06 ; U16.5 214.59,138.28
  13_GND w0.508: 26.35,98.22 J30.5 ; J30.5 27.33,98.56 ; J30.5 26.35,96.25 ; J30.5 26.01,97.24 ; J30.5 28.32,96.25 ; J30.5 27.33,95.92 ; J30.5 28.32,98.22 ; J30.5 28.65,97.24 ; 73.46,133.59 J35.5 ; J35.5 74.45,135.89 ; J35.5 75.43,135.56 ; J35.5 75.43,133.59 ; J35.5 75.77,134.57 ; J35.5 73.46,135.56 ; J35.5 74.45,133.25 ; J35.5 73.13,134.57 ; 68.38,135.56 J35.4 ; J35.4 68.05,134.57 ; J35.4 70.35,135.56 ; J35.4 68.38,133.59 ; J35.4 70.69,134.57 ; J35.4 70.35,133.59 ; J35.4 69.37,135.89 ; J35.4 69.37,133.25 ; J31.4 16.38,101.33 ; J31.4 16.71,102.32 ; J31.4 15.39,103.64 ; J31.4 16.38,103.3 ; J31.4 14.41,103.3 ; J31.4 14.41,101.33 ; J31.4 15.39,101 ; J31.4 14.07,102.32 ; J34.3 82.63,134.57 ; J34.3 81.31,133.25 ; J34.3 81.31,135.89 ; J34.3 79.99,134.57 ; J34.3 82.29,135.56 ; J34.3 80.32,133.59 ; J34.3 80.32,135.56 ; J34.3 82.29,133.59 ; J33.3 61.49,103.64 ; J33.3 60.17,102.32 ; J33.3 60.51,101.33 ; J33.3 61.49,101 ; J33.3 62.48,101.33 ; J33.3 60.51,103.3 ; J33.3 62.48,103.3 ; J33.3 62.81,102.32 ; J34.4 87.37,130.48 ; J34.4 85.4,130.48 ; J34.4 85.07,129.49 ; J34.4 85.4,128.51 ; J34.4 86.39,128.17 ; J34.4 87.37,128.51 ; J34.4 86.39,130.81 ; J34.4 87.71,129.49 ; 61.49,107.85 J32.5 ; J32.5 62.48,110.16 ; J32.5 60.51,108.19 ; J32.5 62.81,109.17 ; J32.5 60.51,110.16 ; J32.5 60.17,109.17 ; J32.5 62.48,108.19 ; J32.5 61.49,110.49 ; J30.2 32.41,103.64 ; J30.2 31.43,103.3 ; J30.2 31.09,102.32 ; J30.2 33.4,103.3 ; J30.2 33.4,101.33 ; J30.2 31.43,101.33 ; J30.2 32.41,101 ; J30.2 33.73,102.32 ; 55.43,101.33 J33.5 ; J33.5 57.4,103.3 ; J33.5 56.41,103.64 ; J33.5 57.4,101.33 ; J33.5 57.73,102.32 ; J33.5 55.43,103.3 ; J33.5 55.09,102.32 ; J33.5 56.41,101 ; 19.15,102.32 J31.5 ; J31.5 20.47,101 ; J31.5 19.49,101.33 ; J31.5 21.79,102.32 ; J31.5 19.49,103.3 ; J31.5 20.47,103.64 ; J31.5 21.46,103.3 ; J31.5 21.46,101.33 ; J34.2 87.37,133.59 ; J34.2 85.4,135.56 ; J34.2 85.4,133.59 ; J34.2 87.71,134.57 ; J34.2 87.37,135.56 ; J34.2 86.39,133.25 ; J34.2 85.07,134.57 ; J34.2 86.39,135.89 ; J32.2 56.41,115.57 ; J32.2 56.41,112.93 ; J32.2 57.4,115.24 ; J32.2 57.4,113.27 ; J32.2 55.09,114.25 ; J32.2 55.43,115.24 ; J32.2 57.73,114.25 ; J32.2 55.43,113.27 ; 55.09,97.24 J33.4 ; J33.4 56.41,95.92 ; J33.4 57.73,97.24 ; J33.4 57.4,96.25 ; J33.4 55.43,98.22 ; J33.4 56.41,98.56 ; J33.4 57.4,98.22 ; J33.4 55.43,96.25 ; 27.33,101 J30.3 ; J30.3 27.33,103.64 ; J30.3 28.32,103.3 ; J30.3 26.01,102.32 ; J30.3 26.35,101.33 ; J30.3 28.65,102.32 ; J30.3 26.35,103.3 ; J30.3 28.32,101.33 ; J34.5 81.31,130.81 ; J34.5 82.29,130.48 ; J34.5 81.31,128.17 ; J34.5 80.32,128.51 ; J34.5 80.32,130.48 ; J34.5 82.63,129.49 ; J34.5 82.29,128.51 ; J34.5 79.99,129.49 ; J30.4 32.41,98.56 ; J30.4 31.43,96.25 ; J30.4 33.4,98.22 ; J30.4 31.09,97.24 ; J30.4 33.4,96.25 ; J30.4 33.73,97.24 ; J30.4 32.41,95.92 ; J30.4 31.43,98.22 ; 56.41,107.85 J32.3 ; J32.3 55.43,108.19 ; J32.3 57.4,110.16 ; J32.3 57.73,109.17 ; J32.3 57.4,108.19 ; J32.3 55.43,110.16 ; J32.3 56.41,110.49 ; J32.3 55.09,109.17 ; 68.05,129.49 J35.2 ; J35.2 70.35,130.48 ; J35.2 70.35,128.51 ; J35.2 69.37,130.81 ; J35.2 68.38,128.51 ; J35.2 68.38,130.48 ; J35.2 70.69,129.49 ; J35.2 69.37,128.17 ; 74.45,128.17 J35.3 ; J35.3 75.43,130.48 ; J35.3 75.43,128.51 ; J35.3 73.13,129.49 ; J35.3 73.46,128.51 ; J35.3 73.46,130.48 ; J35.3 74.45,130.81 ; J35.3 75.77,129.49 ; J31.2 16.71,97.24 ; J31.2 15.39,98.56 ; J31.2 16.38,98.22 ; J31.2 14.41,96.25 ; J31.2 14.07,97.24 ; J31.2 16.38,96.25 ; J31.2 14.41,98.22 ; J31.2 15.39,95.92 ; 60.17,114.25 J32.4 ; J32.4 62.81,114.25 ; J32.4 62.48,115.24 ; J32.4 61.49,112.93 ; J32.4 61.49,115.57 ; J32.4 60.51,113.27 ; J32.4 62.48,113.27 ; J32.4 60.51,115.24 ; J31.3 21.79,97.24 ; J31.3 19.15,97.24 ; J31.3 21.46,98.22 ; J31.3 20.47,95.92 ; J31.3 19.49,98.22 ; J31.3 21.46,96.25 ; J31.3 19.49,96.25 ; J31.3 20.47,98.56 ; 60.51,96.25 J33.2 ; J33.2 61.49,95.92 ; J33.2 60.17,97.24 ; J33.2 62.48,96.25 ; J33.2 60.51,98.22 ; J33.2 61.49,98.56 ; J33.2 62.81,97.24 ; J33.2 62.48,98.22
  14_SIG4 w0.14: v2(131.24,89.84) 130.89,89.84 130.44,89.39 130.05,89.39 129.67,89.02 129.67,88.59 129.43,88.35 129.14,88.35 128.77,87.99 128.77,87.51 128.58,87.32 128.05,87.32 127.7,86.96 127.7,86.63 127.47,86.41 127.06,86.41 126.74,86.09 126.74,81.64 127.04,81.34 127.4,81.34 127.41,81.33 127.44,81.33 127.73,81.05 127.73,80.73 128.18,80.28 128.42,80.28 128.67,80.02 128.67,79.74 129.09,79.32 129.38,79.32 129.76,78.94 129.76,78.7 130.07,78.39 130.37,78.39 130.74,78.02 130.74,75.6 130.47,75.33 130,75.33 129.75,75.08 129.75,74.55 129.53,74.33 126,74.33 125.67,74.01 125.67,73.66 125.4,73.39 125.09,73.39 124.73,73.03 124.73,72.67 124.73,72.66 124.73,72.64 124.43,72.35 124.04,72.35 123.73,72.04 123.73,71.72 123.37,71.35 118.94,71.35 118.49,70.9 118.49,65.59 v2(119.24,64.84)
  14_SIG4 w0.381: 25.5,57.29 25.5,60.71 ; 25.5,60.71 23.03,58.24 ; 25.5,60.71 22.08,60.71 ; 25.5,60.71 27.97,58.24 ; 27.53,39.24 J1.6 ; J1.6 27.53,44.17 ; J1.6 26.58,41.71 ; J1.6 30,38.29 ; MH5.1 236.22,21.27 ; MH5.1 231.53,16.59 ; MH5.1 239.58,19.95 ; MH5.1 232.86,19.95 ; J96.10 18.97,37.6 ; J96.10 16.5,31.72 ; J96.10 14.03,37.6 ; J96.10 16.5,38.55 ; J96.10 14.03,32.67 ; J96.10 18.97,32.67 ; J96.10 19.92,35.13 ; J96.10 13.08,35.13 ; 5.03,37.6 J96.9 ; J96.9 7.5,38.55 ; J96.9 9.97,37.6 ; J96.9 7.5,31.72 ; J96.9 4.08,35.13 ; J96.9 9.97,32.67 ; J96.9 5.03,32.67 ; J96.9 10.92,35.13 ; MH6.1 12.18,9.32 ; MH6.1 4.13,12.69 ; MH6.1 10.86,12.69 ; MH6.1 2.81,9.32 ; MH6.1 10.86,5.96 ; MH6.1 7.49,14.01 ; MH6.1 4.13,5.96 ; 18.53,18.6 J96.7 ; J96.7 23.47,13.67 ; J96.7 18.53,13.67 ; J96.7 17.58,16.13 ; J96.7 24.42,16.13 ; J96.7 21,19.55 ; J96.7 23.47,18.6 ; J1.7 24.42,41.71 ; J1.7 18.53,44.17 ; J1.7 17.58,41.71 ; J1.7 23.47,44.17 ; J1.7 21,38.29 ; J1.7 21,45.12 ; J1.7 18.53,39.24 ; J1.7 23.47,39.24 ; J96.8 15.42,16.13 ; J96.8 14.47,18.6 ; J96.8 9.53,18.6 ; J96.8 9.53,13.67 ; J96.8 14.47,13.67 ; J96.8 12,19.55 ; J96.8 8.58,16.13 ; J96.8 12,12.72 ; 31.08,35.13 J96.12 ; J96.12 32.03,32.67 ; J96.12 32.03,37.6 ; 24.25,173.84 J10.SH2 25.42,170.83 ; J25.1 227.76,16.69 ; J25.1 226.83,14.27 ; J25.1 221.99,19.11 ; J25.1 224.41,20.04 ; J25.1 226.83,19.11 ; J1.8 12,45.12 ; J1.8 14.47,39.24 ; J1.8 12,38.29 ; J1.8 15.42,41.71 ; J1.8 8.58,41.71 ; J1.8 14.47,44.17 ; J1.8 9.53,44.17 ; J1.8 9.53,39.24 ; 197.86,33.19 J38.1 ; J38.1 196.93,35.61 ; J38.1 197.86,38.03 ; 23.03,32.67 25.5,35.13 ; 25.5,35.13 25.5,38.55 ; 25.5,35.13 22.08,35.13 ; 25.5,35.13 27.97,37.6 ; 25.5,35.13 27.97,32.67 ; 25.5,35.13 28.92,35.13 ; 25.5,35.13 25.5,31.72 ; 25.5,35.13 23.03,37.6 ; 14.03,58.24 J1.10 ; J1.10 13.08,60.71 ; J1.10 18.97,58.24 ; J1.10 16.5,57.29 ; J1.9 9.97,58.24 ; J1.9 5.03,58.24 ; J1.9 4.08,60.71 ; J1.9 9.97,63.17 ; J1.9 7.5,57.29 ; J1.9 5.03,63.17 ; J1.9 10.92,60.71 ; 26.58,16.13 J96.6 ; J96.6 27.53,18.6 ; J96.6 33.42,16.13 ; J96.6 27.53,13.67 ; J96.6 32.47,18.6 ; J96.6 30,19.55 ; J96.6 32.47,13.67 ; 232.86,173.98 MH1.1 239.58,173.98 ; 5.46,150.8 MH4.1 2.1,149.48 ; 48.95,173.84 J10.SH1 47.78,170.83 ; 170.55,146.87 J24.1 ; J24.1 169.62,144.45 ; J24.1 172.97,147.8
  14_SIG4 w0.508: 71.85,137.18 J35.5 ; J35.5 74.45,138.18 ; J35.5 77.05,137.18 ; 52.81,97.24 J33.4 53.81,94.63
  15_GND w0.381: J1.8 12.85,42.56 ; J1.8 11.15,42.56 ; J1.8 12.85,40.86 ; J1.8 11.15,40.86 ; J1.8 12,40.58 ; J1.8 10.87,41.71 ; J1.8 13.13,41.71 ; J1.8 12,42.84 ; 20.15,15.28 J96.7 ; J96.7 21.85,16.98 ; J96.7 21,15 ; J96.7 21,17.26 ; J96.7 19.87,16.13 ; J96.7 22.13,16.13 ; J96.7 20.15,16.98 ; J96.7 21.85,15.28 ; 12,15 J96.8 ; J96.8 12,17.26 ; J96.8 10.87,16.13 ; J96.8 13.13,16.13 ; J96.8 12.85,16.98 ; J96.8 11.15,15.28 ; J96.8 12.85,15.28 ; J96.8 11.15,16.98 ; 232.16,34.02 J39.8 ; J39.8 232.97,35.89 ; J39.8 234.03,34.82 ; J39.8 233.77,35.63 ; J39.8 232.97,33.75 ; J39.8 231.9,34.82 ; J39.8 233.77,34.02 ; J39.8 232.16,35.63 ; 26.13,128.98 J110.2 ; J110.2 27.74,128.98 ; J110.2 28,128.18 ; J110.2 25.87,128.18 ; J110.2 27.74,127.37 ; J110.2 26.94,127.11 ; J110.2 26.94,129.24 ; J110.2 26.13,127.37 ; J27.1 49.57,97.16 ; J27.1 47.96,97.16 ; J27.1 47.96,98.77 ; J27.1 48.77,99.03 ; J27.1 49.57,98.77 ; J27.1 47.7,97.97 ; J27.1 49.83,97.97 ; J27.1 48.77,96.9 ; 7.49,6.92 MH6.1 ; MH6.1 5.09,9.32 ; MH6.1 5.74,11.07 ; MH6.1 5.74,7.57 ; MH6.1 7.49,11.72 ; MH6.1 9.24,7.57 ; MH6.1 9.89,9.32 ; MH6.1 9.24,11.07 ; 25.5,59.58 25.5,60.71 ; 25.5,60.71 24.65,61.56 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 24.65,59.86 ; 25.5,60.71 26.35,61.56 ; 235.21,82.26 J53.9 ; J53.9 236.02,82.52 ; J53.9 234.95,81.46 ; J53.9 237.08,81.46 ; J53.9 236.02,80.39 ; J53.9 236.82,80.65 ; J53.9 236.82,82.26 ; J53.9 235.21,80.65 ; J96.12 35.63,35.13 ; J96.12 34.5,34 ; J96.12 35.35,34.28 ; J96.12 33.37,35.13 ; J96.12 34.5,36.26 ; J96.12 33.65,35.98 ; J96.12 35.35,35.98 ; J96.12 33.65,34.28 ; 6.65,61.56 J1.9 ; J1.9 6.65,59.86 ; J1.9 8.63,60.71 ; J1.9 7.5,59.58 ; J1.9 7.5,61.84 ; J1.9 8.35,61.56 ; J1.9 6.37,60.71 ; J1.9 8.35,59.86 ; 5.74,92.97 MH7.1 ; MH7.1 9.24,92.97 ; MH7.1 7.49,92.32 ; MH7.1 9.89,94.72 ; MH7.1 9.24,96.46 ; MH7.1 7.49,97.12 ; MH7.1 5.74,96.46 ; MH7.1 5.09,94.72 ; 27.9,65.54 J36.1 ; J36.1 27.9,67.15 ; J36.1 28.7,65.28 ; J36.1 29.77,66.34 ; J36.1 29.51,65.54 ; J36.1 27.64,66.34 ; J36.1 29.51,67.15 ; J36.1 28.7,67.41 ; J1.2 55.74,57.06 ; J1.2 54.89,55.08 ; J1.2 53.76,56.21 ; J1.2 55.74,55.36 ; J1.2 54.04,57.06 ; J1.2 54.89,57.34 ; J1.2 54.04,55.36 ; J1.6 31.13,41.71 ; J1.6 30.85,40.86 ; J1.6 29.15,42.56 ; J1.6 30,40.58 ; J1.6 29.15,40.86 ; J1.6 30,42.84 ; J1.6 30.85,42.56 ; J1.6 28.87,41.71 ; J52.9 228.65,66.06 ; J52.9 229.46,64.18 ; J52.9 227.58,64.99 ; J52.9 229.72,64.99 ; J52.9 228.65,63.92 ; J52.9 229.46,65.8 ; J52.9 227.85,64.18 ; J52.9 227.85,65.8 ; J23.1 222.8,61.48 ; J23.1 221.19,63.09 ; J23.1 221.19,61.48 ; J23.1 220.93,62.28 ; J23.1 223.06,62.28 ; J23.1 222.8,63.09 ; J23.1 222,61.21 ; J23.1 222,63.35 ; 223.34,16.69 J25.1 ; J25.1 223.6,17.49 ; J25.1 225.21,15.88 ; J25.1 223.6,15.88 ; J25.1 225.21,17.49 ; J25.1 224.41,17.75 ; J25.1 224.41,15.62 ; J25.1 225.48,16.69 ; 5.46,143.71 MH4.1 ; MH4.1 7.21,144.37 ; MH4.1 5.46,148.51 ; MH4.1 3.71,144.37 ; MH4.1 3.71,147.86 ; MH4.1 7.21,147.86 ; MH4.1 7.86,146.11 ; MH4.1 3.06,146.11 ; 198.71,128.53 J26.1 ; J26.1 199.52,128.27 ; J26.1 199.52,130.4 ; J26.1 198.45,129.34 ; J26.1 200.32,130.14 ; J26.1 200.58,129.34 ; J26.1 198.71,130.14 ; J26.1 200.32,128.53 ; 24.65,35.98 25.5,35.13 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 24.65,34.28 ; 25.5,35.13 25.5,34 ; 25.5,35.13 26.35,35.98 ; J96.6 30.85,15.28 ; J96.6 30.85,16.98 ; J96.6 28.87,16.13 ; J96.6 29.15,16.98 ; J96.6 30,17.26 ; J96.6 29.15,15.28 ; J96.6 31.13,16.13 ; J96.6 30,15 ; 213.68,137.97 U16.5 ; U16.5 215.81,137.06 ; U16.5 214.59,135.84 ; U16.5 213.68,136.15 ; U16.5 214.59,138.28 ; U16.5 215.51,136.15 ; U16.5 213.38,137.06 ; U16.5 215.51,137.97 ; 11.07,103.53 J82.2 ; J82.2 12.14,104.59 ; J82.2 10.27,103.79 ; J82.2 11.88,105.4 ; J82.2 10.27,105.4 ; J82.2 10.01,104.59 ; J82.2 11.88,103.79 ; J82.2 11.07,105.66 ; J96.3 55.74,22.58 ; J96.3 56.02,23.43 ; J96.3 54.04,22.58 ; J96.3 54.04,24.28 ; J96.3 53.76,23.43 ; J96.3 54.89,22.3 ; J96.3 55.74,24.28 ; J96.3 54.89,24.56 ; J52.10 232,65.8 ; J52.10 230.39,65.8 ; J52.10 230.39,64.18 ; J52.10 231.19,66.06 ; J52.10 232.26,64.99 ; J52.10 232,64.18 ; J52.10 231.19,63.92 ; J52.10 230.12,64.99 ; 232.16,38.17 J39.10 ; J39.10 232.97,38.43 ; J39.10 232.97,36.29 ; J39.10 234.03,37.36 ; J39.10 231.9,37.36 ; J39.10 233.77,36.56 ; J39.10 233.77,38.17 ; J39.10 232.16,36.56 ; J1.7 21.85,42.56 ; J1.7 19.87,41.71 ; J1.7 21,40.58 ; J1.7 21,42.84 ; J1.7 22.13,41.71 ; J1.7 21.85,40.86 ; J1.7 20.15,40.86 ; J1.7 20.15,42.56 ; 231.9,29.74 J39.4 ; J39.4 232.97,30.81 ; J39.4 232.97,28.67 ; J39.4 234.03,29.74 ; J39.4 233.77,28.94 ; J39.4 232.16,28.94 ; J39.4 233.77,30.55 ; J39.4 232.16,30.55 ; 211.18,135.47 U16.6 ; U16.6 213.01,135.47 ; U16.6 213.31,134.56 ; U16.6 211.18,133.65 ; U16.6 212.09,133.34 ; U16.6 213.01,133.65 ; U16.6 212.09,135.78 ; U16.6 210.88,134.56 ; 15.65,34.28 J96.10 ; J96.10 17.63,35.13 ; J96.10 17.35,34.28 ; J96.10 16.5,36.26 ; J96.10 15.37,35.13 ; J96.10 15.65,35.98 ; J96.10 17.35,35.98 ; J96.10 16.5,34 ; MH5.1 237.97,18.33 ; MH5.1 238.62,16.59 ; MH5.1 234.47,18.33 ; MH5.1 236.22,14.19 ; MH5.1 236.22,18.99 ; MH5.1 234.47,14.84 ; MH5.1 237.97,14.84 ; MH5.1 233.82,16.59 ; J1.3 55.74,49.86 ; J1.3 54.04,49.86 ; J1.3 55.74,48.16 ; J1.3 54.89,50.14 ; J1.3 54.04,48.16 ; J1.3 54.89,47.88 ; J1.3 56.02,49.01 ; J1.3 53.76,49.01 ; 129.57,19.64 MH3.1 ; MH3.1 129.57,23.13 ; MH3.1 131.32,23.79 ; MH3.1 128.92,21.39 ; MH3.1 133.72,21.39 ; MH3.1 133.07,23.13 ; MH3.1 131.32,18.99 ; MH3.1 133.07,19.64 ; 48.85,42.56 J1.4 ; J1.4 50.55,42.56 ; J1.4 49.7,42.84 ; J1.4 49.7,40.58 ; J1.4 50.83,41.71 ; J1.4 48.57,41.71 ; J1.4 48.85,40.86 ; J1.4 50.55,40.86 ; 39,40.58 J1.5 ; J1.5 38.15,40.86 ; J1.5 39.85,40.86 ; J1.5 40.13,41.71 ; J1.5 37.87,41.71 ; 34.5,59.58 J1.12 ; J1.12 35.63,60.71 ; J1.12 33.65,59.86 ; J1.12 33.65,61.56 ; J1.12 34.5,61.84 ; J1.12 35.35,61.56 ; J1.12 35.35,59.86 ; J1.12 33.37,60.71 ; J96.9 8.35,35.98 ; J96.9 6.65,35.98 ; J96.9 7.5,34 ; J96.9 7.5,36.26 ; J96.9 8.63,35.13 ; J96.9 8.35,34.28 ; J96.9 6.65,34.28 ; J96.9 6.37,35.13 ; J38.1 201.08,34.81 ; J38.1 199.21,35.61 ; J38.1 200.28,34.54 ; J38.1 199.47,36.42 ; J38.1 200.28,36.68 ; J38.1 201.08,36.42 ; J38.1 199.47,34.81 ; J38.1 201.35,35.61 ; 42.88,173.84 J10.SH1 ; J10.SH1 46.17,172.45 ; J10.SH1 46.67,173.84 ; 232.16,41.64 J39.14 ; J39.14 231.9,42.44 ; J39.14 233.77,43.25 ; J39.14 233.77,41.64 ; J39.14 232.97,41.37 ; J39.14 234.03,42.44 ; J39.14 232.16,43.25 ; J39.14 232.97,43.51 ; 48.57,16.13 J96.4 ; J96.4 49.7,15 ; J96.4 50.55,15.28 ; J96.4 49.7,17.26 ; J96.4 50.83,16.13 ; J96.4 48.85,16.98 ; J96.4 48.85,15.28 ; J96.4 50.55,16.98 ; 24.17,89.52 J78.4 ; J78.4 25.78,91.13 ; J78.4 24.97,91.39 ; J78.4 25.78,89.52 ; J78.4 24.97,89.26 ; J78.4 24.17,91.13 ; J78.4 26.04,90.32 ; J78.4 23.9,90.32 ; 232.16,40.71 J39.12 ; J39.12 233.77,40.71 ; J39.12 231.9,39.9 ; J39.12 232.97,40.97 ; J39.12 232.97,38.83 ; J39.12 234.03,39.9 ; J39.12 232.16,39.1 ; J39.12 233.77,39.1 ; J1.1 46.05,59.86 ; J1.1 45.2,59.58 ; J1.1 44.07,60.71 ; J1.1 44.35,59.86 ; J1.1 44.35,61.56 ; J1.1 45.2,61.84 ; J1.1 46.33,60.71 ; J1.1 46.05,61.56 ; 39,15 J96.5 ; J96.5 37.87,16.13 ; J96.5 38.15,15.28 ; J96.5 40.13,16.13 ; J96.5 39.85,15.28 ; 172.17,145.25 J24.1 ; J24.1 172.97,145.52 ; J24.1 172.17,143.64 ; J24.1 174.04,144.45 ; J24.1 172.97,143.38 ; J24.1 173.78,143.64 ; J24.1 173.78,145.25 ; J24.1 171.91,144.45 ; 195.63,134.25 C499.2 ; C499.2 197.24,135.86 ; C499.2 195.37,135.05 ; C499.2 196.43,133.98 ; C499.2 196.43,136.12 ; C499.2 197.24,134.25 ; C499.2 197.5,135.05 ; C499.2 195.63,135.86 ; 102.26,128.34 J105.6 ; J105.6 102,129.14 ; J105.6 104.13,129.14 ; J105.6 103.07,130.21 ; J105.6 103.07,128.07 ; J105.6 103.87,129.95 ; J105.6 103.87,128.34 ; J105.6 102.26,129.95 ; 54.04,29.78 J96.2 ; J96.2 55.74,29.78 ; J96.2 54.04,31.48 ; J96.2 54.89,31.76 ; J96.2 53.76,30.63 ; J96.2 55.74,31.48 ; J96.2 54.89,29.5 ; J96.2 56.02,30.63 ; 116.87,135.84 MH2.1 ; MH2.1 120.37,139.34 ; MH2.1 120.37,135.84 ; MH2.1 116.87,139.34 ; MH2.1 118.62,139.99 ; MH2.1 121.02,137.59 ; MH2.1 116.22,137.59 ; MH2.1 118.62,135.19 ; 197.44,14.74 J5.3 ; J5.3 198.25,16.61 ; J5.3 199.31,15.54 ; J5.3 199.05,14.74 ; J5.3 199.05,16.35 ; J5.3 197.44,16.35 ; J5.3 198.25,14.48 ; 234.47,168.86 MH1.1 ; MH1.1 237.97,168.86 ; MH1.1 233.82,170.61 ; MH1.1 236.22,173.01 ; MH1.1 236.22,168.21 ; MH1.1 237.97,172.36 ; MH1.1 238.62,170.61 ; MH1.1 234.47,172.36 ; 206.18,133.65 U16.7 ; U16.7 205.88,134.56 ; U16.7 206.18,135.47 ; U16.7 207.09,133.34 ; U16.7 208.31,134.56 ; U16.7 208.01,133.65 ; U16.7 208.01,135.47 ; U16.7 207.09,135.78 ; J39.16 232.97,46.05 ; J39.16 232.16,45.79 ; J39.16 231.9,44.98 ; J39.16 233.77,44.18 ; J39.16 233.77,45.79 ; J39.16 234.03,44.98 ; J39.16 232.16,44.18 ; J39.16 232.97,43.91 ; J1.10 17.35,61.56 ; J1.10 15.65,61.56 ; J1.10 17.35,59.86 ; J1.10 16.5,61.84 ; J1.10 15.37,60.71 ; J1.10 15.65,59.86 ; J1.10 16.5,59.58 ; J1.10 17.63,60.71 ; 44.35,34.28 J96.1 ; J96.1 45.2,34 ; J96.1 46.05,35.98 ; J96.1 46.33,35.13 ; J96.1 44.07,35.13 ; J96.1 44.35,35.98 ; J96.1 46.05,34.28 ; J96.1 45.2,36.26 ; J39.6 234.03,32.28 ; J39.6 233.77,31.48 ; J39.6 232.16,31.48 ; J39.6 232.97,33.35 ; J39.6 232.16,33.09 ; J39.6 232.97,31.21 ; J39.6 231.9,32.28 ; J39.6 233.77,33.09 ; 237.75,80.65 J53.10 ; J53.10 239.36,82.26 ; J53.10 238.56,82.52 ; J53.10 239.36,80.65 ; J53.10 237.75,82.26 ; J53.10 238.56,80.39 ; J53.10 237.49,81.46 ; J53.10 239.62,81.46 ; 26.53,173.84 J10.SH2 ; J10.SH2 27.04,172.45 ; J10.SH2 30.32,173.84
  15_GND w0.508: 68.38,130.48 J35.2 ; J35.2 70.35,130.48 ; J35.2 69.37,130.81 ; J35.2 68.38,128.51 ; J35.2 70.35,128.51 ; J35.2 68.05,129.49 ; J35.2 70.69,129.49 ; J35.2 69.37,128.17 ; 56.41,112.93 J32.2 ; J32.2 55.43,113.27 ; J32.2 57.73,114.25 ; J32.2 56.41,115.57 ; J32.2 57.4,115.24 ; J32.2 55.43,115.24 ; J32.2 55.09,114.25 ; J32.2 57.4,113.27 ; J31.5 21.46,101.33 ; J31.5 21.79,102.32 ; J31.5 20.47,103.64 ; J31.5 19.49,101.33 ; J31.5 19.49,103.3 ; J31.5 19.15,102.32 ; J31.5 20.47,101 ; J31.5 21.46,103.3 ; J34.3 81.31,135.89 ; J34.3 79.99,134.57 ; J34.3 82.29,135.56 ; J34.3 80.32,133.59 ; J34.3 81.31,133.25 ; J34.3 80.32,135.56 ; J34.3 82.63,134.57 ; J34.3 82.29,133.59 ; J33.2 62.48,96.25 ; J33.2 60.51,96.25 ; J33.2 61.49,98.56 ; J33.2 60.17,97.24 ; J33.2 62.48,98.22 ; J33.2 61.49,95.92 ; J33.2 62.81,97.24 ; J33.2 60.51,98.22 ; 55.43,103.3 J33.5 ; J33.5 56.41,103.64 ; J33.5 55.43,101.33 ; J33.5 55.09,102.32 ; J33.5 57.73,102.32 ; J33.5 57.4,103.3 ; J33.5 57.4,101.33 ; J33.5 56.41,101 ; 19.49,98.22 J31.3 ; J31.3 19.49,96.25 ; J31.3 20.47,98.56 ; J31.3 20.47,95.92 ; J31.3 21.79,97.24 ; J31.3 21.46,96.25 ; J31.3 19.15,97.24 ; J31.3 21.46,98.22 ; 61.49,112.93 J32.4 ; J32.4 62.48,113.27 ; J32.4 61.49,115.57 ; J32.4 62.48,115.24 ; J32.4 60.17,114.25 ; J32.4 62.81,114.25 ; J32.4 60.51,115.24 ; J32.4 60.51,113.27 ; J34.4 87.37,130.48 ; J34.4 85.4,130.48 ; J34.4 85.07,129.49 ; J34.4 87.37,128.51 ; J34.4 86.39,130.81 ; J34.4 86.39,128.17 ; J34.4 87.71,129.49 ; J34.4 85.4,128.51 ; 55.43,98.22 J33.4 ; J33.4 56.41,98.56 ; J33.4 55.43,96.25 ; J33.4 56.41,95.92 ; J33.4 57.73,97.24 ; J33.4 57.4,96.25 ; J33.4 55.09,97.24 ; J33.4 57.4,98.22 ; 26.35,103.3 J30.3 ; J30.3 27.33,103.64 ; J30.3 26.01,102.32 ; J30.3 26.35,101.33 ; J30.3 27.33,101 ; J30.3 28.65,102.32 ; J30.3 28.32,101.33 ; J30.3 28.32,103.3 ; J33.3 62.48,103.3 ; J33.3 60.51,101.33 ; J33.3 62.81,102.32 ; J33.3 62.48,101.33 ; J33.3 61.49,101 ; J33.3 60.17,102.32 ; J33.3 60.51,103.3 ; J33.3 61.49,103.64 ; J31.2 16.71,97.24 ; J31.2 14.41,96.25 ; J31.2 14.41,98.22 ; J31.2 15.39,95.92 ; J31.2 16.38,98.22 ; J31.2 16.38,96.25 ; J31.2 14.07,97.24 ; J31.2 15.39,98.56 ; 31.43,96.25 J30.4 ; J30.4 32.41,95.92 ; J30.4 33.4,96.25 ; J30.4 32.41,98.56 ; J30.4 33.4,98.22 ; J30.4 33.73,97.24 ; J30.4 31.09,97.24 ; J30.4 31.43,98.22 ; J34.5 82.29,128.51 ; J34.5 80.32,130.48 ; J34.5 79.99,129.49 ; J34.5 81.31,128.17 ; J34.5 80.32,128.51 ; J34.5 82.63,129.49 ; J34.5 82.29,130.48 ; J34.5 81.31,130.81 ; 31.43,103.3 J30.2 ; J30.2 33.4,103.3 ; J30.2 31.43,101.33 ; J30.2 32.41,103.64 ; J30.2 33.73,102.32 ; J30.2 31.09,102.32 ; J30.2 33.4,101.33 ; J30.2 32.41,101 ; 56.41,107.85 J32.3 ; J32.3 56.41,110.49 ; J32.3 57.4,108.19 ; J32.3 55.43,108.19 ; J32.3 57.73,109.17 ; J32.3 57.4,110.16 ; J32.3 55.43,110.16 ; J32.3 55.09,109.17 ; J35.4 70.35,135.56 ; J35.4 68.38,135.56 ; J35.4 68.05,134.57 ; J35.4 69.37,133.25 ; J35.4 70.35,133.59 ; J35.4 69.37,135.89 ; J35.4 70.69,134.57 ; J35.4 68.38,133.59 ; 60.51,110.16 J32.5 ; J32.5 62.48,108.19 ; J32.5 62.81,109.17 ; J32.5 61.49,110.49 ; J32.5 61.49,107.85 ; J32.5 60.51,108.19 ; J32.5 62.48,110.16 ; J32.5 60.17,109.17 ; J30.5 28.32,96.25 ; J30.5 26.35,96.25 ; J30.5 28.65,97.24 ; J30.5 27.33,95.92 ; J30.5 28.32,98.22 ; J30.5 26.01,97.24 ; J30.5 27.33,98.56 ; J30.5 26.35,98.22 ; J35.3 75.43,128.51 ; J35.3 73.13,129.49 ; J35.3 74.45,128.17 ; J35.3 74.45,130.81 ; J35.3 73.46,128.51 ; J35.3 73.46,130.48 ; J35.3 75.43,130.48 ; J35.3 75.77,129.49 ; 14.07,102.32 J31.4 ; J31.4 15.39,103.64 ; J31.4 16.71,102.32 ; J31.4 14.41,101.33 ; J31.4 16.38,101.33 ; J31.4 15.39,101 ; J31.4 14.41,103.3 ; J31.4 16.38,103.3 ; J35.5 75.43,135.56 ; J35.5 75.77,134.57 ; J35.5 73.13,134.57 ; J35.5 73.46,135.56 ; J35.5 74.45,135.89 ; J35.5 73.46,133.59 ; J35.5 74.45,133.25 ; J35.5 75.43,133.59 ; J34.2 87.37,135.56 ; J34.2 85.4,135.56 ; J34.2 85.4,133.59 ; J34.2 87.37,133.59 ; J34.2 87.71,134.57 ; J34.2 86.39,133.25 ; J34.2 86.39,135.89 ; J34.2 85.07,134.57
  16_SIG5 w0.381: J96.10 18.97,37.6 ; J96.10 19.92,35.13 ; J96.10 14.03,37.6 ; J96.10 13.08,35.13 ; J96.10 16.5,31.72 ; J96.10 16.5,38.55 ; J96.10 18.97,32.67 ; J96.10 14.03,32.67 ; 30,38.29 J1.6 ; J1.6 30,45.12 ; J1.6 32.47,39.24 ; J1.6 27.53,44.17 ; J1.6 27.53,39.24 ; J1.6 32.47,44.17 ; J1.6 26.58,41.71 ; J25.1 227.76,16.69 ; J25.1 221.99,19.11 ; J25.1 226.83,19.11 ; J25.1 226.83,14.27 ; J25.1 224.41,20.04 ; 48.62,35.13 J96.1 47.67,37.6 ; MH5.1 239.58,19.95 ; MH5.1 236.22,21.27 ; MH5.1 231.53,16.59 ; MH5.1 232.86,19.95 ; 8.58,16.13 J96.8 ; J96.8 12,19.55 ; J96.8 14.47,13.67 ; J96.8 14.47,18.6 ; J96.8 15.42,16.13 ; J96.8 9.53,13.67 ; J96.8 9.53,18.6 ; J96.8 12,12.72 ; 25.5,31.72 25.5,35.13 ; 25.5,35.13 27.97,37.6 ; 25.5,35.13 28.92,35.13 ; 25.5,35.13 25.5,38.55 ; 25.5,35.13 27.97,32.67 ; 25.5,35.13 23.03,32.67 ; 25.5,35.13 22.08,35.13 ; 25.5,35.13 23.03,37.6 ; 239.58,173.98 MH1.1 232.86,173.98 ; 32.03,37.6 J96.12 ; J96.12 32.03,32.67 ; J96.12 31.08,35.13 ; 12,38.29 J1.8 ; J1.8 14.47,39.24 ; J1.8 9.53,39.24 ; J1.8 12,45.12 ; J1.8 14.47,44.17 ; J1.8 15.42,41.71 ; J1.8 8.58,41.71 ; J1.8 9.53,44.17 ; 7.49,90.03 MH7.1 ; MH7.1 12.18,94.72 ; MH7.1 4.13,98.08 ; MH7.1 2.81,94.72 ; MH7.1 4.13,91.35 ; MH7.1 10.86,91.35 ; MH7.1 7.49,99.4 ; MH7.1 10.86,98.08 ; J1.10 18.97,58.24 ; J1.10 13.08,60.71 ; J1.10 14.03,58.24 ; J1.10 16.5,57.29 ; 194.01,132.63 C499.2 196.43,131.7 ; 24.25,173.84 J10.SH2 25.42,170.83 ; 196.93,35.61 J38.1 ; J38.1 197.86,38.03 ; J38.1 197.86,33.19 ; 22.08,60.71 25.5,60.71 ; 25.5,60.71 23.03,58.24 ; 25.5,60.71 25.5,57.29 ; 7.5,57.29 J1.9 ; J1.9 9.97,58.24 ; J1.9 4.08,60.71 ; J1.9 5.03,63.17 ; J1.9 5.03,58.24 ; J1.9 10.92,60.71 ; J1.9 9.97,63.17 ; J1.12 37.92,60.71 ; J1.12 36.97,58.24 ; J1.12 34.5,57.29 ; 4.08,35.13 J96.9 ; J96.9 5.03,32.67 ; J96.9 7.5,31.72 ; J96.9 10.92,35.13 ; J96.9 5.03,37.6 ; J96.9 9.97,37.6 ; J96.9 7.5,38.55 ; J96.9 9.97,32.67 ; 18.53,18.6 J96.7 ; J96.7 24.42,16.13 ; J96.7 23.47,18.6 ; J96.7 17.58,16.13 ; J96.7 18.53,13.67 ; J96.7 23.47,13.67 ; J96.7 21,19.55 ; J1.7 21,45.12 ; J1.7 23.47,39.24 ; J1.7 21,38.29 ; J1.7 18.53,44.17 ; J1.7 23.47,44.17 ; J1.7 18.53,39.24 ; J1.7 17.58,41.71 ; J1.7 24.42,41.71 ; MH6.1 10.86,12.69 ; MH6.1 12.18,9.32 ; MH6.1 4.13,5.96 ; MH6.1 10.86,5.96 ; MH6.1 7.49,14.01 ; MH6.1 4.13,12.69 ; MH6.1 2.81,9.32 ; 36.53,13.67 J96.5 ; J96.5 41.47,13.67 ; J96.5 35.58,16.13 ; J96.6 33.42,16.13 ; J96.6 26.58,16.13 ; J96.6 30,19.55 ; J96.6 32.47,13.67 ; J96.6 32.47,18.6 ; J96.6 27.53,18.6 ; J96.6 27.53,13.67 ; 47.23,39.24 J1.4 49.7,38.29
  16_SIG5 w0.508: 11.79,97.24 J31.2 ; J31.2 12.79,94.63 ; J31.2 15.39,93.63
  17_GND w0.381: 197.44,14.74 J5.3 ; J5.3 199.31,15.54 ; J5.3 198.25,16.61 ; J5.3 198.25,14.48 ; J5.3 199.05,16.35 ; J5.3 197.44,16.35 ; J5.3 199.05,14.74 ; 45.2,34 J96.1 ; J96.1 44.35,35.98 ; J96.1 46.05,35.98 ; J96.1 46.33,35.13 ; J96.1 45.2,36.26 ; J96.1 44.35,34.28 ; J96.1 46.05,34.28 ; J96.1 44.07,35.13 ; 198.45,129.34 J26.1 ; J26.1 198.71,130.14 ; J26.1 199.52,128.27 ; J26.1 200.32,130.14 ; J26.1 200.58,129.34 ; J26.1 199.52,130.4 ; J26.1 200.32,128.53 ; J26.1 198.71,128.53 ; 214.59,135.84 U16.5 ; U16.5 214.59,138.28 ; U16.5 213.68,137.97 ; U16.5 215.51,136.15 ; U16.5 215.81,137.06 ; U16.5 215.51,137.97 ; U16.5 213.68,136.15 ; U16.5 213.38,137.06 ; 26.13,127.37 J110.2 ; J110.2 28,128.18 ; J110.2 26.94,127.11 ; J110.2 27.74,127.37 ; J110.2 26.13,128.98 ; J110.2 26.94,129.24 ; J110.2 25.87,128.18 ; J110.2 27.74,128.98 ; J96.9 8.35,34.28 ; J96.9 7.5,34 ; J96.9 7.5,36.26 ; J96.9 6.37,35.13 ; J96.9 8.63,35.13 ; J96.9 6.65,35.98 ; J96.9 8.35,35.98 ; J96.9 6.65,34.28 ; 232.97,38.83 J39.12 ; J39.12 231.9,39.9 ; J39.12 232.16,39.1 ; J39.12 233.77,40.71 ; J39.12 232.97,40.97 ; J39.12 234.03,39.9 ; J39.12 232.16,40.71 ; J39.12 233.77,39.1 ; 5.74,96.46 MH7.1 ; MH7.1 7.49,92.32 ; MH7.1 5.09,94.72 ; MH7.1 5.74,92.97 ; MH7.1 7.49,97.12 ; MH7.1 9.89,94.72 ; MH7.1 9.24,92.97 ; MH7.1 9.24,96.46 ; 231.9,37.36 J39.10 ; J39.10 232.16,36.56 ; J39.10 233.77,36.56 ; J39.10 232.16,38.17 ; J39.10 233.77,38.17 ; J39.10 232.97,38.43 ; J39.10 232.97,36.29 ; J39.10 234.03,37.36 ; 48.85,42.56 J1.4 ; J1.4 49.7,40.58 ; J1.4 50.83,41.71 ; J1.4 50.55,40.86 ; J1.4 49.7,42.84 ; J1.4 50.55,42.56 ; J1.4 48.85,40.86 ; J1.4 48.57,41.71 ; J25.1 225.48,16.69 ; J25.1 223.6,15.88 ; J25.1 223.6,17.49 ; J25.1 225.21,17.49 ; J25.1 225.21,15.88 ; J25.1 224.41,15.62 ; J25.1 224.41,17.75 ; J25.1 223.34,16.69 ; J105.6 103.87,128.34 ; J105.6 104.13,129.14 ; J105.6 103.07,128.07 ; J105.6 103.07,130.21 ; J105.6 102.26,129.95 ; J105.6 102,129.14 ; J105.6 103.87,129.95 ; J105.6 102.26,128.34 ; 5.46,143.71 MH4.1 ; MH4.1 7.21,147.86 ; MH4.1 3.71,147.86 ; MH4.1 5.46,148.51 ; MH4.1 7.21,144.37 ; MH4.1 3.06,146.11 ; MH4.1 7.86,146.11 ; MH4.1 3.71,144.37 ; J96.12 35.35,34.28 ; J96.12 35.35,35.98 ; J96.12 33.37,35.13 ; J96.12 33.65,34.28 ; J96.12 33.65,35.98 ; J96.12 35.63,35.13 ; J96.12 34.5,36.26 ; J96.12 34.5,34 ; U16.7 207.09,135.78 ; U16.7 205.88,134.56 ; U16.7 206.18,133.65 ; U16.7 207.09,133.34 ; U16.7 208.31,134.56 ; U16.7 206.18,135.47 ; U16.7 208.01,133.65 ; U16.7 208.01,135.47 ; J96.5 40.13,16.13 ; J96.5 39,15 ; J96.5 38.15,15.28 ; J96.5 39.85,15.28 ; J96.5 37.87,16.13 ; J23.1 222,63.35 ; J23.1 222.8,61.48 ; J23.1 221.19,61.48 ; J23.1 221.19,63.09 ; J23.1 222.8,63.09 ; J23.1 223.06,62.28 ; J23.1 220.93,62.28 ; J23.1 222,61.21 ; 235.21,80.65 J53.9 ; J53.9 235.21,82.26 ; J53.9 234.95,81.46 ; J53.9 236.82,80.65 ; J53.9 236.82,82.26 ; J53.9 236.02,80.39 ; J53.9 236.02,82.52 ; J53.9 237.08,81.46 ; 33.65,61.56 J1.12 ; J1.12 35.35,59.86 ; J1.12 35.63,60.71 ; J1.12 34.5,59.58 ; J1.12 33.37,60.71 ; J1.12 33.65,59.86 ; J1.12 34.5,61.84 ; J1.12 35.35,61.56 ; J39.6 234.03,32.28 ; J39.6 233.77,33.09 ; J39.6 232.97,31.21 ; J39.6 232.97,33.35 ; J39.6 232.16,33.09 ; J39.6 231.9,32.28 ; J39.6 233.77,31.48 ; J39.6 232.16,31.48 ; J1.6 30,42.84 ; J1.6 29.15,40.86 ; J1.6 28.87,41.71 ; J1.6 30.85,40.86 ; J1.6 30.85,42.56 ; J1.6 31.13,41.71 ; J1.6 30,40.58 ; J1.6 29.15,42.56 ; J96.2 54.89,31.76 ; J96.2 54.04,31.48 ; J96.2 55.74,31.48 ; J96.2 54.89,29.5 ; J96.2 55.74,29.78 ; J96.2 56.02,30.63 ; J96.2 54.04,29.78 ; J96.2 53.76,30.63 ; J39.4 233.77,30.55 ; J39.4 233.77,28.94 ; J39.4 234.03,29.74 ; J39.4 232.97,28.67 ; J39.4 232.97,30.81 ; J39.4 232.16,30.55 ; J39.4 232.16,28.94 ; J39.4 231.9,29.74 ; J10.SH1 46.67,173.84 ; J10.SH1 42.88,173.84 ; J10.SH1 46.17,172.45 ; 6.65,59.86 J1.9 ; J1.9 8.63,60.71 ; J1.9 6.65,61.56 ; J1.9 8.35,59.86 ; J1.9 7.5,61.84 ; J1.9 8.35,61.56 ; J1.9 7.5,59.58 ; J1.9 6.37,60.71 ; J39.8 233.77,35.63 ; J39.8 232.97,33.75 ; J39.8 231.9,34.82 ; J39.8 233.77,34.02 ; J39.8 232.16,35.63 ; J39.8 232.16,34.02 ; J39.8 234.03,34.82 ; J39.8 232.97,35.89 ; J39.14 232.97,43.51 ; J39.14 231.9,42.44 ; J39.14 232.16,43.25 ; J39.14 234.03,42.44 ; J39.14 233.77,43.25 ; J39.14 233.77,41.64 ; J39.14 232.97,41.37 ; J39.14 232.16,41.64 ; 199.47,34.81 J38.1 ; J38.1 199.47,36.42 ; J38.1 201.08,36.42 ; J38.1 199.21,35.61 ; J38.1 201.35,35.61 ; J38.1 200.28,36.68 ; J38.1 200.28,34.54 ; J38.1 201.08,34.81 ; J96.6 31.13,16.13 ; J96.6 29.15,15.28 ; J96.6 28.87,16.13 ; J96.6 30,17.26 ; J96.6 29.15,16.98 ; J96.6 30.85,15.28 ; J96.6 30.85,16.98 ; J96.6 30,15 ; 28.7,65.28 J36.1 ; J36.1 27.64,66.34 ; J36.1 29.77,66.34 ; J36.1 29.51,67.15 ; J36.1 29.51,65.54 ; J36.1 27.9,65.54 ; J36.1 27.9,67.15 ; J36.1 28.7,67.41 ; J24.1 174.04,144.45 ; J24.1 173.78,145.25 ; J24.1 172.17,143.64 ; J24.1 172.97,143.38 ; J24.1 172.97,145.52 ; J24.1 172.17,145.25 ; J24.1 173.78,143.64 ; J24.1 171.91,144.45 ; C499.2 196.43,136.12 ; C499.2 197.5,135.05 ; C499.2 197.24,135.86 ; C499.2 195.63,135.86 ; C499.2 196.43,133.98 ; C499.2 197.24,134.25 ; C499.2 195.63,134.25 ; C499.2 195.37,135.05 ; 232.16,44.18 J39.16 ; J39.16 232.16,45.79 ; J39.16 234.03,44.98 ; J39.16 232.97,46.05 ; J39.16 231.9,44.98 ; J39.16 232.97,43.91 ; J39.16 233.77,45.79 ; J39.16 233.77,44.18 ; 116.87,135.84 MH2.1 ; MH2.1 118.62,135.19 ; MH2.1 116.22,137.59 ; MH2.1 118.62,139.99 ; MH2.1 121.02,137.59 ; MH2.1 120.37,139.34 ; MH2.1 120.37,135.84 ; MH2.1 116.87,139.34 ; J10.SH2 30.32,173.84 ; J10.SH2 26.53,173.84 ; J10.SH2 27.04,172.45 ; 16.5,59.58 J1.10 ; J1.10 17.63,60.71 ; J1.10 16.5,61.84 ; J1.10 15.65,59.86 ; J1.10 15.65,61.56 ; J1.10 17.35,59.86 ; J1.10 15.37,60.71 ; J1.10 17.35,61.56 ; 212.09,133.34 U16.6 ; U16.6 211.18,135.47 ; U16.6 213.01,133.65 ; U16.6 211.18,133.65 ; U16.6 213.31,134.56 ; U16.6 213.01,135.47 ; U16.6 210.88,134.56 ; U16.6 212.09,135.78 ; J1.2 55.74,55.36 ; J1.2 53.76,56.21 ; J1.2 54.04,55.36 ; J1.2 54.89,55.08 ; J1.2 54.04,57.06 ; J1.2 55.74,57.06 ; J1.2 54.89,57.34 ; J96.8 12.85,16.98 ; J96.8 12,17.26 ; J96.8 12.85,15.28 ; J96.8 11.15,15.28 ; J96.8 10.87,16.13 ; J96.8 12,15 ; J96.8 13.13,16.13 ; J96.8 11.15,16.98 ; 7.49,6.92 MH6.1 ; MH6.1 5.74,11.07 ; MH6.1 5.09,9.32 ; MH6.1 7.49,11.72 ; MH6.1 9.24,11.07 ; MH6.1 9.89,9.32 ; MH6.1 9.24,7.57 ; MH6.1 5.74,7.57 ; J1.8 13.13,41.71 ; J1.8 12.85,40.86 ; J1.8 11.15,40.86 ; J1.8 12,42.84 ; J1.8 12,40.58 ; J1.8 11.15,42.56 ; J1.8 12.85,42.56 ; J1.8 10.87,41.71 ; J52.9 229.46,64.18 ; J52.9 227.58,64.99 ; J52.9 227.85,65.8 ; J52.9 228.65,63.92 ; J52.9 228.65,66.06 ; J52.9 227.85,64.18 ; J52.9 229.46,65.8 ; J52.9 229.72,64.99 ; 238.56,80.39 J53.10 ; J53.10 239.36,82.26 ; J53.10 239.62,81.46 ; J53.10 237.75,80.65 ; J53.10 237.75,82.26 ; J53.10 238.56,82.52 ; J53.10 237.49,81.46 ; J53.10 239.36,80.65 ; 38.15,40.86 J1.5 ; J1.5 39,40.58 ; J1.5 40.13,41.71 ; J1.5 39.85,40.86 ; J1.5 37.87,41.71 ; J82.2 11.07,105.66 ; J82.2 11.88,103.79 ; J82.2 11.88,105.4 ; J82.2 10.01,104.59 ; J82.2 12.14,104.59 ; J82.2 10.27,105.4 ; J82.2 11.07,103.53 ; J82.2 10.27,103.79 ; J1.1 45.2,61.84 ; J1.1 46.05,61.56 ; J1.1 46.33,60.71 ; J1.1 44.35,61.56 ; J1.1 44.35,59.86 ; J1.1 45.2,59.58 ; J1.1 44.07,60.71 ; J1.1 46.05,59.86 ; J96.4 50.55,15.28 ; J96.4 49.7,15 ; J96.4 50.55,16.98 ; J96.4 50.83,16.13 ; J96.4 48.85,15.28 ; J96.4 49.7,17.26 ; J96.4 48.57,16.13 ; J96.4 48.85,16.98 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 24.65,61.56 ; 25.5,60.71 24.65,59.86 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 25.5,59.58 ; 233.82,170.61 MH1.1 ; MH1.1 238.62,170.61 ; MH1.1 237.97,168.86 ; MH1.1 234.47,172.36 ; MH1.1 236.22,168.21 ; MH1.1 236.22,173.01 ; MH1.1 237.97,172.36 ; MH1.1 234.47,168.86 ; J52.10 231.19,66.06 ; J52.10 230.39,65.8 ; J52.10 232.26,64.99 ; J52.10 232,65.8 ; J52.10 232,64.18 ; J52.10 230.39,64.18 ; J52.10 231.19,63.92 ; J52.10 230.12,64.99 ; 21,40.58 J1.7 ; J1.7 20.15,40.86 ; J1.7 20.15,42.56 ; J1.7 22.13,41.71 ; J1.7 21.85,40.86 ; J1.7 21.85,42.56 ; J1.7 19.87,41.71 ; J1.7 21,42.84 ; 53.76,49.01 J1.3 ; J1.3 54.89,50.14 ; J1.3 54.89,47.88 ; J1.3 54.04,48.16 ; J1.3 55.74,49.86 ; J1.3 55.74,48.16 ; J1.3 54.04,49.86 ; J1.3 56.02,49.01 ; 233.82,16.59 MH5.1 ; MH5.1 236.22,14.19 ; MH5.1 238.62,16.59 ; MH5.1 234.47,14.84 ; MH5.1 236.22,18.99 ; MH5.1 237.97,14.84 ; MH5.1 234.47,18.33 ; MH5.1 237.97,18.33 ; J96.10 17.63,35.13 ; J96.10 15.37,35.13 ; J96.10 16.5,34 ; J96.10 17.35,35.98 ; J96.10 15.65,34.28 ; J96.10 15.65,35.98 ; J96.10 16.5,36.26 ; J96.10 17.35,34.28 ; 24.17,91.13 J78.4 ; J78.4 24.97,91.39 ; J78.4 25.78,89.52 ; J78.4 25.78,91.13 ; J78.4 26.04,90.32 ; J78.4 23.9,90.32 ; J78.4 24.97,89.26 ; J78.4 24.17,89.52 ; 20.15,15.28 J96.7 ; J96.7 22.13,16.13 ; J96.7 19.87,16.13 ; J96.7 21,17.26 ; J96.7 21,15 ; J96.7 21.85,16.98 ; J96.7 20.15,16.98 ; J96.7 21.85,15.28 ; 129.57,23.13 MH3.1 ; MH3.1 131.32,18.99 ; MH3.1 131.32,23.79 ; MH3.1 133.07,23.13 ; MH3.1 128.92,21.39 ; MH3.1 133.07,19.64 ; MH3.1 133.72,21.39 ; MH3.1 129.57,19.64 ; 24.65,34.28 25.5,35.13 ; 25.5,35.13 25.5,34 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 24.65,35.98 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 26.63,35.13 ; 54.04,24.28 J96.3 ; J96.3 54.89,22.3 ; J96.3 56.02,23.43 ; J96.3 54.04,22.58 ; J96.3 55.74,22.58 ; J96.3 53.76,23.43 ; J96.3 55.74,24.28 ; J96.3 54.89,24.56 ; 48.77,96.9 J27.1 ; J27.1 47.96,98.77 ; J27.1 48.77,99.03 ; J27.1 47.96,97.16 ; J27.1 49.57,98.77 ; J27.1 49.83,97.97 ; J27.1 47.7,97.97 ; J27.1 49.57,97.16
  17_GND w0.508: 73.46,128.51 J35.3 ; J35.3 74.45,128.17 ; J35.3 75.43,128.51 ; J35.3 73.13,129.49 ; J35.3 74.45,130.81 ; J35.3 75.77,129.49 ; J35.3 73.46,130.48 ; J35.3 75.43,130.48 ; 74.45,133.25 J35.5 ; J35.5 75.43,133.59 ; J35.5 75.77,134.57 ; J35.5 73.13,134.57 ; J35.5 73.46,135.56 ; J35.5 74.45,135.89 ; J35.5 73.46,133.59 ; J35.5 75.43,135.56 ; 55.43,103.3 J33.5 ; J33.5 56.41,101 ; J33.5 55.09,102.32 ; J33.5 57.4,103.3 ; J33.5 57.4,101.33 ; J33.5 55.43,101.33 ; J33.5 57.73,102.32 ; J33.5 56.41,103.64 ; 60.17,97.24 J33.2 ; J33.2 61.49,95.92 ; J33.2 60.51,98.22 ; J33.2 61.49,98.56 ; J33.2 62.48,96.25 ; J33.2 62.48,98.22 ; J33.2 62.81,97.24 ; J33.2 60.51,96.25 ; 60.51,115.24 J32.4 ; J32.4 62.48,113.27 ; J32.4 60.51,113.27 ; J32.4 62.48,115.24 ; J32.4 61.49,115.57 ; J32.4 62.81,114.25 ; J32.4 60.17,114.25 ; J32.4 61.49,112.93 ; 68.38,135.56 J35.4 ; J35.4 68.05,134.57 ; J35.4 68.38,133.59 ; J35.4 69.37,133.25 ; J35.4 70.69,134.57 ; J35.4 70.35,133.59 ; J35.4 69.37,135.89 ; J35.4 70.35,135.56 ; J30.5 28.32,96.25 ; J30.5 26.35,98.22 ; J30.5 28.65,97.24 ; J30.5 27.33,98.56 ; J30.5 26.35,96.25 ; J30.5 28.32,98.22 ; J30.5 26.01,97.24 ; J30.5 27.33,95.92 ; J31.3 20.47,98.56 ; J31.3 20.47,95.92 ; J31.3 19.49,98.22 ; J31.3 19.15,97.24 ; J31.3 21.46,96.25 ; J31.3 21.46,98.22 ; J31.3 19.49,96.25 ; J31.3 21.79,97.24 ; 14.41,98.22 J31.2 ; J31.2 16.71,97.24 ; J31.2 15.39,98.56 ; J31.2 14.41,96.25 ; J31.2 14.07,97.24 ; J31.2 16.38,96.25 ; J31.2 16.38,98.22 ; J31.2 15.39,95.92 ; J31.5 21.79,102.32 ; J31.5 19.15,102.32 ; J31.5 20.47,103.64 ; J31.5 19.49,103.3 ; J31.5 20.47,101 ; J31.5 19.49,101.33 ; J31.5 21.46,101.33 ; J31.5 21.46,103.3 ; 31.09,102.32 J30.2 ; J30.2 32.41,103.64 ; J30.2 31.43,101.33 ; J30.2 32.41,101 ; J30.2 33.73,102.32 ; J30.2 31.43,103.3 ; J30.2 33.4,103.3 ; J30.2 33.4,101.33 ; 26.01,102.32 J30.3 ; J30.3 26.35,103.3 ; J30.3 26.35,101.33 ; J30.3 28.32,103.3 ; J30.3 28.32,101.33 ; J30.3 27.33,103.64 ; J30.3 28.65,102.32 ; J30.3 27.33,101 ; J34.4 87.71,129.49 ; J34.4 85.4,130.48 ; J34.4 86.39,128.17 ; J34.4 86.39,130.81 ; J34.4 87.37,130.48 ; J34.4 85.07,129.49 ; J34.4 85.4,128.51 ; J34.4 87.37,128.51 ; J31.4 16.71,102.32 ; J31.4 15.39,101 ; J31.4 15.39,103.64 ; J31.4 16.38,103.3 ; J31.4 14.41,103.3 ; J31.4 14.41,101.33 ; J31.4 14.07,102.32 ; J31.4 16.38,101.33 ; J30.4 33.4,96.25 ; J30.4 31.43,98.22 ; J30.4 31.09,97.24 ; J30.4 32.41,98.56 ; J30.4 32.41,95.92 ; J30.4 31.43,96.25 ; J30.4 33.4,98.22 ; J30.4 33.73,97.24 ; J34.3 81.31,135.89 ; J34.3 82.29,135.56 ; J34.3 82.29,133.59 ; J34.3 80.32,133.59 ; J34.3 79.99,134.57 ; J34.3 81.31,133.25 ; J34.3 80.32,135.56 ; J34.3 82.63,134.57 ; 55.43,98.22 J33.4 ; J33.4 55.09,97.24 ; J33.4 56.41,98.56 ; J33.4 57.4,96.25 ; J33.4 56.41,95.92 ; J33.4 57.73,97.24 ; J33.4 55.43,96.25 ; J33.4 57.4,98.22 ; 85.4,135.56 J34.2 ; J34.2 87.71,134.57 ; J34.2 86.39,133.25 ; J34.2 86.39,135.89 ; J34.2 85.07,134.57 ; J34.2 87.37,133.59 ; J34.2 87.37,135.56 ; J34.2 85.4,133.59 ; 60.17,109.17 J32.5 ; J32.5 61.49,107.85 ; J32.5 60.51,110.16 ; J32.5 62.81,109.17 ; J32.5 62.48,110.16 ; J32.5 61.49,110.49 ; J32.5 60.51,108.19 ; J32.5 62.48,108.19 ; J34.5 82.63,129.49 ; J34.5 82.29,130.48 ; J34.5 80.32,128.51 ; J34.5 79.99,129.49 ; J34.5 81.31,128.17 ; J34.5 80.32,130.48 ; J34.5 82.29,128.51 ; J34.5 81.31,130.81 ; 60.17,102.32 J33.3 ; J33.3 62.48,101.33 ; J33.3 61.49,101 ; J33.3 62.48,103.3 ; J33.3 62.81,102.32 ; J33.3 60.51,103.3 ; J33.3 60.51,101.33 ; J33.3 61.49,103.64 ; 55.43,115.24 J32.2 ; J32.2 56.41,112.93 ; J32.2 57.4,113.27 ; J32.2 55.09,114.25 ; J32.2 56.41,115.57 ; J32.2 57.4,115.24 ; J32.2 57.73,114.25 ; J32.2 55.43,113.27 ; 69.37,128.17 J35.2 ; J35.2 68.38,130.48 ; J35.2 68.38,128.51 ; J35.2 70.69,129.49 ; J35.2 69.37,130.81 ; J35.2 68.05,129.49 ; J35.2 70.35,128.51 ; J35.2 70.35,130.48 ; J32.3 57.73,109.17 ; J32.3 57.4,110.16 ; J32.3 56.41,107.85 ; J32.3 55.09,109.17 ; J32.3 55.43,110.16 ; J32.3 56.41,110.49 ; J32.3 55.43,108.19 ; J32.3 57.4,108.19
  18_SIG6 w0.381: 18.53,18.6 J96.7 ; J96.7 23.47,13.67 ; J96.7 18.53,13.67 ; J96.7 17.58,16.13 ; J96.7 24.42,16.13 ; J96.7 23.47,18.6 ; J96.7 21,19.55 ; 7.49,90.03 MH7.1 ; MH7.1 7.49,99.4 ; MH7.1 4.13,98.08 ; MH7.1 4.13,91.35 ; MH7.1 2.81,94.72 ; 239.58,19.95 MH5.1 236.22,21.27 ; MH6.1 7.49,14.01 ; MH6.1 10.86,5.96 ; MH6.1 10.86,12.69 ; MH6.1 4.13,12.69 ; MH6.1 2.81,9.32 ; MH6.1 12.18,9.32 ; MH6.1 4.13,5.96 ; J96.6 33.42,16.13 ; J96.6 27.53,13.67 ; J96.6 27.53,18.6 ; J96.6 26.58,16.13 ; J96.6 32.47,13.67 ; 23.03,37.6 25.5,35.13 ; 25.5,35.13 22.08,35.13 ; 25.5,35.13 23.03,32.67 ; 4.08,60.71 J1.9 ; J1.9 10.92,60.71 ; J1.9 5.03,58.24 ; J1.9 9.97,58.24 ; J1.9 7.5,57.29 ; J1.9 9.97,63.17 ; J1.9 5.03,63.17 ; J96.8 14.47,13.67 ; J96.8 15.42,16.13 ; J96.8 9.53,18.6 ; J96.8 8.58,16.13 ; J96.8 14.47,18.6 ; J96.8 9.53,13.67 ; J96.8 12,19.55 ; J96.8 12,12.72 ; J1.8 14.47,39.24 ; J1.8 12,38.29 ; J1.8 8.58,41.71 ; J1.8 15.42,41.71 ; J1.8 14.47,44.17 ; J1.8 9.53,44.17 ; J1.8 12,45.12 ; J1.8 9.53,39.24 ; J1.7 21,45.12 ; J1.7 18.53,44.17 ; J1.7 21,38.29 ; J1.7 23.47,39.24 ; J1.7 23.47,44.17 ; J1.7 17.58,41.71 ; J1.7 24.42,41.71 ; J1.7 18.53,39.24 ; J96.10 16.5,38.55 ; J96.10 19.92,35.13 ; J96.10 18.97,37.6 ; J96.10 14.03,37.6 ; J96.10 18.97,32.67 ; J96.10 14.03,32.67 ; J96.10 16.5,31.72 ; J96.10 13.08,35.13 ; J96.9 9.97,32.67 ; J96.9 5.03,32.67 ; J96.9 10.92,35.13 ; J96.9 7.5,38.55 ; J96.9 7.5,31.72 ; J96.9 5.03,37.6 ; J96.9 9.97,37.6 ; J96.9 4.08,35.13 ; J1.10 18.97,58.24 ; J1.10 13.08,60.71 ; J1.10 14.03,58.24 ; J1.10 16.5,57.29 ; 24.25,173.84 J10.SH2 25.42,170.83 ; 232.86,173.98 MH1.1 239.58,173.98 ; 54.89,59.62 J1.2 51.47,56.21 ; 22.08,60.71 25.5,60.71 23.03,58.24 ; J96.5 41.47,13.67 ; J96.5 35.58,16.13 ; J96.5 36.53,13.67
  19_GND w0.381: J39.16 233.77,44.18 ; J39.16 232.97,43.91 ; J39.16 234.03,44.98 ; J39.16 232.16,45.79 ; J39.16 232.97,46.05 ; J39.16 231.9,44.98 ; J39.16 232.16,44.18 ; J39.16 233.77,45.79 ; 6.37,60.71 J1.9 ; J1.9 6.65,61.56 ; J1.9 7.5,61.84 ; J1.9 8.63,60.71 ; J1.9 8.35,61.56 ; J1.9 6.65,59.86 ; J1.9 7.5,59.58 ; J1.9 8.35,59.86 ; MH6.1 9.24,7.57 ; MH6.1 5.09,9.32 ; MH6.1 5.74,7.57 ; MH6.1 7.49,11.72 ; MH6.1 9.24,11.07 ; MH6.1 5.74,11.07 ; MH6.1 7.49,6.92 ; MH6.1 9.89,9.32 ; 26.53,173.84 J10.SH2 ; J10.SH2 27.04,172.45 ; J10.SH2 30.32,173.84 ; J82.2 11.88,103.79 ; J82.2 11.88,105.4 ; J82.2 11.07,103.53 ; J82.2 10.27,103.79 ; J82.2 11.07,105.66 ; J82.2 10.27,105.4 ; J82.2 12.14,104.59 ; J82.2 10.01,104.59 ; 232.97,31.21 J39.6 ; J39.6 233.77,31.48 ; J39.6 232.16,31.48 ; J39.6 232.97,33.35 ; J39.6 231.9,32.28 ; J39.6 233.77,33.09 ; J39.6 232.16,33.09 ; J39.6 234.03,32.28 ; 3.71,147.86 MH4.1 ; MH4.1 5.46,148.51 ; MH4.1 7.21,147.86 ; MH4.1 5.46,143.71 ; MH4.1 7.21,144.37 ; MH4.1 3.71,144.37 ; MH4.1 7.86,146.11 ; MH4.1 3.06,146.11 ; J1.10 17.35,61.56 ; J1.10 15.65,59.86 ; J1.10 17.35,59.86 ; J1.10 15.37,60.71 ; J1.10 16.5,61.84 ; J1.10 16.5,59.58 ; J1.10 17.63,60.71 ; J1.10 15.65,61.56 ; 33.65,59.86 J1.12 ; J1.12 35.35,59.86 ; J1.12 33.37,60.71 ; J1.12 34.5,59.58 ; J1.12 35.35,61.56 ; J1.12 33.65,61.56 ; J1.12 34.5,61.84 ; J1.12 35.63,60.71 ; J96.8 13.13,16.13 ; J96.8 12,17.26 ; J96.8 12.85,15.28 ; J96.8 10.87,16.13 ; J96.8 12,15 ; J96.8 12.85,16.98 ; J96.8 11.15,15.28 ; J96.8 11.15,16.98 ; J25.1 224.41,17.75 ; J25.1 223.6,17.49 ; J25.1 224.41,15.62 ; J25.1 223.34,16.69 ; J25.1 225.21,17.49 ; J25.1 223.6,15.88 ; J25.1 225.48,16.69 ; J25.1 225.21,15.88 ; C499.2 196.43,136.12 ; C499.2 196.43,133.98 ; C499.2 197.24,135.86 ; C499.2 195.63,134.25 ; C499.2 195.63,135.86 ; C499.2 195.37,135.05 ; C499.2 197.24,134.25 ; C499.2 197.5,135.05 ; 26.13,127.37 J110.2 ; J110.2 27.74,127.37 ; J110.2 26.94,129.24 ; J110.2 26.94,127.11 ; J110.2 26.13,128.98 ; J110.2 27.74,128.98 ; J110.2 25.87,128.18 ; J110.2 28,128.18 ; J26.1 200.32,130.14 ; J26.1 198.71,130.14 ; J26.1 198.71,128.53 ; J26.1 199.52,128.27 ; J26.1 198.45,129.34 ; J26.1 199.52,130.4 ; J26.1 200.58,129.34 ; J26.1 200.32,128.53 ; 33.37,35.13 J96.12 ; J96.12 34.5,36.26 ; J96.12 34.5,34 ; J96.12 33.65,34.28 ; J96.12 33.65,35.98 ; J96.12 35.63,35.13 ; J96.12 35.35,35.98 ; J96.12 35.35,34.28 ; J10.SH1 46.67,173.84 ; J10.SH1 42.88,173.84 ; J10.SH1 46.17,172.45 ; 28.87,16.13 J96.6 ; J96.6 31.13,16.13 ; J96.6 30.85,16.98 ; J96.6 30.85,15.28 ; J96.6 30,15 ; J96.6 29.15,15.28 ; J96.6 29.15,16.98 ; J96.6 30,17.26 ; MH7.1 9.24,92.97 ; MH7.1 5.74,92.97 ; MH7.1 5.74,96.46 ; MH7.1 7.49,97.12 ; MH7.1 7.49,92.32 ; MH7.1 9.89,94.72 ; MH7.1 5.09,94.72 ; MH7.1 9.24,96.46 ; J96.10 16.5,36.26 ; J96.10 16.5,34 ; J96.10 17.63,35.13 ; J96.10 15.65,34.28 ; J96.10 15.65,35.98 ; J96.10 17.35,34.28 ; J96.10 15.37,35.13 ; J96.10 17.35,35.98 ; J1.1 46.05,59.86 ; J1.1 44.35,59.86 ; J1.1 45.2,61.84 ; J1.1 44.35,61.56 ; J1.1 46.05,61.56 ; J1.1 45.2,59.58 ; J1.1 46.33,60.71 ; J1.1 44.07,60.71 ; U16.7 207.09,135.78 ; U16.7 208.01,135.47 ; U16.7 206.18,133.65 ; U16.7 206.18,135.47 ; U16.7 207.09,133.34 ; U16.7 205.88,134.56 ; U16.7 208.01,133.65 ; U16.7 208.31,134.56 ; J1.8 12.85,40.86 ; J1.8 12.85,42.56 ; J1.8 13.13,41.71 ; J1.8 11.15,42.56 ; J1.8 12,42.84 ; J1.8 12,40.58 ; J1.8 11.15,40.86 ; J1.8 10.87,41.71 ; 44.35,35.98 J96.1 ; J96.1 44.07,35.13 ; J96.1 44.35,34.28 ; J96.1 46.33,35.13 ; J96.1 46.05,34.28 ; J96.1 46.05,35.98 ; J96.1 45.2,34 ; J96.1 45.2,36.26 ; 54.89,55.08 J1.2 ; J1.2 54.89,57.34 ; J1.2 55.74,55.36 ; J1.2 53.76,56.21 ; J1.2 54.04,55.36 ; J1.2 55.74,57.06 ; J1.2 54.04,57.06 ; J1.4 49.7,42.84 ; J1.4 49.7,40.58 ; J1.4 48.57,41.71 ; J1.4 48.85,42.56 ; J1.4 50.83,41.71 ; J1.4 48.85,40.86 ; J1.4 50.55,40.86 ; J1.4 50.55,42.56 ; 212.09,133.34 U16.6 ; U16.6 210.88,134.56 ; U16.6 211.18,135.47 ; U16.6 212.09,135.78 ; U16.6 213.01,133.65 ; U16.6 213.01,135.47 ; U16.6 211.18,133.65 ; U16.6 213.31,134.56 ; 199.47,34.81 J38.1 ; J38.1 201.08,34.81 ; J38.1 200.28,34.54 ; J38.1 201.35,35.61 ; J38.1 199.21,35.61 ; J38.1 199.47,36.42 ; J38.1 200.28,36.68 ; J38.1 201.08,36.42 ; 24.65,34.28 25.5,35.13 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 25.5,34 ; 25.5,35.13 25.5,36.26 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 24.65,35.98 ; 25.5,35.13 26.63,35.13 ; 131.32,18.99 MH3.1 ; MH3.1 133.07,23.13 ; MH3.1 133.07,19.64 ; MH3.1 131.32,23.79 ; MH3.1 128.92,21.39 ; MH3.1 129.57,19.64 ; MH3.1 133.72,21.39 ; MH3.1 129.57,23.13 ; 227.58,64.99 J52.9 ; J52.9 229.46,65.8 ; J52.9 229.72,64.99 ; J52.9 229.46,64.18 ; J52.9 227.85,64.18 ; J52.9 228.65,63.92 ; J52.9 228.65,66.06 ; J52.9 227.85,65.8 ; 48.85,16.98 J96.4 ; J96.4 48.57,16.13 ; J96.4 50.83,16.13 ; J96.4 48.85,15.28 ; J96.4 49.7,15 ; J96.4 50.55,15.28 ; J96.4 49.7,17.26 ; J96.4 50.55,16.98 ; J96.3 56.02,23.43 ; J96.3 54.04,22.58 ; J96.3 54.89,24.56 ; J96.3 54.89,22.3 ; J96.3 55.74,22.58 ; J96.3 55.74,24.28 ; J96.3 53.76,23.43 ; J96.3 54.04,24.28 ; 20.15,15.28 J96.7 ; J96.7 22.13,16.13 ; J96.7 19.87,16.13 ; J96.7 21.85,15.28 ; J96.7 21,17.26 ; J96.7 21.85,16.98 ; J96.7 21,15 ; J96.7 20.15,16.98 ; 231.9,42.44 J39.14 ; J39.14 232.97,41.37 ; J39.14 234.03,42.44 ; J39.14 232.16,41.64 ; J39.14 232.97,43.51 ; J39.14 233.77,41.64 ; J39.14 232.16,43.25 ; J39.14 233.77,43.25 ; 232.16,40.71 J39.12 ; J39.12 233.77,39.1 ; J39.12 233.77,40.71 ; J39.12 232.97,40.97 ; J39.12 234.03,39.9 ; J39.12 231.9,39.9 ; J39.12 232.16,39.1 ; J39.12 232.97,38.83 ; 232.16,30.55 J39.4 ; J39.4 231.9,29.74 ; J39.4 234.03,29.74 ; J39.4 233.77,30.55 ; J39.4 232.97,30.81 ; J39.4 232.16,28.94 ; J39.4 233.77,28.94 ; J39.4 232.97,28.67 ; 6.65,35.98 J96.9 ; J96.9 8.35,35.98 ; J96.9 8.63,35.13 ; J96.9 7.5,34 ; J96.9 6.65,34.28 ; J96.9 8.35,34.28 ; J96.9 7.5,36.26 ; J96.9 6.37,35.13 ; J36.1 28.7,67.41 ; J36.1 28.7,65.28 ; J36.1 27.64,66.34 ; J36.1 29.77,66.34 ; J36.1 29.51,67.15 ; J36.1 27.9,67.15 ; J36.1 27.9,65.54 ; J36.1 29.51,65.54 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 26.35,61.56 ; 25.5,60.71 24.65,59.86 ; 25.5,60.71 24.65,61.56 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 25.5,59.58 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 26.35,59.86 ; 102.26,128.34 J105.6 ; J105.6 102.26,129.95 ; J105.6 104.13,129.14 ; J105.6 102,129.14 ; J105.6 103.07,130.21 ; J105.6 103.87,128.34 ; J105.6 103.87,129.95 ; J105.6 103.07,128.07 ; J53.9 236.82,82.26 ; J53.9 236.82,80.65 ; J53.9 236.02,80.39 ; J53.9 236.02,82.52 ; J53.9 237.08,81.46 ; J53.9 235.21,82.26 ; J53.9 234.95,81.46 ; J53.9 235.21,80.65 ; J96.5 40.13,16.13 ; J96.5 38.15,15.28 ; J96.5 39.85,15.28 ; J96.5 37.87,16.13 ; J96.5 39,15 ; 21,40.58 J1.7 ; J1.7 22.13,41.71 ; J1.7 21.85,42.56 ; J1.7 20.15,42.56 ; J1.7 19.87,41.71 ; J1.7 21.85,40.86 ; J1.7 21,42.84 ; J1.7 20.15,40.86 ; U16.5 215.51,136.15 ; U16.5 213.68,137.97 ; U16.5 213.68,136.15 ; U16.5 215.81,137.06 ; U16.5 215.51,137.97 ; U16.5 214.59,135.84 ; U16.5 213.38,137.06 ; U16.5 214.59,138.28 ; 232.16,36.56 J39.10 ; J39.10 232.97,38.43 ; J39.10 232.97,36.29 ; J39.10 233.77,38.17 ; J39.10 233.77,36.56 ; J39.10 234.03,37.36 ; J39.10 231.9,37.36 ; J39.10 232.16,38.17 ; 47.96,97.16 J27.1 ; J27.1 49.57,98.77 ; J27.1 47.7,97.97 ; J27.1 48.77,96.9 ; J27.1 48.77,99.03 ; J27.1 49.83,97.97 ; J27.1 49.57,97.16 ; J27.1 47.96,98.77 ; J53.10 239.36,82.26 ; J53.10 237.75,80.65 ; J53.10 238.56,80.39 ; J53.10 237.75,82.26 ; J53.10 239.36,80.65 ; J53.10 237.49,81.46 ; J53.10 239.62,81.46 ; J53.10 238.56,82.52 ; 234.47,172.36 MH1.1 ; MH1.1 233.82,170.61 ; MH1.1 236.22,168.21 ; MH1.1 234.47,168.86 ; MH1.1 236.22,173.01 ; MH1.1 237.97,172.36 ; MH1.1 238.62,170.61 ; MH1.1 237.97,168.86 ; J5.3 198.25,16.61 ; J5.3 197.44,16.35 ; J5.3 199.05,14.74 ; J5.3 198.25,14.48 ; J5.3 197.44,14.74 ; J5.3 199.05,16.35 ; J5.3 199.31,15.54 ; 53.76,30.63 J96.2 ; J96.2 55.74,31.48 ; J96.2 54.89,31.76 ; J96.2 55.74,29.78 ; J96.2 54.04,31.48 ; J96.2 54.89,29.5 ; J96.2 56.02,30.63 ; J96.2 54.04,29.78 ; 220.93,62.28 J23.1 ; J23.1 221.19,61.48 ; J23.1 221.19,63.09 ; J23.1 223.06,62.28 ; J23.1 222.8,63.09 ; J23.1 222.8,61.48 ; J23.1 222,61.21 ; J23.1 222,63.35 ; J1.3 56.02,49.01 ; J1.3 53.76,49.01 ; J1.3 55.74,48.16 ; J1.3 55.74,49.86 ; J1.3 54.04,48.16 ; J1.3 54.04,49.86 ; J1.3 54.89,50.14 ; J1.3 54.89,47.88 ; MH2.1 120.37,139.34 ; MH2.1 120.37,135.84 ; MH2.1 121.02,137.59 ; MH2.1 116.87,139.34 ; MH2.1 116.22,137.59 ; MH2.1 118.62,135.19 ; MH2.1 116.87,135.84 ; MH2.1 118.62,139.99 ; J52.10 232,64.18 ; J52.10 230.39,65.8 ; J52.10 232,65.8 ; J52.10 230.12,64.99 ; J52.10 231.19,66.06 ; J52.10 231.19,63.92 ; J52.10 232.26,64.99 ; J52.10 230.39,64.18 ; J1.6 30,42.84 ; J1.6 31.13,41.71 ; J1.6 30,40.58 ; J1.6 28.87,41.71 ; J1.6 29.15,40.86 ; J1.6 30.85,42.56 ; J1.6 29.15,42.56 ; J1.6 30.85,40.86 ; J78.4 26.04,90.32 ; J78.4 24.97,89.26 ; J78.4 25.78,89.52 ; J78.4 24.17,89.52 ; J78.4 25.78,91.13 ; J78.4 24.17,91.13 ; J78.4 24.97,91.39 ; J78.4 23.9,90.32 ; 232.16,34.02 J39.8 ; J39.8 233.77,35.63 ; J39.8 232.97,33.75 ; J39.8 232.97,35.89 ; J39.8 234.03,34.82 ; J39.8 231.9,34.82 ; J39.8 233.77,34.02 ; J39.8 232.16,35.63 ; 39,40.58 J1.5 ; J1.5 39.85,40.86 ; J1.5 40.13,41.71 ; J1.5 37.87,41.71 ; J1.5 38.15,40.86 ; 234.47,18.33 MH5.1 ; MH5.1 236.22,18.99 ; MH5.1 238.62,16.59 ; MH5.1 234.47,14.84 ; MH5.1 236.22,14.19 ; MH5.1 237.97,14.84 ; MH5.1 237.97,18.33 ; MH5.1 233.82,16.59 ; J24.1 173.78,145.25 ; J24.1 174.04,144.45 ; J24.1 173.78,143.64 ; J24.1 172.97,145.52 ; J24.1 172.17,143.64 ; J24.1 172.97,143.38 ; J24.1 171.91,144.45 ; J24.1 172.17,145.25
  19_GND w0.508: J32.2 56.41,115.57 ; J32.2 56.41,112.93 ; J32.2 57.4,113.27 ; J32.2 55.43,113.27 ; J32.2 57.4,115.24 ; J32.2 57.73,114.25 ; J32.2 55.43,115.24 ; J32.2 55.09,114.25 ; 14.41,103.3 J31.4 ; J31.4 16.38,101.33 ; J31.4 14.41,101.33 ; J31.4 15.39,101 ; J31.4 16.71,102.32 ; J31.4 14.07,102.32 ; J31.4 15.39,103.64 ; J31.4 16.38,103.3 ; 31.43,96.25 J30.4 ; J30.4 31.43,98.22 ; J30.4 32.41,98.56 ; J30.4 33.4,96.25 ; J30.4 31.09,97.24 ; J30.4 33.4,98.22 ; J30.4 32.41,95.92 ; J30.4 33.73,97.24 ; 68.38,135.56 J35.4 ; J35.4 68.38,133.59 ; J35.4 69.37,135.89 ; J35.4 70.35,133.59 ; J35.4 68.05,134.57 ; J35.4 69.37,133.25 ; J35.4 70.35,135.56 ; J35.4 70.69,134.57 ; 14.41,96.25 J31.2 ; J31.2 16.38,96.25 ; J31.2 16.71,97.24 ; J31.2 15.39,95.92 ; J31.2 15.39,98.56 ; J31.2 14.07,97.24 ; J31.2 14.41,98.22 ; J31.2 16.38,98.22 ; J32.5 62.81,109.17 ; J32.5 60.51,108.19 ; J32.5 61.49,107.85 ; J32.5 62.48,110.16 ; J32.5 60.51,110.16 ; J32.5 60.17,109.17 ; J32.5 61.49,110.49 ; J32.5 62.48,108.19 ; J30.5 27.33,98.56 ; J30.5 28.65,97.24 ; J30.5 26.01,97.24 ; J30.5 26.35,96.25 ; J30.5 28.32,98.22 ; J30.5 27.33,95.92 ; J30.5 28.32,96.25 ; J30.5 26.35,98.22 ; 32.41,101 J30.2 ; J30.2 32.41,103.64 ; J30.2 31.43,101.33 ; J30.2 33.4,101.33 ; J30.2 33.73,102.32 ; J30.2 31.09,102.32 ; J30.2 31.43,103.3 ; J30.2 33.4,103.3 ; J32.4 62.81,114.25 ; J32.4 62.48,113.27 ; J32.4 61.49,112.93 ; J32.4 60.51,113.27 ; J32.4 60.17,114.25 ; J32.4 62.48,115.24 ; J32.4 60.51,115.24 ; J32.4 61.49,115.57 ; 19.15,97.24 J31.3 ; J31.3 21.46,98.22 ; J31.3 20.47,95.92 ; J31.3 21.46,96.25 ; J31.3 21.79,97.24 ; J31.3 20.47,98.56 ; J31.3 19.49,98.22 ; J31.3 19.49,96.25 ; J31.5 21.79,102.32 ; J31.5 20.47,103.64 ; J31.5 21.46,103.3 ; J31.5 19.49,101.33 ; J31.5 21.46,101.33 ; J31.5 19.49,103.3 ; J31.5 20.47,101 ; J31.5 19.15,102.32 ; J35.2 70.69,129.49 ; J35.2 68.38,130.48 ; J35.2 68.38,128.51 ; J35.2 69.37,128.17 ; J35.2 70.35,128.51 ; J35.2 68.05,129.49 ; J35.2 70.35,130.48 ; J35.2 69.37,130.81 ; J30.3 27.33,103.64 ; J30.3 26.01,102.32 ; J30.3 28.32,103.3 ; J30.3 26.35,103.3 ; J30.3 27.33,101 ; J30.3 28.32,101.33 ; J30.3 28.65,102.32 ; J30.3 26.35,101.33 ; J33.3 62.48,101.33 ; J33.3 60.51,101.33 ; J33.3 61.49,101 ; J33.3 61.49,103.64 ; J33.3 62.81,102.32 ; J33.3 60.17,102.32 ; J33.3 60.51,103.3 ; J33.3 62.48,103.3 ; J33.5 57.73,102.32 ; J33.5 56.41,101 ; J33.5 55.43,103.3 ; J33.5 57.4,101.33 ; J33.5 55.43,101.33 ; J33.5 57.4,103.3 ; J33.5 55.09,102.32 ; J33.5 56.41,103.64 ; 73.46,135.56 J35.5 ; J35.5 75.43,133.59 ; J35.5 73.46,133.59 ; J35.5 75.77,134.57 ; J35.5 73.13,134.57 ; J35.5 75.43,135.56 ; J35.5 74.45,135.89 ; J35.5 74.45,133.25 ; 73.46,130.48 J35.3 ; J35.3 75.77,129.49 ; J35.3 75.43,128.51 ; J35.3 74.45,130.81 ; J35.3 73.13,129.49 ; J35.3 75.43,130.48 ; J35.3 74.45,128.17 ; J35.3 73.46,128.51 ; 55.09,97.24 J33.4 ; J33.4 56.41,98.56 ; J33.4 57.73,97.24 ; J33.4 57.4,98.22 ; J33.4 57.4,96.25 ; J33.4 55.43,96.25 ; J33.4 55.43,98.22 ; J33.4 56.41,95.92 ; J34.2 86.39,135.89 ; J34.2 85.07,134.57 ; J34.2 87.37,135.56 ; J34.2 87.37,133.59 ; J34.2 85.4,133.59 ; J34.2 86.39,133.25 ; J34.2 87.71,134.57 ; J34.2 85.4,135.56 ; J34.4 87.71,129.49 ; J34.4 87.37,130.48 ; J34.4 85.4,128.51 ; J34.4 86.39,128.17 ; J34.4 87.37,128.51 ; J34.4 85.07,129.49 ; J34.4 86.39,130.81 ; J34.4 85.4,130.48 ; 79.99,129.49 J34.5 ; J34.5 82.29,130.48 ; J34.5 80.32,130.48 ; J34.5 81.31,130.81 ; J34.5 81.31,128.17 ; J34.5 82.63,129.49 ; J34.5 82.29,128.51 ; J34.5 80.32,128.51 ; 55.43,108.19 J32.3 ; J32.3 55.09,109.17 ; J32.3 56.41,107.85 ; J32.3 57.4,108.19 ; J32.3 57.4,110.16 ; J32.3 57.73,109.17 ; J32.3 56.41,110.49 ; J32.3 55.43,110.16 ; 60.17,97.24 J33.2 ; J33.2 61.49,95.92 ; J33.2 61.49,98.56 ; J33.2 62.48,96.25 ; J33.2 60.51,98.22 ; J33.2 62.48,98.22 ; J33.2 60.51,96.25 ; J33.2 62.81,97.24 ; J34.3 82.29,135.56 ; J34.3 79.99,134.57 ; J34.3 82.29,133.59 ; J34.3 80.32,135.56 ; J34.3 80.32,133.59 ; J34.3 81.31,133.25 ; J34.3 81.31,135.89 ; J34.3 82.63,134.57
  20_SIG7 w0.381: MH6.1 10.86,12.69 ; MH6.1 4.13,5.96 ; MH6.1 4.13,12.69 ; MH6.1 2.81,9.32 ; MH6.1 12.18,9.32 ; MH6.1 7.49,14.01 ; MH6.1 10.86,5.96 ; 8.58,16.13 J96.8 ; J96.8 12,12.72 ; J96.8 9.53,13.67 ; J96.8 9.53,18.6 ; J96.8 14.47,18.6 ; J96.8 15.42,16.13 ; J96.8 12,19.55 ; J96.8 14.47,13.67 ; J25.1 227.76,16.69 ; J25.1 221.99,19.11 ; J25.1 226.83,14.27 ; J25.1 224.41,20.04 ; J25.1 226.83,19.11 ; MH7.1 7.49,99.4 ; MH7.1 4.13,91.35 ; MH7.1 10.86,91.35 ; MH7.1 4.13,98.08 ; MH7.1 7.49,90.03 ; MH7.1 10.86,98.08 ; MH7.1 2.81,94.72 ; MH7.1 12.18,94.72 ; 18.53,44.17 J1.7 ; J1.7 21,45.12 ; J1.7 17.58,41.71 ; J1.7 23.47,44.17 ; J1.7 24.42,41.71 ; J1.7 18.53,39.24 ; J1.7 23.47,39.24 ; J1.7 21,38.29 ; J96.10 18.97,37.6 ; J96.10 14.03,32.67 ; J96.10 13.08,35.13 ; J96.10 19.92,35.13 ; J96.10 18.97,32.67 ; J96.10 14.03,37.6 ; J96.10 16.5,31.72 ; J96.10 16.5,38.55 ; 239.58,173.98 MH1.1 232.86,173.98 ; J1.8 14.47,39.24 ; J1.8 14.47,44.17 ; J1.8 12,38.29 ; J1.8 8.58,41.71 ; J1.8 12,45.12 ; J1.8 9.53,44.17 ; J1.8 15.42,41.71 ; J1.8 9.53,39.24 ; J96.9 9.97,32.67 ; J96.9 9.97,37.6 ; J96.9 7.5,31.72 ; J96.9 5.03,32.67 ; J96.9 5.03,37.6 ; J96.9 7.5,38.55 ; J96.9 10.92,35.13 ; J96.9 4.08,35.13 ; J96.7 23.47,18.6 ; J96.7 24.42,16.13 ; J96.7 18.53,13.67 ; J96.7 18.53,18.6 ; J96.7 17.58,16.13 ; J96.7 23.47,13.67 ; J96.7 21,19.55 ; 24.25,173.84 J10.SH2 25.42,170.83 ; 27.53,44.17 J1.6 ; J1.6 27.53,39.24 ; J1.6 26.58,41.71 ; 25.5,35.13 25.5,38.55 ; 25.5,35.13 23.03,37.6 ; 25.5,35.13 23.03,32.67 ; 25.5,35.13 25.5,31.72 ; 25.5,35.13 27.97,37.6 ; 25.5,35.13 27.97,32.67 ; 25.5,35.13 22.08,35.13 ; 22.08,60.71 25.5,60.71 ; 25.5,60.71 23.03,58.24 ; 25.5,60.71 27.97,58.24 ; 25.5,60.71 25.5,57.29 ; 175.4,146.87 J24.1 172.97,147.8 ; J1.9 9.97,63.17 ; J1.9 10.92,60.71 ; J1.9 9.97,58.24 ; J1.9 7.5,57.29 ; J1.9 4.08,60.71 ; J1.9 5.03,63.17 ; J1.9 5.03,58.24 ; 232.86,19.95 MH5.1 ; MH5.1 239.58,19.95 ; MH5.1 231.53,16.59 ; MH5.1 236.22,21.27 ; 16.5,57.29 J1.10 ; J1.10 13.08,60.71 ; J1.10 14.03,58.24 ; J1.10 18.97,58.24 ; 26.58,16.13 J96.6 ; J96.6 27.53,13.67 ; J96.6 32.47,13.67 ; J96.6 27.53,18.6 ; 52.12,97.97 J27.1 46.35,100.39
  20_SIG7 w0.508: 15.39,93.63 J31.2 ; J31.2 12.79,94.63 ; J31.2 17.99,94.63 ; J31.2 11.79,97.24 ; 77.05,137.18 J35.5 74.45,138.18 ; 52.81,97.24 J33.4 ; J33.4 53.81,94.63 ; J33.4 53.81,99.84 ; 20.47,93.63 J31.3 17.87,94.63 ; 53.81,104.92 J33.5 53.81,99.71
  21_GND w0.381: 195.63,134.25 C499.2 ; C499.2 197.5,135.05 ; C499.2 197.24,135.86 ; C499.2 196.43,133.98 ; C499.2 197.24,134.25 ; C499.2 195.63,135.86 ; C499.2 196.43,136.12 ; C499.2 195.37,135.05 ; 128.92,21.39 MH3.1 ; MH3.1 129.57,23.13 ; MH3.1 133.72,21.39 ; MH3.1 131.32,18.99 ; MH3.1 129.57,19.64 ; MH3.1 131.32,23.79 ; MH3.1 133.07,19.64 ; MH3.1 133.07,23.13 ; 53.76,56.21 J1.2 ; J1.2 55.74,57.06 ; J1.2 55.74,55.36 ; J1.2 54.89,57.34 ; J1.2 54.04,57.06 ; J1.2 54.04,55.36 ; J1.2 54.89,55.08 ; J39.16 232.97,46.05 ; J39.16 232.16,44.18 ; J39.16 234.03,44.98 ; J39.16 233.77,45.79 ; J39.16 232.16,45.79 ; J39.16 233.77,44.18 ; J39.16 232.97,43.91 ; J39.16 231.9,44.98 ; J39.6 233.77,33.09 ; J39.6 232.16,31.48 ; J39.6 232.97,33.35 ; J39.6 231.9,32.28 ; J39.6 234.03,32.28 ; J39.6 233.77,31.48 ; J39.6 232.16,33.09 ; J39.6 232.97,31.21 ; 224.41,15.62 J25.1 ; J25.1 225.21,15.88 ; J25.1 223.34,16.69 ; J25.1 225.21,17.49 ; J25.1 223.6,17.49 ; J25.1 225.48,16.69 ; J25.1 224.41,17.75 ; J25.1 223.6,15.88 ; J1.3 56.02,49.01 ; J1.3 55.74,49.86 ; J1.3 54.04,48.16 ; J1.3 54.89,50.14 ; J1.3 55.74,48.16 ; J1.3 54.04,49.86 ; J1.3 54.89,47.88 ; J1.3 53.76,49.01 ; J110.2 27.74,128.98 ; J110.2 27.74,127.37 ; J110.2 26.13,128.98 ; J110.2 26.94,127.11 ; J110.2 26.94,129.24 ; J110.2 26.13,127.37 ; J110.2 25.87,128.18 ; J110.2 28,128.18 ; MH7.1 9.24,92.97 ; MH7.1 5.74,92.97 ; MH7.1 5.74,96.46 ; MH7.1 7.49,92.32 ; MH7.1 9.24,96.46 ; MH7.1 7.49,97.12 ; MH7.1 5.09,94.72 ; MH7.1 9.89,94.72 ; MH4.1 7.21,147.86 ; MH4.1 5.46,143.71 ; MH4.1 3.06,146.11 ; MH4.1 7.86,146.11 ; MH4.1 3.71,147.86 ; MH4.1 3.71,144.37 ; MH4.1 5.46,148.51 ; MH4.1 7.21,144.37 ; 230.39,64.18 J52.10 ; J52.10 232,65.8 ; J52.10 231.19,63.92 ; J52.10 231.19,66.06 ; J52.10 232.26,64.99 ; J52.10 230.39,65.8 ; J52.10 232,64.18 ; J52.10 230.12,64.99 ; 232.16,36.56 J39.10 ; J39.10 231.9,37.36 ; J39.10 233.77,36.56 ; J39.10 233.77,38.17 ; J39.10 232.97,38.43 ; J39.10 232.97,36.29 ; J39.10 234.03,37.36 ; J39.10 232.16,38.17 ; J1.9 8.35,61.56 ; J1.9 6.65,59.86 ; J1.9 8.35,59.86 ; J1.9 6.65,61.56 ; J1.9 7.5,61.84 ; J1.9 6.37,60.71 ; J1.9 7.5,59.58 ; J1.9 8.63,60.71 ; J1.5 40.13,41.71 ; J1.5 39,40.58 ; J1.5 39.85,40.86 ; J1.5 38.15,40.86 ; J1.5 37.87,41.71 ; 24.65,59.86 25.5,60.71 ; 25.5,60.71 25.5,61.84 ; 25.5,60.71 24.65,61.56 ; 25.5,60.71 25.5,59.58 ; 25.5,60.71 26.63,60.71 ; 25.5,60.71 26.35,59.86 ; 25.5,60.71 24.37,60.71 ; 25.5,60.71 26.35,61.56 ; 53.76,30.63 J96.2 ; J96.2 54.89,29.5 ; J96.2 55.74,29.78 ; J96.2 54.04,29.78 ; J96.2 54.89,31.76 ; J96.2 54.04,31.48 ; J96.2 55.74,31.48 ; J96.2 56.02,30.63 ; J39.12 232.97,40.97 ; J39.12 231.9,39.9 ; J39.12 233.77,39.1 ; J39.12 233.77,40.71 ; J39.12 232.97,38.83 ; J39.12 234.03,39.9 ; J39.12 232.16,39.1 ; J39.12 232.16,40.71 ; 15.65,61.56 J1.10 ; J1.10 17.35,61.56 ; J1.10 17.35,59.86 ; J1.10 15.37,60.71 ; J1.10 16.5,61.84 ; J1.10 16.5,59.58 ; J1.10 17.63,60.71 ; J1.10 15.65,59.86 ; J38.1 201.35,35.61 ; J38.1 199.21,35.61 ; J38.1 201.08,34.81 ; J38.1 201.08,36.42 ; J38.1 200.28,36.68 ; J38.1 199.47,34.81 ; J38.1 199.47,36.42 ; J38.1 200.28,34.54 ; J1.4 50.83,41.71 ; J1.4 48.57,41.71 ; J1.4 50.55,40.86 ; J1.4 48.85,42.56 ; J1.4 49.7,42.84 ; J1.4 50.55,42.56 ; J1.4 49.7,40.58 ; J1.4 48.85,40.86 ; 33.37,35.13 J96.12 ; J96.12 35.35,35.98 ; J96.12 35.35,34.28 ; J96.12 35.63,35.13 ; J96.12 33.65,34.28 ; J96.12 34.5,34 ; J96.12 34.5,36.26 ; J96.12 33.65,35.98 ; J27.1 49.83,97.97 ; J27.1 47.7,97.97 ; J27.1 49.57,97.16 ; J27.1 47.96,98.77 ; J27.1 49.57,98.77 ; J27.1 48.77,99.03 ; J27.1 47.96,97.16 ; J27.1 48.77,96.9 ; J96.10 17.63,35.13 ; J96.10 15.65,35.98 ; J96.10 16.5,36.26 ; J96.10 17.35,35.98 ; J96.10 17.35,34.28 ; J96.10 15.37,35.13 ; J96.10 15.65,34.28 ; J96.10 16.5,34 ; J24.1 173.78,145.25 ; J24.1 172.97,143.38 ; J24.1 172.17,143.64 ; J24.1 173.78,143.64 ; J24.1 171.91,144.45 ; J24.1 172.17,145.25 ; J24.1 174.04,144.45 ; J24.1 172.97,145.52 ; 5.09,9.32 MH6.1 ; MH6.1 9.89,9.32 ; MH6.1 7.49,11.72 ; MH6.1 5.74,7.57 ; MH6.1 9.24,11.07 ; MH6.1 9.24,7.57 ; MH6.1 5.74,11.07 ; MH6.1 7.49,6.92 ; 232.16,43.25 J39.14 ; J39.14 233.77,41.64 ; J39.14 234.03,42.44 ; J39.14 232.16,41.64 ; J39.14 232.97,41.37 ; J39.14 233.77,43.25 ; J39.14 232.97,43.51 ; J39.14 231.9,42.44 ; J53.10 239.62,81.46 ; J53.10 239.36,82.26 ; J53.10 237.75,82.26 ; J53.10 238.56,80.39 ; J53.10 238.56,82.52 ; J53.10 239.36,80.65 ; J53.10 237.49,81.46 ; J53.10 237.75,80.65 ; 10.87,16.13 J96.8 ; J96.8 13.13,16.13 ; J96.8 11.15,16.98 ; J96.8 12.85,15.28 ; J96.8 12.85,16.98 ; J96.8 12,15 ; J96.8 11.15,15.28 ; J96.8 12,17.26 ; 48.57,16.13 J96.4 ; J96.4 48.85,15.28 ; J96.4 50.83,16.13 ; J96.4 50.55,15.28 ; J96.4 50.55,16.98 ; J96.4 49.7,17.26 ; J96.4 49.7,15 ; J96.4 48.85,16.98 ; 7.5,34 J96.9 ; J96.9 8.35,35.98 ; J96.9 8.63,35.13 ; J96.9 6.65,34.28 ; J96.9 6.37,35.13 ; J96.9 7.5,36.26 ; J96.9 8.35,34.28 ; J96.9 6.65,35.98 ; 30,40.58 J1.6 ; J1.6 29.15,40.86 ; J1.6 30,42.84 ; J1.6 31.13,41.71 ; J1.6 30.85,42.56 ; J1.6 30.85,40.86 ; J1.6 28.87,41.71 ; J1.6 29.15,42.56 ; J96.1 45.2,36.26 ; J96.1 44.35,34.28 ; J96.1 45.2,34 ; J96.1 46.33,35.13 ; J96.1 44.35,35.98 ; J96.1 46.05,35.98 ; J96.1 46.05,34.28 ; J96.1 44.07,35.13 ; 232.16,28.94 J39.4 ; J39.4 231.9,29.74 ; J39.4 233.77,28.94 ; J39.4 233.77,30.55 ; J39.4 232.97,30.81 ; J39.4 232.97,28.67 ; J39.4 232.16,30.55 ; J39.4 234.03,29.74 ; J1.7 21.85,40.86 ; J1.7 22.13,41.71 ; J1.7 21.85,42.56 ; J1.7 21,40.58 ; J1.7 20.15,40.86 ; J1.7 21,42.84 ; J1.7 19.87,41.71 ; J1.7 20.15,42.56 ; 27.64,66.34 J36.1 ; J36.1 28.7,65.28 ; J36.1 28.7,67.41 ; J36.1 29.51,65.54 ; J36.1 29.77,66.34 ; J36.1 29.51,67.15 ; J36.1 27.9,65.54 ; J36.1 27.9,67.15 ; 206.18,133.65 U16.7 ; U16.7 207.09,133.34 ; U16.7 205.88,134.56 ; U16.7 208.01,133.65 ; U16.7 207.09,135.78 ; U16.7 208.01,135.47 ; U16.7 208.31,134.56 ; U16.7 206.18,135.47 ; 233.82,16.59 MH5.1 ; MH5.1 234.47,14.84 ; MH5.1 237.97,14.84 ; MH5.1 234.47,18.33 ; MH5.1 237.97,18.33 ; MH5.1 236.22,14.19 ; MH5.1 236.22,18.99 ; MH5.1 238.62,16.59 ; U16.6 212.09,135.78 ; U16.6 212.09,133.34 ; U16.6 213.01,135.47 ; U16.6 213.31,134.56 ; U16.6 210.88,134.56 ; U16.6 211.18,135.47 ; U16.6 213.01,133.65 ; U16.6 211.18,133.65 ; J10.SH1 46.17,172.45 ; J10.SH1 46.67,173.84 ; J10.SH1 42.88,173.84 ; 213.68,137.97 U16.5 ; U16.5 215.51,137.97 ; U16.5 213.38,137.06 ; U16.5 215.51,136.15 ; U16.5 214.59,138.28 ; U16.5 213.68,136.15 ; U16.5 214.59,135.84 ; U16.5 215.81,137.06 ; 11.07,103.53 J82.2 ; J82.2 10.27,103.79 ; J82.2 11.07,105.66 ; J82.2 12.14,104.59 ; J82.2 10.27,105.4 ; J82.2 11.88,103.79 ; J82.2 11.88,105.4 ; J82.2 10.01,104.59 ; 25.5,35.13 26.35,35.98 ; 25.5,35.13 24.65,34.28 ; 25.5,35.13 24.65,35.98 ; 25.5,35.13 25.5,34 ; 25.5,35.13 26.35,34.28 ; 25.5,35.13 26.63,35.13 ; 25.5,35.13 24.37,35.13 ; 25.5,35.13 25.5,36.26 ; 54.04,24.28 J96.3 ; J96.3 54.89,22.3 ; J96.3 54.04,22.58 ; J96.3 53.76,23.43 ; J96.3 56.02,23.43 ; J96.3 54.89,24.56 ; J96.3 55.74,24.28 ; J96.3 55.74,22.58 ; 24.17,91.13 J78.4 ; J78.4 25.78,89.52 ; J78.4 25.78,91.13 ; J78.4 24.97,91.39 ; J78.4 24.97,89.26 ; J78.4 23.9,90.32 ; J78.4 24.17,89.52 ; J78.4 26.04,90.32 ; 11.15,42.56 J1.8 ; J1.8 10.87,41.71 ; J1.8 12,40.58 ; J1.8 12.85,40.86 ; J1.8 12,42.84 ; J1.8 12.85,42.56 ; J1.8 13.13,41.71 ; J1.8 11.15,40.86 ; J23.1 222.8,63.09 ; J23.1 222,61.21 ; J23.1 221.19,63.09 ; J23.1 222.8,61.48 ; J23.1 221.19,61.48 ; J23.1 220.93,62.28 ; J23.1 222,63.35 ; J23.1 223.06,62.28 ; J53.9 236.82,80.65 ; J53.9 235.21,80.65 ; J53.9 236.02,80.39 ; J53.9 237.08,81.46 ; J53.9 236.82,82.26 ; J53.9 234.95,81.46 ; J53.9 236.02,82.52 ; J53.9 235.21,82.26 ; 233.82,170.61 MH1.1 ; MH1.1 237.97,168.86 ; MH1.1 234.47,168.86 ; MH1.1 237.97,172.36 ; MH1.1 234.47,172.36 ; MH1.1 238.62,170.61 ; MH1.1 236.22,168.21 ; MH1.1 236.22,173.01 ; 227.85,65.8 J52.9 ; J52.9 227.85,64.18 ; J52.9 227.58,64.99 ; J52.9 229.46,64.18 ; J52.9 228.65,63.92 ; J52.9 229.72,64.99 ; J52.9 229.46,65.8 ; J52.9 228.65,66.06 ; MH2.1 121.02,137.59 ; MH2.1 116.87,135.84 ; MH2.1 118.62,135.19 ; MH2.1 118.62,139.99 ; MH2.1 116.22,137.59 ; MH2.1 120.37,139.34 ; MH2.1 120.37,135.84 ; MH2.1 116.87,139.34 ; 198.25,14.48 J5.3 ; J5.3 199.31,15.54 ; J5.3 198.25,16.61 ; J5.3 197.44,16.35 ; J5.3 199.05,16.35 ; J5.3 197.44,14.74 ; J5.3 199.05,14.74 ; J96.7 21.85,16.98 ; J96.7 21.85,15.28 ; J96.7 21,15 ; J96.7 22.13,16.13 ; J96.7 20.15,16.98 ; J96.7 19.87,16.13 ; J96.7 20.15,15.28 ; J96.7 21,17.26 ; 29.15,15.28 J96.6 ; J96.6 30.85,16.98 ; J96.6 31.13,16.13 ; J96.6 30.85,15.28 ; J96.6 29.15,16.98 ; J96.6 30,17.26 ; J96.6 28.87,16.13 ; J96.6 30,15 ; 103.07,128.07 J105.6 ; J105.6 102,129.14 ; J105.6 104.13,129.14 ; J105.6 102.26,129.95 ; J105.6 102.26,128.34 ; J105.6 103.87,129.95 ; J105.6 103.87,128.34 ; J105.6 103.07,130.21 ; 232.97,33.75 J39.8 ; J39.8 233.77,35.63 ; J39.8 234.03,34.82 ; J39.8 232.97,35.89 ; J39.8 232.16,34.02 ; J39.8 231.9,34.82 ; J39.8 233.77,34.02 ; J39.8 232.16,35.63 ; J26.1 199.52,130.4 ; J26.1 198.71,128.53 ; J26.1 199.52,128.27 ; J26.1 198.71,130.14 ; J26.1 200.58,129.34 ; J26.1 200.32,130.14 ; J26.1 200.32,128.53 ; J26.1 198.45,129.34 ; 33.65,59.86 J1.12 ; J1.12 35.35,59.86 ; J1.12 34.5,61.84 ; J1.12 33.37,60.71 ; J1.12 33.65,61.56 ; J1.12 34.5,59.58 ; J1.12 35.35,61.56 ; J1.12 35.63,60.71 ; 44.07,60.71 J1.1 ; J1.1 46.05,59.86 ; J1.1 46.33,60.71 ; J1.1 44.35,61.56 ; J1.1 46.05,61.56 ; J1.1 45.2,59.58 ; J1.1 45.2,61.84 ; J1.1 44.35,59.86 ; J96.5 40.13,16.13 ; J96.5 37.87,16.13 ; J96.5 38.15,15.28 ; J96.5 39,15 ; J96.5 39.85,15.28 ; 27.04,172.45 J10.SH2 ; J10.SH2 30.32,173.84 ; J10.SH2 26.53,173.84
  21_GND w0.508: 26.35,103.3 J30.3 ; J30.3 27.33,101 ; J30.3 27.33,103.64 ; J30.3 26.01,102.32 ; J30.3 26.35,101.33 ; J30.3 28.32,103.3 ; J30.3 28.65,102.32 ; J30.3 28.32,101.33 ; 61.49,112.93 J32.4 ; J32.4 62.48,115.24 ; J32.4 61.49,115.57 ; J32.4 62.48,113.27 ; J32.4 60.51,115.24 ; J32.4 60.51,113.27 ; J32.4 62.81,114.25 ; J32.4 60.17,114.25 ; J35.4 69.37,135.89 ; J35.4 70.69,134.57 ; J35.4 70.35,135.56 ; J35.4 70.35,133.59 ; J35.4 69.37,133.25 ; J35.4 68.38,135.56 ; J35.4 68.38,133.59 ; J35.4 68.05,134.57 ; J35.3 74.45,130.81 ; J35.3 75.43,128.51 ; J35.3 74.45,128.17 ; J35.3 73.46,130.48 ; J35.3 75.77,129.49 ; J35.3 75.43,130.48 ; J35.3 73.46,128.51 ; J35.3 73.13,129.49 ; 31.09,102.32 J30.2 ; J30.2 33.4,103.3 ; J30.2 32.41,103.64 ; J30.2 32.41,101 ; J30.2 33.73,102.32 ; J30.2 31.43,101.33 ; J30.2 31.43,103.3 ; J30.2 33.4,101.33 ; J33.5 57.4,103.3 ; J33.5 55.43,101.33 ; J33.5 55.43,103.3 ; J33.5 57.73,102.32 ; J33.5 57.4,101.33 ; J33.5 56.41,101 ; J33.5 55.09,102.32 ; J33.5 56.41,103.64 ; 73.46,135.56 J35.5 ; J35.5 74.45,133.25 ; J35.5 74.45,135.89 ; J35.5 75.43,133.59 ; J35.5 75.43,135.56 ; J35.5 73.13,134.57 ; J35.5 73.46,133.59 ; J35.5 75.77,134.57 ; J32.2 57.4,115.24 ; J32.2 56.41,112.93 ; J32.2 57.4,113.27 ; J32.2 57.73,114.25 ; J32.2 55.09,114.25 ; J32.2 55.43,115.24 ; J32.2 55.43,113.27 ; J32.2 56.41,115.57 ; 80.32,135.56 J34.3 ; J34.3 80.32,133.59 ; J34.3 82.29,133.59 ; J34.3 82.29,135.56 ; J34.3 79.99,134.57 ; J34.3 81.31,135.89 ; J34.3 81.31,133.25 ; J34.3 82.63,134.57 ; J31.2 16.38,96.25 ; J31.2 15.39,98.56 ; J31.2 14.41,98.22 ; J31.2 15.39,95.92 ; J31.2 14.07,97.24 ; J31.2 14.41,96.25 ; J31.2 16.38,98.22 ; J31.2 16.71,97.24 ; 85.07,134.57 J34.2 ; J34.2 87.37,135.56 ; J34.2 85.4,135.56 ; J34.2 87.71,134.57 ; J34.2 87.37,133.59 ; J34.2 86.39,133.25 ; J34.2 85.4,133.59 ; J34.2 86.39,135.89 ; J30.5 28.32,98.22 ; J30.5 28.65,97.24 ; J30.5 27.33,95.92 ; J30.5 26.35,96.25 ; J30.5 27.33,98.56 ; J30.5 26.01,97.24 ; J30.5 28.32,96.25 ; J30.5 26.35,98.22 ; J31.3 21.46,96.25 ; J31.3 19.15,97.24 ; J31.3 20.47,95.92 ; J31.3 20.47,98.56 ; J31.3 21.46,98.22 ; J31.3 19.49,96.25 ; J31.3 21.79,97.24 ; J31.3 19.49,98.22 ; 19.15,102.32 J31.5 ; J31.5 21.79,102.32 ; J31.5 21.46,103.3 ; J31.5 19.49,103.3 ; J31.5 20.47,103.64 ; J31.5 20.47,101 ; J31.5 21.46,101.33 ; J31.5 19.49,101.33 ; 32.41,95.92 J30.4 ; J30.4 33.4,96.25 ; J30.4 31.43,96.25 ; J30.4 33.4,98.22 ; J30.4 32.41,98.56 ; J30.4 33.73,97.24 ; J30.4 31.09,97.24 ; J30.4 31.43,98.22 ; 68.05,129.49 J35.2 ; J35.2 70.69,129.49 ; J35.2 69.37,130.81 ; J35.2 68.38,130.48 ; J35.2 70.35,128.51 ; J35.2 69.37,128.17 ; J35.2 68.38,128.51 ; J35.2 70.35,130.48 ; J32.3 57.4,110.16 ; J32.3 57.4,108.19 ; J32.3 56.41,110.49 ; J32.3 57.73,109.17 ; J32.3 55.43,110.16 ; J32.3 55.43,108.19 ; J32.3 55.09,109.17 ; J32.3 56.41,107.85 ; J34.5 82.63,129.49 ; J34.5 80.32,130.48 ; J34.5 81.31,128.17 ; J34.5 82.29,130.48 ; J34.5 80.32,128.51 ; J34.5 79.99,129.49 ; J34.5 81.31,130.81 ; J34.5 82.29,128.51 ; J31.4 15.39,103.64 ; J31.4 16.38,101.33 ; J31.4 14.41,101.33 ; J31.4 14.07,102.32 ; J31.4 16.38,103.3 ; J31.4 16.71,102.32 ; J31.4 14.41,103.3 ; J31.4 15.39,101 ; 55.43,98.22 J33.4 ; J33.4 56.41,98.56 ; J33.4 57.4,98.22 ; J33.4 55.43,96.25 ; J33.4 56.41,95.92 ; J33.4 57.4,96.25 ; J33.4 57.73,97.24 ; J33.4 55.09,97.24 ; J32.5 62.48,110.16 ; J32.5 61.49,107.85 ; J32.5 60.17,109.17 ; J32.5 61.49,110.49 ; J32.5 62.81,109.17 ; J32.5 62.48,108.19 ; J32.5 60.51,108.19 ; J32.5 60.51,110.16 ; 61.49,95.92 J33.2 ; J33.2 60.51,96.25 ; J33.2 60.51,98.22 ; J33.2 60.17,97.24 ; J33.2 62.48,98.22 ; J33.2 61.49,98.56 ; J33.2 62.81,97.24 ; J33.2 62.48,96.25 ; J33.3 62.81,102.32 ; J33.3 61.49,101 ; J33.3 62.48,103.3 ; J33.3 60.51,103.3 ; J33.3 60.51,101.33 ; J33.3 62.48,101.33 ; J33.3 60.17,102.32 ; J33.3 61.49,103.64 ; 86.39,128.17 J34.4 ; J34.4 86.39,130.81 ; J34.4 85.07,129.49 ; J34.4 85.4,128.51 ; J34.4 87.37,128.51 ; J34.4 87.37,130.48 ; J34.4 85.4,130.48 ; J34.4 87.71,129.49
  BOTTOM w0.152: v2(79.32,118.17) 79.84,117.65 80.49,117.65 80.82,117.32 80.82,116.96 81.66,116.13 C1236.2 81.67,115.52 81.82,115.37 81.82,114.96 81.53,114.67 81.5,114.67 81.5,114.66 80.82,114.66 v2(80.32,114.17) ; 72.82,110.67 v2(72.32,111.17) 71.83,110.67 71.83,109.72 C1391.2 72.82,109.82 72.82,110.67
  BOTTOM w0.178: v1(36.15,70.01) 35.36,70.01 35.18,69.83 U13.2 ; U13.3 36.86,69.02 v1(37.09,69.25)
  BOTTOM w0.191: v2(123.24,79.84) 123.74,80.34 124.5,80.34 124.74,80.58 124.74,81.03 125.03,81.32 125.03,81.34 ; v2(124.24,55.84) 124.24,55.57 124.74,55.07 124.74,54.62 125.01,54.34 125.45,54.34 125.74,54.06 125.74,53.65 126.05,53.34 126.51,53.34 126.74,53.12 126.74,52.62 127.01,52.34 127.49,52.34 127.74,52.1 127.74,51.63 128.03,51.34 131.43,51.34 131.74,51.03 131.74,50.62 132.01,50.34 138.48,50.34 138.74,50.09 138.74,45.72 139.12,45.34 139.49,45.34 139.74,45.1 139.74,44.62 140.01,44.34 140.36,44.34 140.72,43.98 140.72,43.1 142.65,41.17 142.65,35.12 145.41,32.36 Z5.2 ; v2(134.24,76.84) 133.76,77.32 133.76,84.09 134,84.33 135.46,84.33 135.74,84.61 135.74,85.07 136.01,85.34 136.43,85.34 136.74,85.65 136.74,86.03 137.05,86.34 137.4,86.34 137.74,86.68 137.74,87.05 138.03,87.34 140.84,87.34 141.06,87.56 144.96,87.56 145.85,86.68 151.25,86.68 Z108.2 ; v2(121.24,77.84) 121.24,78.15 121.74,78.66 121.74,79.02 122.05,79.32 126.49,79.32 126.74,79.57 126.74,85.07 127.01,85.34 127.46,85.34 127.74,85.62 127.74,86.03 128.06,86.35 128.44,86.35 128.74,86.65 128.74,87.03 129.04,87.33 129.42,87.33 129.69,87.61 129.69,88.03 130,88.34 130.46,88.34 130.79,88.66 130.79,89.05 131.04,89.3 131.43,89.3 136.85,94.73 140.92,94.73 142.44,96.25 142.44,97.06 142.17,97.32 142.17,97.76 142.24,97.83 Z102.2 ; 125.03,81.34 125.44,81.34 125.55,81.34 125.74,81.53 125.74,85.07 125.98,85.31 126.43,85.31 126.71,85.59 126.71,86 127.06,86.36 127.44,86.36 127.74,86.65 127.74,90.07 131.6,93.93 131.6,100.65 Z133.2 ; 125.03,81.34 125.03,81.34 ; Z92.2 103.85,116.14 103.85,114.34 104.6,113.59 104.6,113.22 104.19,112.81 103.38,112.81 102.4,113.79 101.47,113.79 101.45,113.82 99.72,113.82 v2(99.23,113.32) ; v2(131.24,89.84) 130.99,90.09 130.99,91.95 139.96,100.93 Z129.2 ; Z14.2 151.27,88.11 147.15,88.11 145.62,89.63 138.05,89.63 137.69,89.28 137.69,88.61 137.43,88.34 137.01,88.34 136.75,88.09 136.75,87.63 136.45,87.33 136.03,87.33 135.76,87.06 135.76,86.68 135.44,86.36 134.06,86.36 133.76,86.05 133.76,85.64 133.46,85.34 133.05,85.34 132.74,85.04 132.74,84.62 132.46,84.34 131.05,84.34 130.74,84.03 130.74,79.34 v2(130.24,78.84)
  BOTTOM w0.203: U22.3 52.23,79.57 v1(52.65,79.99) 53.07,79.57 U33.10 ; v1(32.97,108.05) 32.55,108.47 U128.2 ; U33.3 v1(55.38,80.15) ; U134.4 147.09,105.64 147.4,105.95 v1(147.4,106.4) ; U22.2 v1(51.25,80.74) ; U33.2 54.68,80.73 v1(54.67,80.75) 54.28,80.36 U33.1
  BOTTOM w0.241: v2(101.24,118.32) 101.27,118.3 C1244.2
  BOTTOM w0.254: C1204.2 167.82,30.55 v4(167.56,30.81) ; C1197.2 167.82,73.09 v4(167.56,73.35) ; v4(165.16,73.35) 165.4,73.11 C1150.2 ; 192.49,27.15 192.35,27.02 U156.20 ; R933.2 157.22,95.38 v4(157.96,94.65) ; C1224.2 157.28,90.53 v4(157.96,89.85) ; C1215.2 v1(167.83,68.95) ; v4(162.76,45.16) 162.71,45.21 C1190.2 ; v4(163.56,38.01) 164.3,38.74 C1177.2 ; C1154.2 157.24,86.73 v4(157.96,87.45) ; v4(157.96,33.21) 157.28,33.89 C1227.2 ; C1211.2 157.28,48.24 v4(157.96,47.56) ; R938.2 v1(163.76,56.85) ; v4(165.16,45.16) 165.4,44.91 C1144.2 ; C1401.2 158.03,119.51 158.5,119.05 v1(158.5,118.77) 158.63,118.64 U9.20 ; C1175.2 164.3,95.39 v4(163.56,94.65) ; v4(167.56,59.26) 167.82,59 C1193.2 167.94,58.41 C1146.2 ; C130.2 207.46,63.67 207.92,64.13 v1(208.2,64.13) 208.33,64.26 U6.20 ; C1201.2 154.63,88.37 v4(154.76,88.25) ; R930.2 157.94,52.36 v4(157.96,52.36) ; C1228.2 162.36,38.41 v4(161.96,38.01) ; C1165.2 164.52,52.78 164.09,52.36 v4(163.56,52.36) ; v4(167.56,45.16) 167.82,44.9 C1189.2 ; v4(156.36,94.65) 156.19,94.82 C1174.2 ; C258.2 185.49,138.36 185.02,137.9 v1(184.74,137.9) 184.61,137.77 U30.20 ; v1(57.89,135.24) 57.69,135.04 57.69,134.06 U143.4 ; C1210.2 160.51,45.01 v4(160.36,45.16) ; C1311.2 46.04,117.97 45.57,118.44 v1(45.57,118.72) 45.44,118.85 U150.20 ; U143.8 57.17,130.19 v1(57.61,129.75) ; C1205.2 154.63,31.73 v4(154.76,31.61) ; C1160.2 157.24,30.09 v4(157.96,30.81) ; v4(165.16,59.26) 165.4,59.01 C1147.2 ; v1(163.62,42.79) 163.66,42.75 R936.2 164.45,41.96 C1143.2 ; C1200.2 162.29,89.52 v4(162.76,89.05) ; v3(39.5,105.66) 39.51,105.67 U125.4 ; v4(160.36,87.45) 160.51,87.3 C1222.2 ; R932.2 157.22,81.29 v4(157.96,80.55) ; R7.2 157.22,38.74 v4(157.96,38.01) ; C1167.2 v1(166.68,54.66) ; C1173.2 v1(166.68,82.92) ; C1148.2 157.24,58.54 v4(157.96,59.26) ; C1598.2 181.91,44.15 C1668.2 182.22,44.28 v1(183.27,44.28) ; C1198.2 162.71,73.4 v4(162.76,73.35) ; v4(161.96,66.46) 161.96,66.65 C1213.2 ; C1220.2 160.51,73.2 v4(160.36,73.35) ; v4(157.96,45.16) 157.24,44.44 C1145.2 ; C1169.2 156.19,66.62 v4(156.36,66.46) ; C1212.2 167.83,54.45 167.6,54.68 167.6,54.69 v1(167.58,54.7) ; v4(161.96,52.36) 161.96,52.55 C1209.2 ; v1(178.31,51.52) 178.31,50.62 C1720.2 ; C1188.2 160.36,52.36 v4(160.36,52.36) ; C1217.2 v1(167.83,82.92) ; v1(220.05,48.36) 220.33,48.36 220.79,48.83 C1402.2 ; v4(160.36,66.46) C1194.2 ; v4(161.96,94.65) 162.36,95.05 C1221.2 ; C1721.2 161.74,137.46 v1(160.84,137.46) ; C1195.2 162.71,59.31 v4(162.76,59.26) ; C1214.2 160.51,59.1 v4(160.36,59.26) ; v4(165.16,87.45) 165.4,87.2 C1153.2 ; v4(165.16,30.81) 165.4,30.56 C1162.2 ; C1151.2 157.24,72.63 v4(157.96,73.35) ; v1(163.55,70.95) R940.2 164.45,70.16 C1149.2 ; C1152.2 164.28,84.57 164.45,84.75 R942.2 v1(163.8,85.04) ; C1216.2 157.28,62.34 v4(157.96,61.66) ; C1219.2 157.28,76.43 v4(157.96,75.75) ; v1(145.52,120.76) U23.7 ; C1603.2 168.21,141.05 C1674.2 168.08,141.36 v1(168.08,142.41) ; v4(157.96,66.46) 157.85,66.56 157.24,67.17 R931.2 ; v4(156.36,80.55) 156.19,80.72 C1172.2 ; v4(160.36,38.01) C1207.2 ; C1168.2 164.52,66.78 164.2,66.46 v4(163.56,66.46) ; U23.1 v4(147.02,118.47) ; v4(160.36,94.65) C1202.2 ; v1(169.23,30.89) C1161.2 ; v1(146.57,101.14) 146.59,101.17 U134.8 ; U125.8 38.99,106.17 v3(39.5,106.68) ; C1170.2 v1(166.68,68.95) ; C1166.2 156.19,52.53 v4(156.36,52.36) ; C1178.2 156.19,38.17 v4(156.36,38.01)
  BOTTOM w0.279: U164.25 234.17,105.05 v3(234,104.88)
  BOTTOM w0.305: U8.2 v1(194.52,64.97) ; U35.1 187.14,118.41 187.32,118.59 187.32,118.62 v1(187.35,118.62) 187.06,118.91 U35.2 ; v1(163.76,56.85) 163.34,57.27 C1192.2 ; C1218.2 162.18,80.77 v4(161.96,80.55) ; U31.6 176.44,37.71 176.15,37.42 v1(176.15,37.07) U31.7 ; v2(85.23,118.32) 85.14,118.41 C1239.2 ; C1196.2 160.21,80.71 v4(160.36,80.55) ; v2(99.23,123.32) 99.46,123.56 C1269.2 ; C1226.2 160.51,30.66 v4(160.36,30.81) ; C1191.2 163.3,43.11 v1(163.62,42.79) ; U125.8 36.88,106.17 v1(36.86,106.19) ; Z8.2 179.36,36.21 v1(178.94,36.63) ; C1450.2 152.78,77.65 153.16,77.27 v1(153.16,77.01) 152.78,76.63 C1575.2 ; v1(153.16,80.82) 153.68,81.34 C331.2 ; v2(85.23,113.32) 84.86,112.95 C1238.2 ; U8.7 195.52,62.48 v1(195.96,62.92) ; U4.20 219.92,48.23 v1(220.05,48.36) ; C1241.2 85.22,120.45 v2(85.23,120.45) ; C1240.2 85.02,115.11 v2(85.23,115.32) ; v1(191.59,119.76) 191.44,119.91 U35.7 ; v4(163.56,80.55) 164.12,81.11 C1171.2 ; X1.4 8.38,71.46 v1(8,71.83) ; U27.7 v1(190.17,155) ; v2(83.32,110.17) 83.69,109.79 C1237.2 ; U27.1 v1(188.67,157.11) ; v1(8,84.66) 8.17,84.66 8.38,84.45 X7.4 ; C154.2 v1(194.13,120.68)
  BOTTOM w0.381: C1441.2 174.54,16.88 v3(175.11,16.32) ; 34.5,33.75 J96.12 ; J96.12 35.88,35.13 ; J96.12 33.47,36.16 ; J96.12 34.5,36.52 ; J96.12 33.47,34.1 ; J96.12 35.53,34.1 ; J96.12 33.12,35.13 ; J96.12 35.53,36.16 ; U60.E3 v4(77.96,37.44) ; U64.T1 v4(68.36,49.14) ; C522.2 v1(138.28,114.37) ; U12.7 143.98,113.21 v1(144.28,112.91) ; R356.2 v1(62.77,139.39) ; J96.6 31.03,15.1 ; J96.6 28.97,15.1 ; J96.6 31.38,16.13 ; J96.6 28.97,17.16 ; J96.6 31.03,17.16 ; J96.6 30,14.75 ; J96.6 28.62,16.13 ; J96.6 30,17.52 ; U62.E8 v4(77.96,97.83) ; C1714.2 238.77,105.07 v1(238.51,105.33) ; 198.25,14.22 J5.3 ; J5.3 199.57,15.54 ; J5.3 199.23,14.56 ; 235.03,80.47 J53.9 ; J53.9 234.7,81.46 ; J53.9 235.03,82.44 ; v9(46.94,49) 47.14,48.79 47.7,48.79 48.33,49.42 C1553.2 ; U63.D2 v4(78.76,78.13) ; U17.1 56.5,34.68 v1(55.91,35.27) 55.84,35.34 C122.2 ; C1362.2 6.53,159.79 v1(6.78,159.53) ; J96.9 8.53,34.1 ; J96.9 6.12,35.13 ; J96.9 8.88,35.13 ; J96.9 7.5,36.52 ; J96.9 6.47,36.16 ; J96.9 8.53,36.16 ; J96.9 7.5,33.75 ; J96.9 6.47,34.1 ; v2(76.32,123.17) 76.14,122.99 C1271.2 ; 24.12,60.71 25.5,60.71 ; 25.5,60.71 24.47,61.74 ; 25.5,60.71 26.53,59.68 ; 25.5,60.71 25.5,62.09 ; 25.5,60.71 24.47,59.68 ; 25.5,60.71 26.88,60.71 ; 25.5,60.71 25.5,59.32 ; 25.5,60.71 26.53,61.74 ; v1(112.71,107.48) 112.71,106.36 C1733.2 110.93,106.35 v1(110.93,107.48) ; C1280.2 v2(101.25,124.51) ; 10.97,15.1 J96.8 ; J96.8 12,14.75 ; J96.8 10.62,16.13 ; J96.8 13.38,16.13 ; J96.8 10.97,17.16 ; J96.8 12,17.52 ; J96.8 13.03,15.1 ; J96.8 13.03,17.16 ; 37.97,40.68 J1.5 ; J1.5 40.03,40.68 ; J1.5 39,40.32 ; J1.5 37.62,41.71 ; J1.5 40.38,41.71 ; v1(2.08,127.28) 2.08,126.29 C816.2 2.94,126.09 v1(2.94,127.28) ; C1453.2 152.65,78.79 v1(153.16,78.28) ; U14.3 v1(36.07,86.41) 36.07,86.79 36.32,87.05 C6.1 ; 128.63,18.7 MH3.1 ; MH3.1 131.32,25.12 ; MH3.1 128.63,24.08 ; MH3.1 131.32,17.65 ; MH3.1 127.58,21.39 ; C1157.2 v1(161.19,101.43) ; v1(8.74,67.44) 8.77,67.41 U131.2 ; J96.4 51.08,16.13 ; J96.4 48.67,17.16 ; J96.4 49.7,17.52 ; J96.4 50.73,17.16 ; J96.4 48.67,15.1 ; J96.4 48.32,16.13 ; J96.4 50.73,15.1 ; J96.4 49.7,14.75 ; v2(117.24,55.84) 116.75,55.35 C4.2 ; J36.1 30.02,67.67 ; J36.1 30.02,65.02 ; J36.1 27.38,65.02 ; J36.1 27.38,67.67 ; J36.1 28.7,65.02 ; J36.1 30.02,66.34 ; J36.1 28.7,67.67 ; J96.5 40.03,15.1 ; J96.5 40.38,16.13 ; J96.5 37.97,15.1 ; J96.5 37.62,16.13 ; J96.5 39,14.75 ; 231.98,33.84 J39.8 ; J39.8 233.95,35.81 ; J39.8 233.95,33.84 ; J39.8 231.65,34.82 ; J39.8 231.98,35.81 ; C1627.2 v1(126.41,160.52) ; 44.17,34.1 J96.1 ; J96.1 45.2,33.75 ; J96.1 46.23,36.16 ; J96.1 46.58,35.13 ; J96.1 46.23,34.1 ; J96.1 44.17,36.16 ; J96.1 45.2,36.52 ; J96.1 43.82,35.13 ; J39.4 233.95,30.73 ; J39.4 231.98,30.73 ; J39.4 231.98,28.76 ; J39.4 231.65,29.74 ; J39.4 233.95,28.76 ; v1(153.87,95.71) 153.72,95.55 C923.2 C920.2 ; C1180.2 v1(167.54,105.24) ; C11.1 v1(35.18,88.44) ; C878.2 v1(11.23,121.24) ; 53.86,55.18 J1.2 ; J1.2 53.51,56.21 ; J1.2 53.86,57.24 ; J1.2 55.92,57.24 ; J1.2 54.89,54.82 ; J1.2 55.92,55.18 ; J1.2 54.89,57.59 ; J39.10 233.95,38.35 ; J39.10 231.98,36.38 ; J39.10 233.95,36.38 ; J39.10 231.98,38.35 ; C811.2 v1(17.06,127.77) ; U61.A2 v4(81.16,64.04) ; C290.2 C1645.2 v1(56.41,150.96) ; 224.41,15.37 J25.1 ; J25.1 225.39,17.67 ; J25.1 223.42,15.7 ; J25.1 223.42,17.67 ; J25.1 224.41,18.01 ; J25.1 225.39,15.7 ; J25.1 225.73,16.69 ; J25.1 223.09,16.69 ; C1442.2 v1(162.39,121.99) ; C132.2 v1(134.75,18.11) ; v1(167.83,40.63) 167.7,40.5 v1(166.68,40.5) C1182.2 ; v1(167.83,40.63) 167.83,40.63 R222.2 R223.2 ; v1(167.83,40.63) C1225.2 ; R1318.2 207.47,104.19 v1(207.47,103.41) ; R204.2 44.67,140.51 v1(45.06,140.51) 45.72,140.51 45.84,140.39 R200.2 ; v1(120.36,115.48) 120.99,116.11 C236.2 ; 220.68,62.28 J23.1 ; J23.1 223.32,62.28 ; J23.1 222,63.6 ; J23.1 222.98,61.3 ; J23.1 222.98,63.27 ; J23.1 221.01,63.27 ; J23.1 221.01,61.3 ; C499.2 196.43,136.37 ; C499.2 195.45,134.07 ; C499.2 197.75,135.05 ; C499.2 196.43,133.73 ; C499.2 197.42,134.07 ; C499.2 195.11,135.05 ; C499.2 197.42,136.04 ; R377.2 153.54,75.74 v1(153.16,75.74) 152.91,75.49 R383.2 ; C1572.2 151.39,55.04 R184.2 150.62,55.08 v1(150.5,54.95) ; 231.98,38.92 J39.12 ; J39.12 231.65,39.9 ; J39.12 231.98,40.89 ; J39.12 233.95,38.92 ; J39.12 233.95,40.89 ; v4(167.56,87.45) 167.51,87.4 C1203.2 ; U28.12 49.93,147.84 v1(49.56,148.21) ; R46.2 v1(221.69,27.02) ; C842.2 v1(8.7,139.31) ; C82.2 37.9,146.48 v1(38.61,145.77) ; C180.2 C178.2 110.46,31.3 v1(110.39,31.37) ; C180.2 C181.2 115.88,31.3 v1(116.02,31.44) ; C180.2 112.65,30.96 v1(113,30.61) ; v4(73.16,63.24) U61.K1 ; 139.45,22.26 v1(141.13,22.26) ; 139.45,22.26 U5.17 ; 139.45,22.26 140.53,21.18 U5.10 ; v1(176.07,120.44) 176.64,120.44 177.31,121.11 C163.2 177.31,121.29 176.66,121.94 v1(176.01,121.94) ; R1317.2 207.47,93.78 v1(207.47,92.99) ; C1643.2 v1(54.55,167.62) ; v1(141.13,23.41) 139.51,23.41 U5.17 ; C1301.2 69.38,123.22 v2(69.32,123.17) ; C5.2 50.16,82.09 v1(50.42,81.84) ; J1.7 22.03,42.74 ; J1.7 19.97,40.68 ; J1.7 19.62,41.71 ; J1.7 21,40.32 ; J1.7 19.97,42.74 ; J1.7 21,43.09 ; J1.7 22.38,41.71 ; J1.7 22.03,40.68 ; R434.2 188.56,144.71 v1(188.85,145) ; v1(35.51,66.59) 35.51,65.71 C39.2 ; R156.2 204.38,57.32 v1(204.09,57.03) ; v1(153.16,80.82) 152.91,81.08 C1455.2 ; U60.N1 v4(70.76,35.04) ; R1155.2 222.34,55.18 222.3,55.14 C1396.2 221.57,55.39 v1(221.11,55.85) ; v1(142.08,107.11) 142.74,107.11 C1187.2 142.52,108.33 v1(142.06,108.33) ; v1(126.82,108.94) 126.82,107.78 C1748.2 125.4,107.81 v1(125.4,108.94) ; v1(1.22,164.64) 1.62,164.24 C1566.2 ; v1(181.4,67.1) 181.62,66.88 C1599.2 ; R116.2 C1467.2 v1(153.03,40.18) ; v1(215.26,158.23) 215.44,158.41 Q15.2 ; v1(142.78,136.82) 142.79,136.81 C1604.2 ; C1345.2 53.49,28.07 v1(53.45,28.03) ; C1166.2 156.19,54.05 C249.2 ; C1332.2 137.75,53.35 v2(138.24,53.84) ; 6.12,60.71 J1.9 ; J1.9 7.5,62.09 ; J1.9 7.5,59.32 ; J1.9 8.53,59.68 ; J1.9 6.47,59.68 ; J1.9 8.53,61.74 ; J1.9 6.47,61.74 ; J1.9 8.88,60.71 ; U63.M9 v4(72.36,84.53) ; U60.M9 v4(72.36,42.24) ; C1279.2 94.83,120.72 v2(95.23,120.32) ; v2(87.23,117.32) 87.41,117.14 C1291.2 ; C1389.2 v1(60.98,131.1) 62.57,131.1 v1(62.72,130.94) 62.72,131.85 C1388.2 63.21,132.26 63.56,131.91 v1(63.56,130.97) ; C1296.2 78.34,107.59 v1(78.01,107.25) ; U114.10 v1(21.78,106.98) ; v3(37.3,138.11) 37.33,138.08 C109.2 ; C204.2 99.59,23.21 v1(100.55,24.18) ; v2(97.23,117.32) 96.79,116.89 C1282.2 ; 227.67,64.01 J52.9 ; J52.9 227.67,65.97 ; J52.9 229.64,65.97 ; J52.9 229.64,64.01 ; J52.9 227.33,64.99 ; v1(170.89,41.81) 171.07,41.99 C501.2 ; C821.2 v1(9.66,141.73) ; 231.98,43.43 J39.14 ; J39.14 233.95,41.46 ; J39.14 231.65,42.44 ; J39.14 231.98,41.46 ; J39.14 233.95,43.43 ; v4(73.16,49.14) U64.K1 ; 19.97,15.1 J96.7 ; J96.7 21,17.52 ; J96.7 21,14.75 ; J96.7 22.03,17.16 ; J96.7 19.97,17.16 ; J96.7 19.62,16.13 ; J96.7 22.38,16.13 ; J96.7 22.03,15.1 ; D39.2 136.33,106.44 v1(136.46,106.57) ; U43.10 v1(147.67,18.57) ; C1656.2 v1(133.51,153.52) ; C713.2 v1(122.68,101.77) ; v2(76.32,110.17) 76.06,110.43 C1284.2 ; U60.B2 v4(80.36,35.84) ; U60.A8 v4(81.16,41.44) ; R50.2 60.11,69.98 v1(60.07,69.94) ; C250.2 154.44,58.59 154.23,58.8 154.23,59.52 154.76,60.05 v4(154.76,60.06) ; U63.N1 v4(70.76,77.33) ; C1285.2 72.03,115.46 v2(72.32,115.17) ; 26.28,173.84 J10.SH2 ; J10.SH2 26.86,172.27 ; J10.SH2 30.57,173.84 ; J1.1 45.2,62.09 ; J1.1 43.82,60.71 ; J1.1 46.58,60.71 ; J1.1 46.23,61.74 ; J1.1 44.17,61.74 ; J1.1 46.23,59.68 ; v1(218.95,164.58) 219.08,164.7 R487.2 ; R581.2 v1(138.27,115.64) ; C803.2 v1(23.23,143.13) ; v4(154.76,74.95) 154.61,75.1 R384.2 ; C1481.2 v1(142.37,30.4) ; C15.2 119.96,121.58 v1(119.99,121.62) ; C73.2 v1(230.89,91.19) ; v1(223.09,44.47) C1443.2 ; C1463.2 152.78,45.9 v1(153.16,46.28) ; R170.2 207.47,83.36 v1(207.47,82.58) ; C859.2 v1(36.21,109.59) ; 103.07,127.82 J105.6 ; J105.6 104.05,128.16 ; J105.6 102.08,128.16 ; v1(186.09,145.5) 186.27,145.32 C98.2 ; v1(28.19,125.22) 27.93,125.48 C775.2 ; C1476.2 v1(111.83,101.77) ; U61.E8 v4(77.96,69.64) ; v1(153.16,71.68) 153.16,71.17 152.91,70.92 C1465.2 152.39,70.53 151.89,70.03 R22.2 ; v1(60.07,72.48) 60.16,72.4 R40.2 ; U62.F1 v4(77.16,91.43) ; MH4.1 5.46,149.85 ; MH4.1 8.15,148.8 ; MH4.1 5.46,142.38 ; MH4.1 8.15,143.42 ; MH4.1 9.19,146.11 ; C1578.2 124.84,33.07 124.82,33.1 v1(124.82,33.76) ; J1.8 12,43.09 ; J1.8 10.97,42.74 ; J1.8 10.62,41.71 ; J1.8 13.38,41.71 ; J1.8 13.03,40.68 ; J1.8 10.97,40.68 ; J1.8 12,40.32 ; J1.8 13.03,42.74 ; v1(153.16,48.82) 152.53,49.45 R380.2 ; 200.28,34.29 J38.1 ; J38.1 201.26,36.6 ; J38.1 199.47,36.42 ; J38.1 201.26,34.63 ; J38.1 201.6,35.61 ; J38.1 199.21,35.61 ; R378.2 153.03,74.35 v1(153.16,74.47) ; C1568.2 v1(153.16,41.58) ; C1649.2 v1(122.96,170.21) ; v1(190.03,166.35) 190.32,166.64 U71.3 ; 49.7,40.32 J1.4 ; J1.4 50.73,40.68 ; J1.4 48.67,42.74 ; J1.4 48.32,41.71 ; J1.4 51.08,41.71 ; J1.4 49.7,43.09 ; J1.4 48.67,40.68 ; J1.4 50.73,42.74 ; v1(154.96,101.43) 154.84,101.31 C1155.2 ; v3(38.29,138.11) 38.44,137.96 C135.2 39.25,137.08 39.66,136.67 C114.2 ; R775.2 22.98,137 v1(23.42,137.44) ; J1.10 17.88,60.71 ; J1.10 17.53,61.74 ; J1.10 17.53,59.68 ; J1.10 15.12,60.71 ; J1.10 16.5,62.09 ; J1.10 16.5,59.32 ; J1.10 15.47,61.74 ; J1.10 15.47,59.68 ; R59.2 48.1,138.35 v1(47.64,137.89) ; v1(64.94,131.01) 64.94,131.92 C1390.2 65.51,132.26 arc(65.67,132.19) 65.74,132.03 65.74,131.07 v1(65.77,131.04) ; U62.M9 v4(72.36,98.63) ; C843.2 15.85,132.22 v5(15.5,132.57) ; C589.2 94.31,101.68 v1(94.41,101.78) ; U60.A2 v4(81.16,35.84) ; 231.65,44.98 J39.16 ; J39.16 233.95,44 ; J39.16 233.95,45.97 ; J39.16 232.97,46.3 ; J39.16 231.98,44 ; J39.16 231.98,45.97 ; J26.1 200.84,129.34 ; J26.1 200.5,128.35 ; J26.1 198.53,130.32 ; J26.1 200.5,130.32 ; J26.1 199.52,130.66 ; J26.1 198.2,129.34 ; J26.1 198.53,128.35 ; C1287.2 82.15,122.34 v2(82.32,122.17) ; C1306.2 v1(157.61,22.78) ; v1(174.08,67.59) 173.89,67.78 C157.2 ; U63.E9 v4(77.96,84.53) ; v1(35.13,133.65) 34.6,133.13 R73.1 ; C1011.2 v1(131.73,153.52) ; U64.B2 v4(80.36,49.94) ; U61.H9 v4(75.56,70.44) ; J110.2 27.92,127.19 ; J110.2 25.61,128.18 ; J110.2 25.95,129.16 ; J110.2 25.95,127.19 ; U12.2 147.76,113.21 v1(147.41,113.56) 147.71,113.86 U12.1 ; v1(167.16,101.6) 167.54,101.22 C1159.2 ; J1.6 31.03,42.74 ; J1.6 31.38,41.71 ; J1.6 28.97,40.68 ; J1.6 30,43.09 ; J1.6 28.97,42.74 ; J1.6 28.62,41.71 ; J1.6 31.03,40.68 ; J1.6 30,40.32 ; Q11.2 v1(207.7,158.32) ; v1(28.75,126.11) 29.98,126.11 C788.2 29.93,127 v1(28.75,127) ; R821.2 34.52,106.35 v1(34.01,105.84) ; C1288.2 69.13,109.97 v2(69.32,110.17) ; R69.2 v1(45.08,135.43) ; v1(59.34,92.91) 60.12,92.91 C516.2 60.12,93.8 v1(59.34,93.8) ; 15.47,36.16 J96.10 ; J96.10 16.5,33.75 ; J96.10 17.88,35.13 ; J96.10 15.47,34.1 ; J96.10 17.53,34.1 ; J96.10 16.5,36.52 ; J96.10 15.12,35.13 ; J96.10 17.53,36.16 ; C1462.2 C160.2 152.78,47.17 v1(153.16,47.55) ; C848.2 162.77,21.91 v1(162.77,22.47) ; v5(21.9,140.57) 22.29,140.96 22.29,142.03 C805.2 ; U60.K9 v4(73.96,42.24) ; v1(99.57,101.8) 99.57,101.74 99.54,101.7 99.54,101.69 99.39,101.54 C628.2 ; R216.2 77.84,123.65 v2(78.32,123.17) ; v1(121.43,25.02) 121.48,24.97 122.23,24.97 122.81,25.55 L87.2 122.09,26.41 v1(121.73,26.05) ; J96.2 55.92,29.6 ; J96.2 54.89,29.25 ; J96.2 53.51,30.63 ; J96.2 54.89,32.02 ; J96.2 56.27,30.63 ; J96.2 53.86,31.66 ; J96.2 53.86,29.6 ; J96.2 55.92,31.66 ; C111.2 37.08,141.32 v3(37.3,141.1) ; C65.2 60.78,46.47 v1(60.41,46.84) 60.05,46.47 59.28,46.47 59.04,46.24 C69.2 ; C1625.2 v1(53.54,172.2) ; 172.97,143.13 J24.1 ; J24.1 172.97,145.77 ; J24.1 174.29,144.45 ; J24.1 171.99,143.47 ; J24.1 173.96,145.43 ; J24.1 171.65,144.45 ; J24.1 173.96,143.47 ; J24.1 171.99,145.43 ; U20.5 v1(58.12,40.13) ; v4(154.76,51.56) 153.47,52.85 C255.2 ; C874.2 41.41,109.51 v1(40.77,110.16) ; C27.2 86.8,25.32 v1(86.61,25.13) ; v1(92.68,32.99) 92.68,32.01 C1736.2 91.57,31.95 v1(91.57,32.99) ; J83.6 v1(15,168.91) ; C1295.2 87.12,110.43 v2(87.23,110.32) ; v1(169.42,89.33) 169.42,88.3 C1745.2 170.43,88.8 v1(170.43,89.33) ; U63.E8 v4(77.96,83.73) ; U63.T1 v4(68.36,77.33) ; v1(60.07,71.21) 60.11,71.25 R41.2 ; v1(132.62,29.91) 132.72,30.01 R548.2 R560.2 ; U51.11 205.13,153.34 v1(205.28,153.5) 204.79,153.99 U51.12 ; C1587.2 v1(236.52,117.54) ; C870.2 v1(34.68,110.24) ; C810.2 16.9,129.97 v5(17.1,130.17) ; v1(128.96,30.18) 128.65,30.48 C1516.2 ; v1(9.3,119.47) 9.15,119.32 C865.2 ; v1(153.16,79.55) 152.78,79.93 C1452.2 ; v1(119.93,161.55) 120.73,161.55 C1109.2 120.77,162.34 v1(119.93,162.34) ; C103.2 35.03,137.08 35.31,137.36 v3(35.31,138.11) ; C1653.2 v1(123.1,153.52) ; R486.2 220.73,164.73 v1(220.9,164.55) ; R194.2 106.32,23.79 v3(106.39,23.87) 106.39,24.78 106.71,25.1 C701.2 ; U60.T1 v4(68.36,35.04) ; v1(16.18,122.17) 15.74,122.61 C1343.2 ; v1(88.19,124.71) 88.19,125.49 C1425.2 87.13,125.51 v1(87.13,124.69) ; U41.1 217.68,70.4 v1(218.06,70.03) ; J52.10 232.18,64.01 ; J52.10 230.21,65.97 ; J52.10 232.51,64.99 ; J52.10 230.21,64.01 ; J52.10 232.18,65.97 ; C852.2 166.06,17.98 v1(165.55,18.48) ; v1(203.38,155.07) 203.63,155.32 Q10.2 ; C1650.2 v1(125.9,166.49) ; U63.F1 v4(77.16,77.33) ; C1654.2 v1(124.75,153.52) ; C62.2 v1(52.07,75.07) ; v1(37.4,119.43) 37.4,116.21 37.77,115.84 C1317.2 ; C141.2 36.19,138 v3(36.3,138.11) ; U62.D2 v4(78.76,92.23) ; 231.98,33.27 J39.6 ; J39.6 231.98,31.3 ; J39.6 231.65,32.28 ; J39.6 233.95,31.3 ; J39.6 233.95,33.27 ; Q14.2 213.54,158.4 v1(213.46,158.33) ; U61.A8 v4(81.16,69.64) ; U60.H1 v4(75.56,35.04) ; v1(161.27,72.56) 161.27,70.94 C916.2 162.75,71.31 v1(162.75,72.56) ; v1(165.55,19.5) 165.87,19.81 C853.2 ; v1(55.84,62.76) C66.2 55.84,60.85 56.5,60.19 U3.1 ; v1(167.5,120.62) 168.47,120.62 C153.2 ; U61.N1 v4(70.76,63.24) ; v1(53.44,23.23) 52.82,23.23 52.07,23.98 C1346.2 ; MH7.1 10.18,92.03 ; MH7.1 7.49,90.98 ; MH7.1 10.18,97.41 ; MH7.1 7.49,98.45 ; MH7.1 11.23,94.72 ; v1(165.17,55.87) 164.77,55.87 C1486.2 164.28,54.7 v1(165.17,54.7) ; 63.35,153.35 63.35,153.35 U26.3 ; 63.35,153.35 v1(63.36,153.35) ; 63.35,153.35 63.26,153.35 C1648.2 C288.2 v1(60.09,150.96) ; C1392.2 76.08,117.92 v2(76.32,118.17) ; C825.2 v1(8.05,141.52) ; C70.2 v1(32.5,83.61) ; C74.2 234.05,79.73 v1(234.2,79.88) 233.84,80.25 U42.1 ; C1530.2 v1(195.79,44.17) ; J78.4 26.29,90.32 ; J78.4 24.97,91.64 ; J78.4 23.99,91.31 ; J78.4 25.96,91.31 ; J78.4 23.99,89.34 ; J78.4 23.65,90.32 ; J78.4 25.96,89.34 ; U61.H1 v4(75.56,63.24) ; C1485.2 v1(121.13,101.77) ; C1344.2 v1(57.61,24.06) ; v1(211.51,158.33) 211.63,158.45 Q13.2 ; v2(79.32,115.17) 79.41,115.26 C1286.2 ; v1(209.54,158.33) 209.6,158.4 Q12.2 ; R1190.2 v1(58.95,35.39) ; 32.77,129.54 32.77,129.21 v1(32.28,128.73) ; v1(101.04,101.78) 100.96,101.7 C1520.2 ; 25.5,33.75 25.5,35.13 ; 25.5,35.13 26.53,36.16 ; 25.5,35.13 26.88,35.13 ; 25.5,35.13 24.47,34.1 ; 25.5,35.13 26.53,34.1 ; 25.5,35.13 25.5,36.52 ; 25.5,35.13 24.12,35.13 ; 25.5,35.13 24.47,36.16 ; v1(124.38,126.16) 123.3,126.16 C1740.2 123.27,127.41 v1(124.41,127.41) ; v1(207.72,57.84) 207.25,57.36 C125.2 ; U64.D8 v4(78.76,55.54) ; v1(8.61,162.96) 8.01,163.56 U154.13 ; J10.SH1 46.92,173.84 ; J10.SH1 42.63,173.84 ; J10.SH1 46.34,172.27 ; R805.2 v1(9.38,118.25) ; U63.B2 v4(80.36,78.13) ; v1(5.79,159.43) 5.38,159.84 5.38,160.18 C1361.2 ; U62.T1 v4(68.36,91.43) ; C1206.2 162.71,30.86 v4(162.76,30.81) ; v1(23.74,171.66) 23.74,172.59 J83.10 24.74,172.61 v1(24.74,171.66) ; v5(15.5,136.57) 15.61,136.46 C835.2 ; C123.2 v1(61.57,24.02) ; C295.2 6.59,73.85 C57.2 6.59,75.86 v1(6.53,75.92) ; v1(164.27,27.94) 164.27,28.06 164.45,28.24 R944.2 ; C794.2 v1(17.16,141.64) ; v1(31.52,135.46) 31.91,135.07 C136.2 32.26,135.07 C115.2 ; C1626.2 v1(51.46,150.96) ; v1(98.12,101.85) 98.17,101.8 98.17,101.06 C1547.2 ; v1(178.94,36.63) 179.96,37.64 R193.2 ; v1(149.56,134.34) 150.1,133.8 C1636.2 ; v1(62.23,117.99) 61.93,117.69 C1356.2 ; C110.2 v3(38.29,140.11) ; v2(76.32,113.17) 76.14,113.35 C1283.2 ; R138.2 v1(142.19,18.2) ; v2(112.24,71.84) 111.75,71.35 C856.2 ; C239.2 v1(54.1,74.97) ; R484.2 v1(230.25,166.09) ; U132.3 v1(140.29,155.81) ; v1(82.93,79.81) 83.7,79.04 R1002.2 ; U60.D8 v4(78.76,41.44) ; U62.C9 v4(79.56,98.63) ; C1480.2 v1(108.73,101.77) ; v5(18.7,133.37) 18.71,133.38 C822.2 ; v1(167.83,82.92) 168.82,82.92 C906.2 ; Q26.2 v1(202.99,162.06) ; v2(122.24,57.84) 122.73,57.35 C1331.2 ; C470.2 10.92,63.6 v1(10.77,63.45) ; C1747.2 v1(167.08,112.81) ; v1(155.75,105.21) 156.11,104.85 C1179.2 ; C1242.2 88.65,108.39 88.53,108.27 C1290.2 88.04,108 v1(87.52,107.48) ; Z121.2 164.82,133.72 164.38,133.29 161.86,133.29 161.48,133.67 v1(161.48,133.9) ; U64.K9 v4(73.96,56.34) ; v1(57.68,117.12) 57.46,117.34 C1342.2 ; 115.93,140.28 MH2.1 ; MH2.1 122.35,137.59 ; MH2.1 118.62,141.33 ; MH2.1 115.93,134.9 ; MH2.1 114.88,137.59 ; MH2.1 121.31,140.28 ; MH2.1 121.31,134.9 ; 33.12,60.71 J1.12 ; J1.12 34.5,59.32 ; J1.12 33.47,59.68 ; J1.12 33.47,61.74 ; C1640.2 6.59,86.68 C1583.2 6.59,88.69 v1(6.53,88.75) ; C1246.2 92.97,108.03 v1(92.97,107.41) 93.24,107.69 C1233.2 ; R45.2 204.52,29.83 204.82,30.14 v1(204.82,30.73) ; C540.2 v1(129.07,15.57) ; Q58.2 203.41,165.82 204.05,166.46 v1(204.67,166.46) ; Q59.2 40.7,142.04 C139.2 C113.2 38.6,141.41 v3(38.29,141.1) ; v1(147.41,111.4) 147.91,111.91 U12.4 ; Q8.2 v1(200.71,156.41) ; 38.92,76.2 v1(38.1,76.2) ; v1(34.57,112.83) 34.57,113 34.99,113.43 C869.2 ; v1(173.96,47.93) 174.35,47.55 Z120.2 ; C1483.2 v1(110.28,101.77) ; U60.G8 v4(76.36,41.44) ; U109.1 23.8,123.17 23.32,122.68 23.09,122.68 v1(23.04,122.73) ; U60.K1 v4(73.16,35.04) ; C1571.2 C334.2 153.09,73.15 v1(153.16,73.08) 153.8,72.44 C1199.2 ; v1(158.6,82.87) C908.2 v1(160.02,84.25) ; C849.2 162.89,17.85 v1(163.52,18.48) ; U61.T1 v4(68.36,63.24) ; C83.2 38.54,138.86 v3(38.29,139.11) ; v1(54.01,148.34) 53.88,148.46 C41.2 53.87,149.1 C893.2 ; C1245.2 102.52,124.06 v1(102.7,124.24) ; C1628.2 v1(121.45,153.52) ; v1(187.73,75.95) 186.62,75.95 C918.2 186.44,74.7 v1(187.71,74.7) ; C137.2 C84.2 35.43,141.23 v3(35.31,141.1) ; U62.A2 v4(81.16,92.23) ; v1(187.02,33.1) 186.9,32.97 R756.2 ; U5.17 v1(136.85,22.81) ; R892.2 v1(179.88,169.53) ; C633.2 132.96,16.04 v1(133.25,16.33) ; R1124.2 v1(22.91,140.51) ; v2(101.23,109.32) 101.29,109.38 C1294.2 ; C1298.2 94.73,112.83 v2(95.23,113.32) ; v4(73.16,77.33) U63.K1 ; C116.2 35.06,138.86 v3(35.31,139.11) ; C1475.2 v1(143.64,30.53) ; R346.2 v1(111.76,171.06) ; v5(17.1,138.97) 16.5,139.57 C841.2 ; U62.B2 v4(80.36,92.23) ; v1(177.9,81.41) 177.9,80.56 C1749.2 176.68,80.52 v1(176.68,81.38) ; R51.2 60.11,68.71 v1(60.07,68.67) ; U63.K9 v4(73.96,84.53) ; C1718.2 v1(161.06,139.47) ; v1(177.55,14.81) 177.12,15.24 R9.2 ; R49.2 v1(220.69,31.11) ; C126.2 v1(55.25,74.96) ; U61.K9 v4(73.96,70.44) ; v1(53.59,129.47) 53.59,130.2 C1386.2 52.7,130.16 v1(52.7,129.47) ; v1(118.34,28.12) 118.11,28.35 C618.2 ; U60.C9 v4(79.56,42.24) ; R1074.2 50.35,115.03 v1(50.65,114.74) ; U71.1 191.62,166.74 v1(192.01,166.35) ; R600.2 v1(144.27,115.64) ; C1012.2 v1(120.3,158.19) ; R134.2 v1(215.11,154.03) ; C808.2 v1(12.87,127.57) ; v1(109.98,30.4) 109.47,30.91 C622.2 ; C8.2 v1(51.69,81.33) ; v1(123.95,108.05) 123.25,108.05 C903.2 123.09,109.58 v1(123.9,109.58) ; C1281.2 87.52,123.03 v2(88.23,122.32) ; U64.A8 v4(81.16,55.54) ; v4(73.16,91.43) U62.K1 ; U63.H1 v4(75.56,77.33) ; C837.2 v1(8.7,129.17) ; U61.G8 v4(76.36,69.64) ; 54.89,22.05 J96.3 ; J96.3 53.86,22.4 ; J96.3 53.86,24.46 ; R47.2 v1(221.69,19.4) ; v1(151.39,122.87) 151.68,122.59 R1154.2 ; R992.2 v1(54.13,134.59) ; U61.D2 v4(78.76,64.04) ; U62.E3 v4(77.96,93.83) ; U60.H9 v4(75.56,42.24) ; C1244.2 102.14,118.45 103.14,119.45 C1232.2 ; J83.9 13.42,173.1 v1(13.8,172.72) ; v1(45.08,138.93) 44.83,138.68 C133.2 ; U61.B2 v4(80.36,64.04) ; C1552.2 52.07,49.51 52.77,48.81 v1(53.44,48.81) ; C142.2 v1(30.6,134.67) ; C1156.2 162.84,105.54 v1(162.74,105.64) ; U61.C9 v4(79.56,70.44) ; R478.2 v1(224.73,161.76) ; R483.2 v1(225.93,164.67) ; C140.2 35.2,140 v3(35.31,140.11) ; U63.D8 v4(78.76,83.73) ; C7.2 v1(51.99,95.3) ; v1(76.32,109.17) 75.97,109.17 75.65,108.85 C1272.2 ; 53.86,50.04 J1.3 ; J1.3 53.86,47.98 ; J1.3 54.89,47.62 ; C1635.2 v1(180.77,57.52) ; C640.2 v1(125.35,139.66) ; U62.N1 v4(70.76,91.43) ; C124.2 187.96,134.01 v1(187.49,133.53) ; C1223.2 v1(168.91,96.25) ; C75.2 v1(57.18,139.83) ; C63.2 v1(50,75.75) ; U63.C9 v4(79.56,84.53) ; U63.H9 v4(75.56,84.53) ; U64.N1 v4(70.76,49.14) ; v1(18.93,118.3) 18.93,119.26 19.37,119.7 C866.2 19.75,119.7 20,119.44 v1(20,118.3) ; R896.2 165,98.99 v1(164.95,98.93) ; v1(17.68,90.04) 18.6,90.96 C64.2 ; v2(123.24,71.84) 122.74,71.35 C858.2 ; R1319.2 207.47,114.6 v1(207.47,113.82) ; U18.3 v1(206.33,21.89) ; C1647.2 v1(53.11,150.96) ; U63.E1 v4(77.96,77.33) ; C1586.2 v1(230.5,104.07) ; C864.2 v1(12.89,118.94) ; U61.E9 v4(77.96,70.44) ; R1001.2 82.86,91.12 v1(82.68,90.94) ; v1(142.14,110.52) 142.38,110.52 C1186.2 142.74,109.16 v1(142.08,109.16) ; U44.1 v1(42.53,73.83) ; C1243.2 93.61,126.15 93.94,125.82 v1(93.94,124.98) 94.11,124.82 94.11,124.76 94.23,124.65 R988.2 ; v1(31.57,116.89) 31.75,116.71 R827.2 ; v1(181.48,163.51) 182.07,163.51 182.45,163.13 C1108.2 182.45,161.38 182.83,161 v1(183.34,161) ; C1651.2 v1(120.3,159.95) ; v1(161.63,20) 162.01,19.62 C850.2 ; C774.2 28.44,116.12 v1(29.08,116.76) ; v3(39.5,105.66) 39.06,105.22 C862.2 ; R899.2 153.57,99.07 v1(153.7,98.95) ; U62.D8 v4(78.76,97.83) ; C834.2 v1(14.36,141.86) ; C252.2 R4.2 153.03,50.6 v1(153.26,50.37) ; v1(216.15,165.77) 215.27,165.77 R488.2 ; C1184.2 v1(153.67,109.65) ; C1642.2 v1(53.54,170.55) ; C873.2 v1(29.74,105.31) ; v1(211.07,153.72) 210.8,153.99 U51.13 ; C1277.2 90.46,117.09 v2(90.23,117.32) ; C289.2 50.92,158.93 v1(50.16,159.69) ; C253.2 153.83,63.8 v1(153.16,64.46) 153.13,64.43 R108.2 152.27,65.33 151.89,65.71 R20.2 ; C1655.2 v1(126.41,153.52) ; R48.2 v1(226.18,29.83) ; C1300.2 C1299.2 v1(80.27,106.51) ; C1293.2 97.3,124.52 97.75,124.97 99.08,124.97 99.46,124.59 C1269.2 ; v1(57.49,49.63) C1551.2 ; C1608.2 v1(238.42,99.17) ; v1(168.08,142.41) R1200.2 ; J83.12 v1(11.8,157.54) ; U63.A2 v4(81.16,78.13) ; v1(15.4,67.03) 14.64,66.28 C543.2 ; v1(116.48,101.77) 116.46,101.75 C1755.2 ; U64.E8 v4(77.96,55.54) ; C1716.2 v1(180.33,51.31) ; v1(111.38,162.99) 111.82,162.55 C466.2 ; C833.2 v1(9.08,127.01) ; C921.2 v1(114.93,101.74) ; C851.2 v1(167.39,22.03) ; C1289.2 v1(54.13,137.19) ; U62.E1 v4(77.96,91.43) ; U61.D8 v4(78.76,69.64) ; v1(42.55,132) 41.65,132.9 41.65,133.09 ; C806.2 v1(10.78,127.64) ; U63.E3 v4(77.96,79.73) ; R859.2 v1(11.44,72.85) ; v1(131.83,26.54) 131.83,27.71 C1750.2 ; R187.2 v1(150.52,62.13) ; v1(170.99,60.99) 170.14,60.99 C914.2 170.12,60.07 v1(171.02,60.07) ; C79.2 v1(26.67,141.96) ; U21.5 v1(33.51,80.56) ; U61.M9 v4(72.36,70.44) ; C467.2 v1(49.88,162.7) ; v1(151.13,110.92) 150.35,110.14 C1185.2 ; C1652.2 v1(129.71,153.52) ; J83.11 12.02,163.35 v1(12.41,162.97) ; C1176.2 v1(165.73,96.25) ; C1303.2 v1(144.12,21.14) ; U62.H9 v4(75.56,98.63) ; v1(59.61,65.51) 59.01,64.91 R43.2 ; C1742.2 v1(167.28,118.65) ; U61.E1 v4(77.96,63.24) ; C1.2 53.49,53.65 v9(53.45,53.61) ; C1573.2 v1(153.16,43.1) ; R808.2 v1(26.21,112.57) ; C1660.2 v1(238.04,118.23) ; C1183.2 v1(147.19,109.65) ; U62.A8 v4(81.16,97.83) ; C99.2 v1(40.05,73.36) ; C798.2 v1(23.04,127.53) ; R1104.2 v1(9.32,159.66) ; U62.H1 v4(75.56,91.43) ; Q2.2 v1(219.51,158.33) ; C1646.2 v1(49.81,150.96) ; U64.A2 v4(81.16,49.94) ; C1570.2 152.5,85.55 v1(153.16,84.89) 152.68,84.4 C1464.2 ; C828.2 v1(13.11,141.73) ; C801.2 v1(21.51,127.65) ; R1052.2 v1(51.64,124.08) ; U60.E8 v4(77.96,41.44) ; C1347.2 48.6,23.85 v1(47.98,23.23) ; C96.2 v1(51.38,74.49) ; U60.F1 v4(77.16,35.04) ; C820.2 v1(19.22,127.84) ; Z96.2 v3(187.53,34.51) ; R809.2 v1(31.01,105.31) ; v1(83.56,25.13) 83.56,25.58 C26.2 ; U64.D2 v4(78.76,49.94) ; C1395.2 151.72,119.67 151.87,119.53 v1(152.22,119.53) ; U64.H1 v4(75.56,49.14) ; v1(105.66,133.15) 106.18,132.63 R52.2 ; U64.E1 v4(77.96,49.14) ; C112.2 40.26,144.78 41.12,143.91 v1(41.15,143.91) ; R183.2 v1(150.5,58.08) ; v1(40.01,107.8) 40.26,108.05 40.26,108.89 40.13,109.01 C876.2 39.38,108.48 39.38,107.98 v1(39.22,107.82) ; C830.2 12.76,134.52 v5(12.3,134.97) ; U64.E9 v4(77.96,56.34) ; U61.F1 v4(77.16,63.24) ; U64.M9 v4(72.36,56.34) ; v1(132.37,129.03) 132.89,129.54 C162.2 ; C1013.2 v1(128.06,153.52) ; U64.G8 v4(76.36,55.54) ; R1141.2 85.23,115.89 v2(85.23,115.32) ; R891.2 v1(119.48,170.46) ; U62.K9 v4(73.96,98.63) ; v1(118.62,103.12) 119.09,103.12 C165.2 119.21,104.88 v1(118.6,104.88) ; R188.2 v1(150.5,59.13) ; J83.14 v1(20.7,157.48) ; U62.G8 v4(76.36,97.83) ; C1644.2 v1(54.76,150.96) ; R345.2 v1(49.96,172.2) ; U63.A8 v4(81.16,83.73) ; R12.2 v1(56.9,14.83) ; C525.2 v1(190.47,171.89) ; U64.H9 v4(75.56,56.34) ; U61.E3 v4(77.96,65.64) ; U64.F1 v4(77.16,49.14) ; U63.G8 v4(76.36,83.73) ; C1641.2 v1(50.18,160.69) ; U64.C9 v4(79.56,56.34) ; R481.2 v1(222.38,164.49) ; Q16.2 v1(217.48,158.32) ; C40.2 v1(36.15,70.01) ; U62.E9 v4(77.96,98.63) ; U64.E3 v4(77.96,51.54) ; R482.2 v1(224.16,164.67) ; U60.E9 v4(77.96,42.24) ; R815.2 v1(26.19,108.82) ; v1(183.27,44.28) R1199.2 ; U60.E1 v4(77.96,35.04) ; C72.2 v1(222,68.13) ; C1569.2 v1(153.16,44.63) ; C12.2 v1(39.6,95.55) ; U60.D2 v4(78.76,35.84) ; C173.2 v1(204.98,68.03) ; C894.2 v1(50.79,149.1) ; 170.18,70.77 v1(170.18,71.55) 170.18,72.46 C917.2 169.04,72.33 v1(169.04,71.55) 169.04,70.9 C909.2 170.18,70.77
  BOTTOM w0.508: 19.17,101.02 J31.5 ; J31.5 21.77,103.62 ; J31.5 21.77,101.02 ; J31.5 19.17,103.62 ; J31.5 18.71,102.32 ; J31.5 20.47,100.55 ; J31.5 22.24,102.32 ; 84.62,129.49 J34.4 ; J34.4 86.39,127.73 ; J34.4 87.68,128.19 ; J34.4 85.09,128.19 ; J34.4 88.15,129.49 ; 60.19,95.94 J33.2 ; J33.2 63.26,97.24 ; J33.2 59.73,97.24 ; J33.2 61.49,99 ; J33.2 62.79,98.54 ; J33.2 60.19,98.54 ; J32.2 57.71,112.95 ; J32.2 56.41,112.49 ; J32.2 57.71,115.55 ; J32.2 58.18,114.25 ; J32.2 55.11,115.55 ; J32.2 55.11,112.95 ; J32.2 56.41,116.02 ; J33.3 63.26,102.32 ; J33.3 62.79,101.02 ; J33.3 60.19,103.62 ; J33.3 60.19,101.02 ; J33.3 61.49,100.55 ; J33.3 59.73,102.32 ; J33.3 62.79,103.62 ; 54.65,102.32 J33.5 ; J33.5 57.71,101.02 ; J33.5 55.11,103.62 ; J33.5 56.41,104.08 ; J33.5 56.41,100.55 ; J33.5 58.18,102.32 ; J33.5 55.11,101.02 ; J33.5 57.71,103.62 ; J35.5 76.21,134.57 ; J35.5 72.68,134.57 ; J35.5 73.15,135.87 ; J35.5 75.75,135.87 ; J35.5 74.45,136.34 ; J30.4 32.41,99 ; J30.4 31.11,98.54 ; J30.4 32.41,95.47 ; J30.4 33.71,98.54 ; J30.4 31.11,95.94 ; J30.4 30.65,97.24 ; J30.3 28.63,101.02 ; J30.3 27.33,100.55 ; J30.3 26.03,101.02 ; J30.3 26.03,103.62 ; J30.3 25.57,102.32 ; J30.3 29.1,102.32 ; J30.3 28.63,103.62 ; J32.3 57.71,110.47 ; J32.3 57.71,107.87 ; J32.3 54.65,109.17 ; J32.3 58.18,109.17 ; J32.3 56.41,110.94 ; J32.3 56.41,107.41 ; J32.3 55.11,107.87 ; J34.3 82.6,135.87 ; J34.3 79.54,134.57 ; J34.3 83.07,134.57 ; J34.3 80.01,135.87 ; J34.3 81.31,136.34 ; 55.11,98.54 J33.4 ; J33.4 58.18,97.24 ; J33.4 57.71,95.94 ; J33.4 57.71,98.54 ; J33.4 56.41,99 ; J31.2 16.69,95.94 ; J31.2 15.39,99 ; J31.2 13.63,97.24 ; J31.2 17.16,97.24 ; J31.2 14.09,95.94 ; J31.2 15.39,95.47 ; J31.2 16.69,98.54 ; J31.2 14.09,98.54 ; J31.3 21.77,95.94 ; J31.3 20.47,95.47 ; J31.3 20.47,99 ; J31.3 18.71,97.24 ; J31.3 19.17,98.54 ; J31.3 19.17,95.94 ; J31.3 21.77,98.54 ; J31.3 22.24,97.24 ; 31.11,103.62 J30.2 ; J30.2 31.11,101.02 ; J30.2 30.65,102.32 ; J30.2 33.71,101.02 ; J30.2 32.41,100.55 ; J34.5 83.07,129.49 ; J34.5 79.54,129.49 ; J34.5 82.6,130.79 ; J34.5 80.01,130.79 ; 26.03,98.54 J30.5 ; J30.5 27.33,95.47 ; J30.5 28.63,95.94 ; J30.5 28.63,98.54 ; J30.5 26.03,95.94 ; J30.5 27.33,99 ; J30.5 25.57,97.24 ; J30.5 29.1,97.24 ; J35.4 69.37,136.34 ; J35.4 70.67,135.87 ; J35.4 71.13,134.57 ; 61.49,112.49 J32.4 ; J32.4 62.79,112.95 ; J32.4 59.73,114.25 ; J32.4 62.79,115.55 ; J32.4 60.19,115.55 ; J32.4 60.19,112.95 ; J32.4 61.49,116.02 ; J32.5 61.49,110.94 ; J32.5 60.19,110.47 ; J32.5 62.79,110.47 ; J32.5 59.73,109.17 ; 192.49,27.15 193.18,27.15 C1404.2 ; 72.68,129.49 J35.3 ; J35.3 76.21,129.49 ; J35.3 75.75,130.79 ; J35.3 73.15,130.79 ; 84.62,134.57 J34.2 ; J34.2 87.68,135.87 ; J34.2 88.15,134.57 ; J34.2 86.39,136.34 ; J34.2 85.09,135.87 ; v1(233.17,129.21) C1634.2 v1(234.51,128.11) ; 14.09,101.02 J31.4 ; J31.4 16.69,103.62 ; J31.4 17.16,102.32 ; J31.4 16.69,101.02 ; J31.4 15.39,100.55
  BOTTOM w0.762: v1(195.03,28.16) 195.03,27.78 ; 195.03,27.78 194.97,27.73 C1404.2 ; 195.03,27.78 v1(195.03,27.4)
  vias: v1(0.95,172.66) v1(0.95,170.12) v1(0.95,159.96) v1(0.95,157.42) v1(0.95,154.88) v1(0.95,152.34) v1(0.95,149.8) v1(0.95,147.26) v1(0.95,144.72) v1(0.95,142.18) v1(0.95,139.64) v1(0.95,137.1) v1(0.95,134.56) v1(0.95,132.02) v1(0.95,129.48) v1(0.95,126.94) v1(0.95,124.4) v1(0.95,121.86) v1(0.95,119.32) v1(0.95,116.78) v1(0.95,114.24) v1(0.95,111.7) v1(0.95,109.16) v1(0.95,106.62) v1(0.95,104.08) v1(0.95,101.54) v1(0.95,99) v1(0.95,96.46) v1(0.95,93.92) v1(0.95,91.38) v1(0.95,77.41) v1(0.95,63.44) v1(0.95,60.9) v1(0.95,58.36) v1(0.95,55.82) v1(0.95,53.28) v1(0.95,50.74) v1(0.95,48.2) v1(0.95,45.66) v1(0.95,43.12) v1(0.95,40.58) v1(0.95,38.04) v1(0.95,35.5) v1(0.95,32.96) v1(0.95,30.42) v1(0.95,27.88) v1(0.95,25.34) v1(0.95,22.8) v1(0.95,20.26) v1(0.95,17.72) v1(0.95,15.18) v1(0.95,12.64) v1(0.95,10.1) v1(0.95,7.56) v1(1.95,174.99) v1(2.33,5.42) v1(4.49,174.99) v1(4.87,5.42) v1(7.03,174.99) v1(7.04,165.63) v1(7.41,5.42) v1(9.57,174.99) v1(9.95,5.42) v1(12.11,174.99) v1(12.49,5.42) v1(14.06,12.5) v1(14.06,9.96) v1(14.06,7.42) v1(14.65,174.99) v1(15.4,68.55) v1(16.31,13.68) v1(16.92,68.55) v1(16.92,67.03) v1(17.19,174.99) v1(17.45,84.15) v1(17.45,82.83) v1(17.53,81.53) v1(17.53,80.31) v1(17.5,78.54) v1(18.85,13.68) v1(19.73,174.99) v1(21.39,13.68) v1(21.72,149.78) v1(21.72,148.89) v1(22.27,174.99) v1(22.44,101.78) v1(23.93,13.68) v1(24.81,174.99) v1(25.37,101.78) v1(25.65,132.51) v1(26.16,133.02) v1(26.47,13.68) v1(26.67,132.51) v1(29.01,13.68) v1(31.55,13.68) v1(31.75,110.95) v1(32.43,174.99) v1(34.09,13.68) v1(34.97,174.99) v1(35.39,89.77) v1(36.2,89.77) v1(37.51,174.99) v1(38.25,120.4) v1(39.19,62.55) v1(39.62,120.83) v1(39.62,120.07) v1(40.05,174.99) v1(40.59,62.55) v1(40.69,72.84) v1(40.69,71.08) v1(40.69,69.41) v1(40.69,57.96) v1(40.69,44.5) v1(40.69,32.39) v1(40.69,18.93) v1(41.58,57.96) v1(41.58,32.39) v1(41.83,44.5) v1(41.83,18.93) v1(41.99,62.92) v1(42.09,72.84) v1(42.09,71.08) v1(42.09,69.41) v1(42.6,57.96) v1(42.6,32.39) v1(42.98,44.5) v1(42.98,18.93) v1(43.68,13.66) v1(43.75,64.32) v1(43.75,62.92) v1(44.76,62.78) v1(45.01,114.88) v1(44.99,102.67) v1(44.96,100.98) v1(45.19,70.1) v1(45.59,116.15) v1(46,102.67) v1(45.98,100.98) v1(46.14,136.89) v1(46.1,115.34) v1(46.51,116.43) v1(46.59,70.1) v1(46.89,137.39) v1(47.02,62.78) v1(47.64,136.89) v1(47.67,174.99) v1(47.81,118.77) v1(47.81,117.88) v1(48.56,62.72) v1(49.61,68.6) v1(50.21,174.99) v1(50.32,64.12) v1(50.32,62.72) v1(51.38,68.6) v1(51.38,67.2) v1(52.75,174.99) v1(55.29,174.99) v1(56.42,133.07) v1(56.42,132.07) v1(56.95,107.21) v1(56.95,104.28) v1(57.17,132.57) v1(57.83,174.99) v1(57.92,133.07) v1(57.92,132.07) v1(57.9,128.04) v1(57.9,126.89) v1(57.9,125.75) v1(59.16,14.23) v1(60.37,174.99) v1(61.9,88.78) v1(61.9,87.28) v1(62.23,118.88) v1(62.16,14.23) v1(62.91,174.99) v1(62.9,87.28) v1(63.18,18.02) v1(63.18,14.23) v1(65.45,174.99) v1(65.5,144.71) v1(66.18,18.02) v1(66.18,14.23) v1(67.54,21.32) v1(67.54,17.53) v1(67.99,174.99) v1(69.51,144.52) v1(70.1,144.92) v1(70.53,174.99) v1(70.54,21.32) v1(70.54,17.53) v1(70.54,13.73) v1(73.07,174.99) v1(73.54,17.53) v1(73.54,13.73) v1(74.91,20.05) v1(74.91,16.26) v1(75.61,174.99) v1(77.91,20.05) v1(77.91,16.26) v1(78.15,174.99) v1(80.04,17.9) v1(80.04,14.11) v1(80.69,174.99) v1(83.04,17.9) v1(83.04,14.11) v1(83.23,174.99) v1(83.56,24.11) v1(83.56,23.1) v1(83.56,22.08) v1(84.45,19.04) v1(84.45,15.57) v1(84.57,25.13) v1(84.57,24.11) v1(84.57,23.1) v1(84.57,22.08) v1(85.59,25.13) v1(85.59,24.11) v1(85.59,23.1) v1(85.77,174.99) v1(86.61,24.11) v1(87.45,19.04) v1(87.45,15.57) v1(88.31,174.99) v1(88.8,17.77) v1(88.8,13.97) v1(89.13,28.04) v1(90.13,28.04) v1(90.85,174.99) v1(91.8,17.77) v1(91.8,13.97) v1(93.16,19.62) v1(93.16,15.83) v1(93.39,174.99) v1(95.93,174.99) v1(96.16,19.62) v1(96.16,15.83) v1(97.65,19.62) v1(97.65,15.83) v1(98.47,174.99) v1(100.65,19.62) v1(100.65,15.83) v1(100.77,32.87) v1(101.01,174.99) v1(101.65,18.02) v1(101.65,14.23) v1(101.86,32.89) v1(103.25,32.94) v1(103.55,174.99) v1(104.35,32.89) v1(104.65,18.02) v1(104.65,14.23) v1(105.64,102.91) v1(105.65,19.75) v1(105.65,15.95) v1(106.09,174.99) v1(108.63,174.99) v1(108.65,19.75) v1(108.65,15.95) v1(109.65,18.02) v1(109.65,14.23) v1(111.17,174.99) v1(112.65,18.02) v1(112.65,14.23) v1(113.71,174.99) v1(113.65,19.75) v1(113.65,15.95) v1(116.25,174.99) v1(116.65,19.75) v1(116.65,15.95) v1(117.65,18.02) v1(117.65,14.23) v1(118.79,174.99) v1(120.65,18.02) v1(120.65,14.23) v1(121.33,174.99) v1(122.54,19.75) v1(122.54,15.95) v1(123.87,174.99) v1(125.54,19.75) v1(125.54,15.95) v1(125.65,18.02) v1(125.65,14.23) v1(126.41,174.99) v1(128.65,18.02) v1(128.65,14.23) v1(128.95,174.99) v1(129.41,132.38) v1(129.41,131.29) v1(130.15,131.29) v1(130.89,131.29) v1(131.49,174.99) v1(134.03,174.99) v1(134.59,120.53) v1(134.59,119.76) v1(136.57,174.99) v1(137.26,112.72) v1(137.89,113.08) v1(137.88,112.37) v1(139.11,174.99) v1(139.52,29.14) v1(140.28,29.14) v1(140.47,28.33) v1(141.04,29.14) v1(141.65,174.99) v1(144.19,174.99) v1(145.84,104.12) v1(146.59,103.62) v1(146.73,174.99) v1(147.34,104.12) v1(147.34,103.12) v1(148.69,128.65) v1(148.89,129.39) v1(149.27,174.99) v1(150.01,129.76) v1(149.97,128.87) v1(151.81,174.99) v1(154.35,174.99) v1(156.26,119.61) v1(156.26,118.72) v1(156.56,120.73) v1(156.89,174.99) v1(157.33,121.88) v1(158.09,120.86) v1(158.47,121.88) v1(158.99,132.44) v1(159.43,174.99) v1(159.62,132.94) v1(161.16,102.54) v1(161.92,102.54) v1(161.97,174.99) v1(163.52,20.52) v1(163.52,19.5) v1(164.51,174.99) v1(164.52,118.84) v1(164.52,118.08) v1(164.52,117.19) v1(164.54,20.52) v1(164.54,19.5) v1(164.54,18.48) v1(165.91,112.88) v1(165.91,111.86) v1(167.05,174.99) v1(169.16,31.7) v1(169.59,174.99) v1(169.9,31.88) v1(170.23,52.93) v1(170.26,53.64) v1(172.13,174.99) v1(174.67,174.99) v1(175.03,71.55) v1(175.03,70.41) v1(176.81,71.55) v1(176.81,70.41) v1(177.04,62.6) v1(177.04,61.71) v1(177.04,60.82) v1(177.21,174.99) v1(177.83,130.48) v1(178.85,130.48) v1(179.75,174.99) v1(182.29,174.99) v1(183.17,131.88) v1(184.06,131.88) v1(184.5,139.91) v1(184.83,174.99) v1(184.82,131.88) v1(185.28,20.89) v1(185.51,19.87) v1(185.51,18.85) v1(185.58,140.13) v1(185.83,31.17) v1(185.85,32.21) v1(186.3,20.89) v1(186.53,19.87) v1(186.53,18.85) v1(186.85,139.88) v1(186.98,138.36) v1(187.37,174.99) v1(187.53,19.84) v1(187.48,18.9) v1(187.99,139.12) v1(187.99,137.97) v1(189.91,174.99) v1(190.38,18.84) v1(191.27,18.84) v1(192.45,174.99) v1(193.4,55.02) v1(193.4,54.25) v1(194.28,69.17) v1(194.28,68.15) v1(194.28,67.14) v1(194.28,55.02) v1(194.28,54.26) v1(194.99,174.99) v1(195.45,153.59) v1(195.45,152.32) v1(196.72,153.59) v1(196.72,152.32) v1(197.53,174.99) v1(199.45,13.68) v1(200.07,174.99) v1(201.99,13.68) v1(202.61,174.99) v1(204.53,13.68) v1(204.94,64.06) v1(204.94,62.91) v1(205.15,174.99) v1(205.96,63.68) v1(206.09,62.15) v1(207.07,13.68) v1(207.36,61.9) v1(207.69,174.99) v1(208.12,70.15) v1(208.25,61.9) v1(208.88,70.15) v1(209.61,13.68) v1(209.77,70.15) v1(210.23,174.99) v1(212.15,13.68) v1(212.77,174.99) v1(213.14,40.95) v1(214.09,71.55) v1(214.16,40.95) v1(214.69,13.68) v1(215.1,71.55) v1(215.31,174.99) v1(217.23,13.68) v1(217.85,174.99) v1(218.47,42.34) v1(219.36,42.34) v1(219.77,13.68) v1(220,50.6) v1(220.12,42.34) v1(220.39,174.99) v1(220.89,50.6) v1(222.16,50.34) v1(222.22,49.45) v1(222.22,48.49) v1(222.31,13.68) v1(222.93,174.99) v1(223.29,48.23) v1(224.85,13.68) v1(225.47,174.99) v1(227.08,94.41) v1(227.08,93.52) v1(227.08,92.51) v1(227.39,13.68) v1(228.01,174.99) v1(228.09,94.41) v1(228.09,93.52) v1(228.09,92.51) v1(229.11,94.41) v1(229.11,93.52) v1(229.11,92.51) v1(229.93,13.68) v1(230.12,93.52) v1(230.12,92.51) v1(230.55,174.99) v1(232.47,13.68) v1(233.09,174.99) v1(234.92,55.68) v1(234.95,57.4) v1(235.63,174.99) v1(235.84,55.65) v1(235.86,57.38) v1(238.17,174.99) v1(240.09,13.68) v1(240.35,173.69) v1(240.35,171.15) v1(240.35,168.61) v1(240.35,160.99) v1(240.35,158.45) v1(240.35,155.91) v1(240.35,153.37) v1(240.35,148.29) v1(240.35,145.75) v1(240.35,143.21) v1(240.35,140.67) v1(240.35,138.13) v1(240.35,135.59) v1(240.35,133.05) v1(240.35,130.51) v1(240.35,127.97) v1(240.35,125.43) v1(240.35,122.89) v1(240.35,120.35) v1(240.35,117.81) v1(240.35,115.27) v1(240.35,112.73) v1(240.35,100.03) v1(240.35,97.49) v1(240.35,94.95) v1(240.35,92.41) v1(240.35,89.87) v1(240.35,87.33) v1(240.35,84.79) v1(240.35,82.25) v1(240.35,79.71) v1(240.35,77.17) v1(240.35,74.63) v1(240.35,72.09) v1(240.35,69.55) v1(240.35,67.01) v1(240.35,64.47) v1(240.35,61.93) v1(240.35,59.39) v1(240.35,56.85) v1(240.35,54.31) v1(240.35,51.77) v1(240.35,49.23) v1(240.35,46.69) v1(240.35,44.15) v1(240.35,41.61) v1(240.35,39.07) v1(240.35,36.53) v1(240.35,33.99) v1(240.35,31.45) v1(240.35,28.91) v1(240.35,26.37) v1(240.35,23.83) v1(240.35,21.29) v1(240.35,18.75) v1(240.35,16.21) v2(101.18,116.32) v2(147.56,144.22) v2(148.19,143.46) v2(148.19,142.44) v2(148.19,141.43) v2(148.19,140.41) v2(148.7,143.46) v2(148.7,142.44) v2(148.7,141.43) v2(148.7,140.41) v2(149.21,143.46) v2(149.21,142.44) v2(149.21,141.43) v2(149.21,140.41) v2(149.72,143.46) v2(149.72,142.44) v2(149.72,141.43) v2(149.72,140.41) v2(187.49,62.54) v2(187.49,62.04) v2(187.49,61.53) v2(187.49,61.02) v2(188.5,62.54) v2(188.5,62.04) v2(188.5,61.53) v2(188.5,61.02) v2(189.52,62.54) v2(189.52,62.04) v2(189.52,61.53) v2(189.52,61.02) v2(190.53,62.54) v2(190.53,62.04) v2(190.53,61.53) v2(190.53,61.02) v2(213.83,100.71) v2(213.8,90.25) v2(213.95,121.41) v2(213.95,111) v2(214.59,120.14) v2(214.59,119.12) v2(214.59,118.11) v2(214.59,117.09) v2(214.59,109.73) v2(214.59,108.71) v2(214.59,107.69) v2(214.59,106.68) v2(214.59,99.31) v2(214.59,98.3) v2(214.59,97.28) v2(214.59,96.26) v2(214.59,88.9) v2(214.59,87.88) v2(214.59,86.87) v2(214.59,85.85) v2(215.22,120.14) v2(215.22,119.12) v2(215.22,118.11) v2(215.22,117.09) v2(215.22,109.73) v2(215.22,108.71) v2(215.22,107.69) v2(215.22,106.68) v2(215.22,99.31) v2(215.22,98.3) v2(215.22,97.28) v2(215.22,96.26) v2(215.22,88.9) v2(215.22,87.88) v2(215.22,86.87) v2(215.22,85.85) v2(215.86,120.14) v2(215.86,119.12) v2(215.86,118.11) v2(215.86,117.09) v2(215.86,109.73) v2(215.86,108.71) v2(215.86,107.69) v2(215.86,106.68) v2(215.86,99.31) v2(215.86,98.3) v2(215.86,97.28) v2(215.86,96.26) v2(215.86,88.9) v2(215.86,87.88) v2(215.86,86.87) v2(215.86,85.85) v2(223.99,118.87) v2(223.99,112.52) v2(223.99,108.46) v2(223.99,102.11) v2(223.99,98.04) v2(223.99,91.69) v2(223.99,87.63) v2(223.99,81.28) v2(224.29,105.33) v2(224.62,115.69) v2(224.57,94.87) v2(224.62,84.45) v2(225.13,105.28) v2(225.23,94.87) v2(225.26,118.87) v2(225.26,115.69) v2(225.26,112.52) v2(225.26,108.46) v2(225.26,102.11) v2(225.26,98.04) v2(225.26,91.69) v2(225.26,87.63) v2(225.26,84.45) v2(225.26,81.28) v2(225.89,118.23) v2(225.89,116.96) v2(225.89,115.69) v2(225.89,114.42) v2(225.89,113.15) v2(225.89,107.82) v2(225.89,106.55) v2(225.89,105.28) v2(225.89,104.01) v2(225.89,102.74) v2(225.89,97.41) v2(225.89,96.14) v2(225.89,94.87) v2(225.89,93.6) v2(225.89,92.33) v2(225.89,86.99) v2(225.89,85.72) v2(225.89,84.45) v2(225.89,83.18) v2(225.89,81.91) v3(36.3,141.1) v3(36.3,140.11) v3(36.3,139.11) v3(37.3,140.11) v3(37.3,139.11) v3(159.65,141.7) v3(159.65,140.69) v3(159.65,138.91) v3(159.65,137.77) v3(172.35,92) v3(172.35,89.97) v3(172.35,87.93) v3(173.24,105.21) v3(173.24,90.98) v3(173.24,88.95) v3(173.24,86.92) v3(174.26,110.29) v3(174.26,108.13) v3(174.26,106.1) v3(174.26,104.19) v3(174.26,100.13) v3(174.26,98.09) v3(174.26,96.06) v3(174.26,94.03) v3(174.26,92) v3(174.26,89.97) v3(174.26,87.93) v3(174.26,85.9) v3(174.26,83.74) v3(175.27,111.3) v3(175.27,109.27) v3(175.27,106.98) v3(175.27,105.21) v3(175.27,99.11) v3(175.27,97.08) v3(175.27,95.05) v3(175.27,93.01) v3(175.27,84.89) v3(175.27,82.6) v3(176.29,110.29) v3(176.29,108.13) v3(176.29,106.1) v3(176.29,104.19) v3(176.29,100.13) v3(176.29,98.09) v3(176.29,96.06) v3(176.29,94.03) v3(176.29,85.9) v3(176.29,83.74) v3(182.57,49.38) v3(183.71,49.38) v3(185.23,48.3) v3(185.49,49.38) v3(186.25,48.3) v3(186.5,49.38) v3(196.52,37.99) v3(196.52,36.7) v3(196.52,35.43) v3(196.52,34.16) v3(196.52,32.89) v3(196.52,31.62) v3(196.52,30.35) v3(196.52,29.08) v3(196.52,27.81) v3(196.52,26.54) v3(196.52,25.27) v3(196.52,24) v3(196.52,22.73) v3(196.55,43.05) v3(196.55,41.78) v3(196.55,40.51) v3(196.55,39.24) v3(197.82,43.05) v3(197.82,41.78) v3(197.82,40.51) v3(197.82,39.24) v3(197.79,37.99) v3(197.79,36.7) v3(197.79,35.43) v3(197.79,34.16) v3(197.79,32.89) v3(197.79,31.62) v3(197.79,30.35) v3(197.79,29.08) v3(197.79,27.81) v3(197.79,26.54) v3(197.79,25.27) v3(197.79,24) v3(197.79,22.73) v4(68.36,93.03) v4(68.36,82.93) v4(68.36,78.93) v4(68.36,68.84) v4(68.36,64.84) v4(68.36,54.74) v4(68.36,40.64) v4(68.36,36.64) v4(69.16,97.03) v4(69.16,93.03) v4(69.16,82.93) v4(69.16,78.93) v4(69.16,68.84) v4(69.16,64.84) v4(69.16,54.74) v4(69.16,50.74) v4(69.16,40.64) v4(69.16,36.64) v4(69.96,97.03) v4(69.96,93.03) v4(69.96,82.93) v4(69.96,78.93) v4(69.96,68.84) v4(69.96,64.84) v4(69.96,54.74) v4(69.96,50.74) v4(69.96,40.64) v4(69.96,36.64) v4(70.76,97.03) v4(70.76,93.03) v4(70.76,82.93) v4(70.76,78.93) v4(70.76,68.84) v4(70.76,64.84) v4(70.76,54.74) v4(70.76,50.74) v4(70.76,40.64) v4(70.76,36.64) v4(71.56,93.03) v4(71.56,78.93) v4(71.56,64.84) v4(71.56,50.74) v4(71.56,36.64) v4(72.36,97.03) v4(72.36,93.03) v4(72.36,82.93) v4(72.36,78.93) v4(72.36,68.84) v4(72.36,64.84) v4(72.36,54.74) v4(72.36,50.74) v4(72.36,40.64) v4(72.36,36.64) v4(73.16,97.03) v4(73.16,93.03) v4(73.16,82.93) v4(73.16,78.93) v4(73.16,68.84) v4(73.16,64.84) v4(73.16,54.74) v4(73.16,40.64) v4(73.96,97.03) v4(73.96,82.93) v4(73.96,68.84) v4(73.96,54.74) v4(73.96,40.64) v4(74.76,97.03) v4(74.76,82.93) v4(74.76,78.93) v4(74.76,68.84) v4(74.76,64.84) v4(74.76,54.74) v4(74.76,40.64) v4(75.56,97.03) v4(75.56,93.03) v4(75.56,82.93) v4(75.56,78.93) v4(75.56,68.84) v4(75.56,64.84) v4(75.56,54.74) v4(75.56,50.74) v4(75.56,40.64) v4(75.56,36.64) v4(76.36,97.03) v4(76.36,93.03) v4(76.36,82.93) v4(76.36,78.93) v4(76.36,68.84) v4(76.36,64.84) v4(76.36,54.74) v4(76.36,50.74) v4(76.36,40.64) v4(76.36,36.64) v4(77.16,97.03) v4(77.16,93.03) v4(77.16,82.93) v4(77.16,78.93) v4(77.16,68.84) v4(77.16,64.84) v4(77.16,54.74) v4(77.16,50.74) v4(77.16,40.64) v4(77.16,36.64) v4(77.96,97.03) v4(77.96,93.03) v4(77.96,82.93) v4(77.96,78.93) v4(77.96,68.84) v4(77.96,64.84) v4(77.96,54.74) v4(77.96,50.74) v4(77.96,40.64) v4(77.96,36.64) v4(78.76,97.03) v4(78.76,93.03) v4(78.76,82.93) v4(78.76,78.93) v4(78.76,68.84) v4(78.76,64.84) v4(78.76,54.74) v4(78.76,50.74) v4(78.76,40.64) v4(78.76,36.64) v4(79.56,97.03) v4(79.56,93.03) v4(79.56,82.93) v4(79.56,78.93) v4(79.56,68.84) v4(79.56,64.84) v4(79.56,54.74) v4(79.56,50.74) v4(79.56,40.64) v4(79.56,36.64) v4(80.36,97.03) v4(80.36,93.03) v4(80.36,82.93) v4(80.36,78.93) v4(80.36,68.84) v4(80.36,64.84) v4(80.36,54.74) v4(80.36,50.74) v4(80.36,40.64) v4(80.36,36.64) v4(81.16,97.03) v4(81.16,93.03) v4(81.16,82.93) v4(81.16,78.93) v4(81.16,68.84) v4(81.16,64.84) v4(81.16,54.74) v4(81.16,50.74) v4(81.16,40.64) v4(81.16,36.64) v4(81.96,41.44) v4(81.96,40.64) v4(81.96,37.44) v4(81.96,36.64) v4(154.76,93.05) v4(154.76,89.05) v4(154.76,78.95) v4(154.76,64.86) v4(154.76,60.86) v4(154.76,50.76) v4(154.76,46.76) v4(154.76,36.41) v4(154.76,32.41) v4(155.56,93.05) v4(155.56,89.05) v4(155.56,78.95) v4(155.56,74.95) v4(155.56,64.86) v4(155.56,60.86) v4(155.56,50.76) v4(155.56,46.76) v4(155.56,36.41) v4(155.56,32.41) v4(156.36,93.05) v4(156.36,89.05) v4(156.36,78.95) v4(156.36,74.95) v4(156.36,64.86) v4(156.36,60.86) v4(156.36,50.76) v4(156.36,46.76) v4(156.36,36.41) v4(156.36,32.41) v4(157.16,93.05) v4(157.16,89.05) v4(157.16,78.95) v4(157.16,74.95) v4(157.16,64.86) v4(157.16,60.86) v4(157.16,50.76) v4(157.16,46.76) v4(157.16,36.41) v4(157.16,32.41) v4(157.96,93.05) v4(157.96,89.05) v4(157.96,78.95) v4(157.96,74.95) v4(157.96,64.86) v4(157.96,60.86) v4(157.96,50.76) v4(157.96,46.76) v4(157.96,36.41) v4(157.96,32.41) v4(158.76,93.05) v4(158.76,89.05) v4(158.76,78.95) v4(158.76,74.95) v4(158.76,64.86) v4(158.76,60.86) v4(158.76,50.76) v4(158.76,46.76) v4(158.76,36.41) v4(158.76,32.41) v4(159.56,93.05) v4(159.56,89.05) v4(159.56,78.95) v4(159.56,74.95) v4(159.56,64.86) v4(159.56,60.86) v4(159.56,50.76) v4(159.56,46.76) v4(159.56,36.41) v4(159.56,32.41) v4(160.36,93.05) v4(160.36,89.05) v4(160.36,78.95) v4(160.36,74.95) v4(160.36,64.86) v4(160.36,60.86) v4(160.36,50.76) v4(160.36,46.76) v4(160.36,36.41) v4(160.36,32.41) v4(161.16,93.05) v4(161.16,89.05) v4(161.16,78.95) v4(161.16,74.95) v4(161.16,64.86) v4(161.16,60.86) v4(161.16,50.76) v4(161.16,46.76) v4(161.16,36.41) v4(161.16,32.41) v4(161.96,93.05) v4(161.96,78.95) v4(161.96,64.86) v4(161.96,50.76) v4(161.96,36.41) v4(162.76,93.05) v4(162.76,78.95) v4(162.76,74.95) v4(162.76,64.86) v4(162.76,60.86) v4(162.76,50.76) v4(162.76,46.76) v4(162.76,36.41) v4(162.76,32.41) v4(163.56,93.05) v4(163.56,89.05) v4(163.56,78.95) v4(163.56,74.95) v4(163.56,64.86) v4(163.56,60.86) v4(163.56,50.76) v4(163.56,46.76) v4(163.56,36.41) v4(163.56,32.41) v4(164.36,89.05) v4(164.36,74.95) v4(164.36,60.86) v4(164.36,46.76) v4(164.36,32.41) v4(165.16,93.05) v4(165.16,89.05) v4(165.16,78.95) v4(165.16,74.95) v4(165.16,64.86) v4(165.16,60.86) v4(165.16,50.76) v4(165.16,46.76) v4(165.16,36.41) v4(165.16,32.41) v4(165.96,93.05) v4(165.96,89.05) v4(165.96,78.95) v4(165.96,74.95) v4(165.96,64.86) v4(165.96,60.86) v4(165.96,50.76) v4(165.96,46.76) v4(165.96,36.41) v4(165.96,32.41) v4(166.76,93.05) v4(166.76,89.05) v4(166.76,78.95) v4(166.76,74.95) v4(166.76,64.86) v4(166.76,60.86) v4(166.76,50.76) v4(166.76,46.76) v4(166.76,36.41) v4(166.76,32.41) v4(167.56,93.05) v4(167.56,89.05) v4(167.56,78.95) v4(167.56,74.95) v4(167.56,64.86) v4(167.56,60.86) v4(167.56,50.76) v4(167.56,46.76) v4(167.56,36.41) v4(167.56,32.41) v6(62.15,11.41) v6(62.15,8.41) v6(67.15,11.41) v6(67.15,8.41) v6(69.15,5.99) v6(71.15,11.41) v6(71.15,8.41) v6(71.15,5.99) v6(73.15,5.99) v6(75.15,11.41) v6(75.15,8.41) v6(79.15,11.41) v6(79.15,8.41) v6(83.15,11.41) v6(83.15,8.41) v6(83.15,5.99) v6(85.15,5.99) v6(87.15,11.41) v6(87.15,8.41) v6(87.15,5.99) v6(89.15,5.99) v6(91.15,11.41) v6(91.15,8.41) v6(91.15,5.99) v6(96.15,11.41) v6(96.15,8.41) v6(100.15,11.41) v6(100.15,8.41) v6(100.15,5.99) v6(102.15,5.99) v6(104.15,11.41) v6(104.15,8.41) v6(104.15,5.99) v6(106.15,5.99) v6(108.15,11.41) v6(108.15,8.41) v6(108.15,5.99) v6(110.15,5.99) v6(112.15,11.41) v6(112.15,8.41) v6(112.15,5.99) v6(114.15,5.99) v6(116.15,11.41) v6(116.15,8.41) v6(116.15,5.99) v6(118.15,5.99) v6(120.15,11.41) v6(120.15,8.41) v6(120.15,5.99) v6(122.15,5.99) v6(124.15,11.41) v6(124.15,8.41) v6(124.15,5.99) v8(76.35,130.81) v8(79.4,130.81) v9(45.53,57.01) v9(45.53,54.61) v9(45.53,47.41) v9(45.53,45.01) v9(45.53,31.43) v9(45.53,29.03) v9(45.53,21.83) v9(45.53,19.43) v9(47.24,57.01) v9(47.24,54.61) v9(47.24,47.41) v9(47.24,45.01) v9(47.24,31.43) v9(47.24,29.03) v9(47.24,21.83) v9(47.24,19.43) v9(55.7,47.6) v9(55.7,45.2) v9(55.7,22.03) v9(55.7,19.37) v9(56.09,54.92) v9(56.09,29.34) v9(56.68,57.16) v9(56.68,31.58) v9(57.4,47.6) v9(57.4,45.2) v9(57.4,22.03) v9(57.4,19.37) v9(57.8,54.92) v9(57.8,29.34) v9(58.39,57.16) v9(58.39,31.58)
