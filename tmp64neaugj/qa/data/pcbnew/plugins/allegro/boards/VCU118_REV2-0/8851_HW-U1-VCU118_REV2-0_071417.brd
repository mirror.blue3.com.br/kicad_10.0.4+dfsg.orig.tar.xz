# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_C2_A9: length 178.4
  TOP w0.152: U1.AM26 126.74,68.34 v2(127.24,68.84) ; U135.R7 v4(166.76,49.96) ; U136.R7 v4(166.76,64.06) ; U138.R7 v4(166.76,92.25) ; U139.R7 v4(166.76,35.61) ; U137.R7 v4(166.76,78.15)
  03_SIG1 w0.173: v4(166.76,35.61) 167.32,35.05 167.86,35.05 168.2,35.38 168.2,38.61 168.39,38.8 168.39,43.85 168.29,43.95 167.97,43.95 167.81,44.11 167.81,44.52 167.96,44.67 168.24,44.67 168.39,44.82 168.39,48.33 v4(166.76,49.96) 167.15,50.35 167.16,50.36 167.16,52.52 167.15,52.54 167.15,59.08 167.16,59.09 167.16,63.66 v4(166.76,64.06) 167.16,64.46 167.16,68 167.29,68.13 167.29,69.93 167.16,70.06 167.16,77.75 v4(166.76,78.15) 167.16,78.55 167.16,82.38 167.25,82.47 167.25,83.56 167.16,83.65 167.16,91.85 v4(166.76,92.25) 167.16,92.65 167.74,92.65 167.97,92.88 167.97,93.47 168.01,93.52
  03_SIG1 w0.292: v1(168.53,105.08) 170.75,102.86 170.75,100.5 168.32,98.08 168.32,93.83 168.01,93.52
  05_SIG2 w0.173: v2(127.24,68.84) 127.74,69.34 127.74,70.05 127.44,70.34 127.03,70.34 126.74,70.05 126.74,69.64 126.44,69.34 126.03,69.34 125.74,69.05 125.74,66.64 127.03,65.34 127.44,65.34 127.74,65.05 127.74,64.64 128.03,64.34 128.44,64.34 128.74,64.05 128.74,63.64 129.03,63.34 129.44,63.34 129.74,63.05 129.74,62.64 130.03,62.34 130.44,62.34 130.74,62.05 130.74,61.64 131.03,61.34 131.44,61.34 131.74,61.05 131.74,60.64 132.03,60.34 132.44,60.34 132.74,60.05 132.74,59.64 133.03,59.34 133.44,59.34 133.74,59.05 133.74,58.64 134.03,58.34 134.44,58.34 134.74,58.05 134.74,57.64 135.03,57.34 135.44,57.34 135.74,57.05 135.74,56.64 136.03,56.34 136.44,56.34 136.74,56.05 136.74,55.64 137.03,55.34 137.44,55.34 137.74,55.05 137.74,54.64 138.03,54.34 138.44,54.34 138.74,54.05 138.74,53.64 139.03,53.34 139.44,53.34 139.74,53.05 139.74,52.64 140.03,52.34 140.44,52.34 140.74,52.05 140.74,51.64 141.03,51.34 141.46,51.34 142.63,50.18 ; 167.29,30.32 167.16,30.45 167.16,30.46 167.16,31.77 167.39,32.01 167.72,32.01 167.96,32.24 167.96,34.41 v4(166.76,35.61)
  05_SIG2 w0.292: 142.63,50.18 143.32,49.48 143.32,41.41 141.78,39.88 141.78,31.96 143.01,30.74 143.01,29.99 145.85,27.15 147.69,27.15 148.02,26.83 150.27,26.83 150.8,26.3 156.51,26.3 156.82,26.62 157.89,26.62 158.66,25.85 159.95,25.85 161.91,23.89 167.63,23.89 168.86,25.12 168.86,28.75 167.29,30.32
  BOTTOM w0.279: R909.2 168.81,104.8 v1(168.53,105.08)
DDR4_C2_A10: length 181.8
  TOP w0.152: U1.AR28 129.74,70.34 v2(130.24,70.84) ; U139.M3 v4(164.36,33.21) ; U135.M3 v4(164.36,47.56) ; U137.M3 v4(164.36,75.75) ; U136.M3 v4(164.36,61.66) ; U138.M3 v4(164.36,89.85)
  03_SIG1 w0.173: 164.5,95.39 164.5,95.16 164.4,95.05 164.4,89.89 v4(164.36,89.85) U138.M3 163.96,87.03 164.36,86.63 v4(164.36,75.75) U137.M3 163.96,73.19 164.36,72.79 v4(164.36,61.66) U136.M3 163.96,58.59 164.32,58.22 164.32,56.41 164.17,56.26 164.17,53.96 164.32,53.81 164.32,47.59 v4(164.36,47.56) U135.M3 163.96,44.44 164.11,44.29 164.52,44.29 164.67,44.14 164.67,43.92 164.52,43.77 164.11,43.77 163.96,43.62 163.96,43.16 164.17,42.94 164.64,42.94 164.78,42.8 164.78,41.8 164.61,41.62 163.6,41.62 163.45,41.47 163.45,41.26 163.6,41.11 164.2,41.11 164.36,40.95 v4(164.36,33.21)
  03_SIG1 w0.292: v1(157.38,101.15) 158.91,99.63 161.56,99.63 161.84,99.35 161.84,98.26 164.5,95.6 164.5,95.39
  07_SIG3 w0.173: 163.92,29.59 164.76,30.42 164.76,32.81 v4(164.36,33.21) ; v2(130.24,70.84) 130.74,70.34 130.74,68.61 130.97,68.37 131.52,68.37 131.76,68.13 131.76,67.58 132,67.34 132.51,67.34 132.76,67.09 132.76,66.71 134.05,65.42 134.33,65.42 134.72,65.02 134.72,52.59 135,52.31 135.41,52.31 135.72,52.01 135.72,51.58 135.93,51.37 136.45,51.37 136.76,51.07 136.76,50.56 136.91,50.41 137.47,50.41 137.76,50.12 137.76,49.53 137.91,49.38 138.49,49.38 138.72,49.14 138.72,48.58 138.93,48.37 139.44,48.37 139.72,48.09 139.72,47.55 139.94,47.33 140.49,47.33 140.72,47.11 140.72,44.59 140.99,44.32
  07_SIG3 w0.292: 140.99,44.32 141.25,44.06 141.86,44.06 142.33,43.59 142.33,43.33 141.69,42.69 141.69,42.35 141.81,42.23 142.09,42.23 142.63,42.77 143,42.77 143.3,42.46 143.3,42.17 142.64,41.52 142.36,41.52 142.24,41.64 141.89,41.64 141.69,41.45 141.69,40.34 141.89,40.14 142.11,40.14 143.41,41.44 143.68,41.44 143.9,41.22 143.9,41.04 142.56,39.69 142.56,39.47 142.78,39.25 143,39.25 144.7,40.95 144.92,40.95 145.15,40.72 145.15,40.5 143.45,38.8 143.45,38.58 143.67,38.36 143.89,38.36 145.59,40.06 145.81,40.06 146.04,39.83 146.04,39.61 144.34,37.91 144.34,37.69 144.56,37.47 144.78,37.47 146.48,39.17 146.7,39.17 146.93,38.94 146.93,38.72 145.23,37.02 145.23,36.8 145.78,36.25 146.19,36.25 146.41,36.47 146.41,37.16 147.48,38.23 148.42,38.23 150.29,36.35 150.29,34.07 149.63,33.41 148.67,33.41 148.47,33.2 148.47,32.74 149.36,31.85 151.31,31.85 151.59,31.57 151.59,30.33 152.33,29.59 163.92,29.59
  BOTTOM w0.279: R908.2 v1(157.38,101.15)
DDR4_C2_A11: length 181.2
  TOP w0.152: U136.T2 v4(167.56,60.06) ; U138.T2 v4(167.56,88.25) ; U139.T2 v4(167.56,31.61) ; U135.T2 v4(167.56,45.96) ; v2(130.24,69.84) 129.74,69.34 U1.AR27 ; U137.T2 v4(167.56,74.15)
  05_SIG2 w0.173: 142.63,49.22 141.5,50.34 141.03,50.34 140.74,50.64 140.74,51.05 140.44,51.34 140.03,51.34 139.74,51.64 139.74,52.05 139.44,52.34 139.03,52.34 138.74,52.64 138.74,53.05 138.44,53.34 138.03,53.34 137.74,53.64 137.74,54.05 137.44,54.34 137.03,54.34 136.74,54.64 136.74,55.05 136.44,55.34 136.03,55.34 135.74,55.64 135.74,56.05 135.44,56.34 135.03,56.34 134.74,56.64 134.74,57.05 134.44,57.34 134.03,57.34 133.74,57.64 133.74,58.05 133.44,58.34 133.03,58.34 132.74,58.64 132.74,59.05 132.44,59.34 132.03,59.34 131.74,59.64 131.74,60.05 131.44,60.34 131.03,60.34 130.74,60.64 130.74,61.05 130.44,61.34 130.03,61.34 129.74,61.64 129.74,62.05 129.44,62.34 129.03,62.34 128.74,62.64 128.74,63.05 128.44,63.34 128.03,63.34 127.74,63.64 127.74,64.05 127.44,64.34 127.03,64.34 126.74,64.64 126.74,65.05 125.44,66.34 125.03,66.34 124.74,66.64 124.74,69.05 125.03,69.34 125.44,69.34 125.74,69.64 125.74,70.05 126.03,70.34 126.44,70.34 126.74,70.64 126.74,71.05 127.03,71.34 129.44,71.34 129.74,71.05 129.74,70.64 130.24,70.14 v2(130.24,69.84) ; v4(167.56,31.61) 167.85,31.61 168.27,31.19 168.27,30.37
  05_SIG2 w0.292: 142.63,49.22 142.65,49.2 142.65,41.94 141.05,40.34 141.05,34.21 140.23,33.4 140.23,31.43 140.53,31.14 140.94,31.14 141.55,30.53 141.55,29.87 145.38,26.05 145.84,26.05 146.63,25.25 151.08,25.25 152.37,23.96 160.34,23.96 161.12,23.18 169.91,23.18 170.21,23.47 170.21,28.43 168.27,30.37
  07_SIG3 w0.173: 168.01,88.7 v4(167.56,88.25) 168.01,87.8 168.01,86.4 167.67,86.07 167.67,84.09 168.49,83.27 168.49,81.97 168.3,81.78 168.3,74.99 167.56,74.25 v4(167.56,74.15) 168.3,73.41 168.3,69.45 168.48,69.27 168.48,68.53 168.3,68.35 168.3,60.8 v4(167.56,60.06) 168.06,59.56 168.06,55.42 168.22,55.26 168.22,54.19 168.06,54.03 168.06,46.46 v4(167.56,45.96) 168.5,45.01 168.5,42.65 168.35,42.5 167.85,42.5 167.7,42.35 167.7,42.13 167.85,41.98 168.35,41.98 168.5,41.83 168.5,32.79 167.94,32.23 167.94,31.99 v4(167.56,31.61)
  07_SIG3 w0.292: v1(168.2,101.57) 168.78,100.99 168.78,99.88 168.21,99.3 168.21,88.9 168.01,88.7
  BOTTOM w0.279: R907.2 168.81,100.96 v1(168.2,101.57)
DDR4_C2_A12: length 184.7
  TOP w0.152: U139.M7 v4(163.56,35.61) ; v2(133.24,67.84) 132.74,67.34 U1.AV25 ; U138.M7 v4(163.56,92.25) ; U135.M7 v4(163.56,49.96) ; U136.M7 v4(163.56,64.06) ; U137.M7 v4(163.56,78.15)
  05_SIG2 w0.173: v4(163.56,35.61) 163.76,35.4 164.28,35.4 164.4,35.52 164.4,36.48 164.24,36.63 164.12,36.63 163.97,36.78 163.97,36.99 164.12,37.14 164.24,37.14 164.4,37.3 164.4,39.59 164.28,39.71 163.8,39.71 163.71,39.81 163.71,40.19 163.83,40.32 164,40.32 164.13,40.45 164.13,43.3 163.51,43.92 163.51,44.34 163.67,44.49 163.81,44.49 163.96,44.64 163.96,49.56 v4(163.56,49.96) 164.25,50.65 164.25,57.66 163.96,57.95 163.96,63.66 v4(163.56,64.06) 163.96,64.46 163.96,67.39 163.02,68.33 163.02,71.92 163.25,72.15 163.25,73.02 163.16,73.11 163.16,76.21 163.56,76.61 v4(163.56,78.15) 163.96,78.55 163.96,83.42 163.16,84.22 163.16,90.98 163.56,91.38 v4(163.56,92.25) 163.96,92.65 163.96,95.04 163.61,95.39
  05_SIG2 w0.292: 163.61,95.39 160.9,98.1 153.57,98.1 152.91,98.76 152.91,101.27 152.4,101.77 152.4,103.29 153.85,104.73 v1(153.85,104.95)
  07_SIG3 w0.173: 141.71,48.05 141.44,48.32 141.07,48.32 140.71,48.68 140.71,49.05 140.44,49.32 140.02,49.32 139.7,49.64 139.7,50.05 139.4,50.35 139.04,50.35 138.74,50.66 138.74,51.02 138.42,51.34 138.01,51.34 137.73,51.62 137.73,52.03 137.43,52.32 137.09,52.32 136.74,52.68 136.74,65.05 135.93,65.85 135.52,65.85 134.74,66.64 134.74,67.05 134.44,67.34 133.96,67.34 133.46,67.84 v2(133.24,67.84)
  07_SIG3 w0.292: 141.71,48.05 141.91,47.84 142.14,47.84 142.43,48.14 142.65,48.14 142.87,47.91 142.87,47.69 142.58,47.4 142.58,47.26 142.58,47.26 142.89,46.95 143.03,46.95 143.32,47.24 143.54,47.24 143.77,47.02 143.77,46.8 143.47,46.51 143.47,46.28 143.69,46.06 143.92,46.06 144.21,46.35 144.43,46.35 144.66,46.13 144.66,45.91 144.36,45.61 144.36,45.39 144.55,45.2 144.84,45.2 145.1,45.46 145.32,45.46 145.55,45.24 145.55,45.02 145.25,44.72 145.25,44.5 145.48,44.28 145.7,44.28 145.99,44.57 146.22,44.57 146.44,44.35 146.44,44.13 146.14,43.83 146.14,43.61 146.37,43.39 146.59,43.39 146.88,43.68 147.11,43.68 147.33,43.46 147.33,43.24 147.04,42.94 147.04,42.72 147.26,42.5 147.48,42.5 147.77,42.79 148,42.79 148.22,42.57 148.22,42.34 147.93,42.05 147.93,41.83 148.15,41.61 148.37,41.61 148.62,41.86 148.84,41.86 149.07,41.63 149.07,41.41 148.82,41.16 148.82,40.94 149.4,40.36 149.4,39.72 149.34,39.67 149.34,39.45 149.56,39.23 149.79,39.23 150.09,39.53 151.15,39.53 151.44,39.23 151.44,38.79 150.84,38.19 150.84,37.97 151.07,37.75 151.29,37.75 152.02,38.48 152.7,38.48 153,38.18 153,31.98 153.22,31.76 153.49,31.76 153.62,31.88 153.62,38.08 153.8,38.27 154.09,38.27 154.23,38.13 154.23,34.29 154.5,34.02 162.6,34.02 162.82,34.24 162.82,34.51 162.74,34.59 155.04,34.59 154.86,34.78 154.86,34.98 154.98,35.1 163.05,35.1 v4(163.56,35.61)
  BOTTOM w0.279: R912.2 154.08,104.72 v1(153.85,104.95)
DDR4_C2_A13: length 173.5
  TOP w0.152: v2(131.24,67.84) 130.74,67.34 U1.AT25 ; U136.T8 v4(167.56,65.66) ; U135.T8 v4(167.56,51.56) ; U139.T8 v4(167.56,37.21) ; U137.T8 v4(167.56,79.75) ; U138.T8 v4(167.56,93.85)
  05_SIG2 w0.173: v4(167.56,37.21) 168.29,37.94 168.29,41.12 168.12,41.29 167.73,41.29 167.56,41.46 167.56,41.81 167.73,41.98 168.12,41.98 168.29,42.15 168.29,42.5 168.12,42.67 167.73,42.67 167.56,42.84 167.56,43.19 167.73,43.36 168.12,43.36 168.29,43.54 168.29,50.86 167.59,51.56 v4(167.56,51.56) 168.3,52.3 168.3,64.92 v4(167.56,65.66) 168.33,66.43 168.33,78.98 v4(167.56,79.75) 168.4,80.6 168.4,83.24 167.64,84 167.64,86.54 168.36,87.26 168.36,93.05 v4(167.56,93.85) 167.56,93.97 168.01,94.42
  05_SIG2 w0.292: v1(170.74,104.32) 171.76,103.3 171.76,100.76 169.75,98.76 169.75,96.16 168.01,94.42
  14_SIG4 w0.089: 133.74,42.02 133.74,44.12 133.51,44.34 132.97,44.34 132.69,44.62 132.69,45.08 132.53,45.25 131.96,45.25 131.74,45.47 131.74,67.34 v2(131.24,67.84)
  14_SIG4 w0.157: v4(167.56,37.21) 170.85,33.92 170.85,33.7 170.59,33.44 169.87,33.44 169.68,33.25 169.68,32.71 169.86,32.54 170.64,32.54 170.85,32.33 170.85,30.94 167.23,27.33 161.66,27.33 161.05,26.72 157.05,26.72 156.8,26.46 154.36,26.46 153.87,26.95 147.82,26.95 147.06,27.7 145.25,27.7 143.34,29.61 142.88,30.07 142.88,30.62 142.58,30.91 140.08,30.91 139.75,31.24 139.04,31.24 138.82,31.46 138.82,31.79 138.67,31.95 137.7,31.95 137.54,31.79 137.54,31.46 137.38,31.29 136.83,31.29 136.66,31.46 136.66,31.94 136.45,32.16 135.8,32.16 135.58,31.94 135.58,31.46 135.37,31.24 134.82,31.24 133.1,32.97 133.1,33.27 134.66,34.83 134.66,35.4 134.36,35.7 134,35.7 133.28,34.98 132.85,34.98 132.66,35.17 132.66,37.49 133.05,37.88 133.05,41.32 133.74,42.02
  BOTTOM w0.279: R920.2 v1(170.74,104.32)
DDR4_C2_A14_WE_B: length 178.8
  TOP w0.152: U137.L2 v4(163.56,74.15) ; U139.L2 v4(163.56,31.61) ; U1.AV28 132.74,70.34 v2(133.24,70.84) ; U135.L2 v4(163.56,45.96) ; U138.L2 v4(163.56,88.25) ; U136.L2 v4(163.56,60.06)
  03_SIG1 w0.173: v2(133.24,70.84) 133.24,70.44 133.13,70.34 132.03,70.34 131.74,70.05 131.74,69.64 131.44,69.34 130.96,69.34 130.74,69.12 130.74,66.64 131.56,65.81 131.98,65.81 132.74,65.05 132.74,63.64 133.03,63.34 133.44,63.34 133.74,63.05 133.74,62.64 134.03,62.34 134.44,62.34 134.74,62.05 134.74,61.64 135.03,61.34 135.44,61.34 135.74,61.05 135.74,60.64 136.03,60.34 136.44,60.34 136.74,60.05 136.74,59.64 137.03,59.34 137.44,59.34 137.74,59.05 137.74,48.67 138.07,48.34 138.5,48.34 138.74,48.11 138.74,42.67 ; v4(163.56,31.61) 163.16,31.21 162.59,31.21 162.33,30.95 162.33,30.62
  03_SIG1 w0.292: 138.74,42.67 138.74,42.01 138.44,41.71 137.61,41.71 137.22,41.32 137.22,39.27 137.47,39.01 138.58,39.01 139.22,38.38 140.81,38.38 141.04,38.15 141.04,37.78 140.9,37.63 139.27,37.63 139.08,37.45 139.08,37.13 139.27,36.95 141.18,36.95 141.43,36.7 141.43,36.42 141.23,36.22 139.26,36.22 139.07,36.03 139.07,35.66 139.27,35.45 141.31,35.45 141.47,35.3 141.47,34.97 141.18,34.68 139.2,34.68 138.97,34.44 137.73,34.44 137.54,34.25 137.54,33.99 137.84,33.69 141.37,33.69 141.77,34.09 144.73,34.09 146.71,32.11 146.71,30.28 147.92,29.07 151.82,29.07 153.32,27.57 154.22,27.57 154.36,27.43 156.41,27.43 157.24,28.26 157.72,28.26 158.32,27.66 158.88,27.66 159.21,27.99 159.21,29.32 159.4,29.51 161.59,29.51 162.33,30.25 162.33,30.62
  05_SIG2 w0.173: 164.34,95.39 164.34,92.42 163.96,92.04 163.96,88.65 v4(163.56,88.25)
  05_SIG2 w0.292: v1(157.69,104.98) 157.69,103.98 158.45,103.23 158.45,102.36 158.8,102.01 160,102.01 160.55,101.46 160.55,100.55 161.83,99.28 161.83,98.36 164.34,95.85 164.34,95.39
  07_SIG3 w0.173: v4(163.56,31.61) U139.L2 163.16,33.97 164.06,34.87 164.06,36.98 164.21,37.13 164.44,37.13 164.59,37.29 164.59,37.5 164.44,37.65 164.21,37.65 164.06,37.8 164.06,38.02 164.21,38.17 164.57,38.17 164.72,38.32 164.72,38.54 164.57,38.69 164.21,38.69 164.06,38.84 164.06,43.16 163.96,43.26 163.96,45.56 v4(163.56,45.96) 163.96,46.36 163.96,47.93 164.2,48.17 164.2,56.39 164.29,56.48 164.29,58.27 163.96,58.6 163.96,59.66 v4(163.56,60.06) 163.96,60.46 163.96,61.82 164.04,61.9 164.04,71.75 163.96,71.83 163.96,73.75 v4(163.56,74.15) 163.96,74.55 163.96,76.45 164.31,76.81 164.31,86.79 163.96,87.15 163.96,87.85 v4(163.56,88.25)
  BOTTOM w0.279: R913.2 157.76,104.91 v1(157.69,104.98)
DDR4_C2_A15_CAS_B: length 178.7
  TOP w0.152: U136.M8 v4(163.56,65.66) ; U138.M8 v4(163.56,93.85) ; v2(132.24,68.84) 131.74,68.34 U1.AU26 ; U139.M8 v4(163.56,37.21) ; U135.M8 v4(163.56,51.56) ; U137.M8 v4(163.56,79.75)
  03_SIG1 w0.173: 157.98,30.1 158.36,30.48 158.36,31.05 158.51,31.21 161.36,31.21 161.57,31.42 161.57,32.5 161.88,32.81 162.92,32.81 163.16,33.04 163.16,36.57 163.56,36.97 v4(163.56,37.21) ; 142.63,42.99 141.36,44.25 140.98,44.25 140.74,44.49 140.74,48.13 140.56,48.31 140.06,48.31 139.74,48.63 139.74,59.05 139.44,59.34 139.03,59.34 138.74,59.64 138.74,60.05 138.44,60.34 138.03,60.34 137.74,60.64 137.74,61.12 137.51,61.34 137.03,61.34 136.74,61.64 136.74,62.05 136.44,62.34 136.03,62.34 135.74,62.64 135.74,63.05 135.44,63.34 135.03,63.34 134.74,63.64 134.74,65.05 133.9,65.88 133.49,65.88 132.74,66.64 132.74,68.34 v2(132.24,68.84)
  03_SIG1 w0.292: 142.63,42.99 144.58,41.03 144.58,40.67 144.34,40.44 144.03,40.44 141.11,43.36 140.75,43.36 140.53,43.14 140.53,42.91 140.76,42.68 140.76,42.46 140.44,42.14 140.44,41.92 140.66,41.69 140.88,41.69 141.21,42.01 141.43,42.01 141.65,41.79 141.65,41.57 140.64,40.56 140.23,40.56 139.83,40.17 139.83,39.93 140,39.76 140.73,39.76 142.1,41.12 142.32,41.12 142.54,40.9 142.54,40.68 142.22,40.36 142.22,40.13 142.51,39.85 145.6,39.85 146.07,39.38 146.07,38.25 146.23,38.09 147.41,38.09 147.61,37.89 147.61,37.52 147.43,37.34 146.2,37.34 145.92,37.06 145.92,34.87 148.13,32.66 148.49,32.66 148.74,32.92 148.74,33.35 148.95,33.55 149.51,33.55 149.86,33.2 149.86,32.98 149.16,32.27 149.16,32 149.33,31.83 149.86,31.83 150.07,32.04 150.07,32.25 150.25,32.44 150.65,32.44 151.56,31.52 151.56,30.79 151.85,30.5 152.59,30.5 153.24,29.85 153.49,29.85 153.61,29.97 153.61,30.23 153.77,30.39 154.08,30.39 154.29,30.18 154.29,29.56 154.45,29.4 154.74,29.4 154.92,29.58 154.92,30.19 155.07,30.33 155.39,30.33 155.56,30.16 155.56,29.5 155.8,29.26 156.06,29.26 156.29,29.49 156.29,30.15 156.44,30.3 156.9,30.3 157.06,30.14 157.06,29.91 157.21,29.75 157.63,29.75 157.98,30.1
  05_SIG2 w0.173: v4(163.56,37.21) 163.96,37.61 163.96,39.09 163.72,39.33 163.36,39.33 163.16,39.53 163.16,40.44 163.31,40.6 163.53,40.6 163.68,40.75 163.68,40.96 163.53,41.11 163.31,41.11 163.16,41.27 163.16,41.48 163.31,41.63 163.48,41.63 163.63,41.77 163.63,41.99 163.46,42.15 163.31,42.15 163.12,42.34 163.12,43.26 163.16,43.29 163.16,51.16 v4(163.56,51.56) 163.16,51.96 163.16,65.26 v4(163.56,65.66) 163.16,66.06 163.16,67.4 162.26,68.3 162.26,76.22 163.16,77.12 163.16,79.35 v4(163.56,79.75) 163.16,80.15 163.16,81.41 162.8,81.77 162.8,83.34 162.09,84.05 162.09,90.61 163.16,91.68 163.16,93.45 v4(163.56,93.85) 163.16,94.25 163.16,94.83 162.6,95.39
  05_SIG2 w0.292: 162.6,95.39 160.65,97.34 153.17,97.34 151.61,98.89 151.61,100.58 v1(150.96,101.23)
  BOTTOM w0.279: R914.2 151.03,101.15 v1(150.96,101.23)
DDR4_C2_A16_RAS_B: length 184.9
  TOP w0.152: U138.L8 v4(162.76,93.85) ; U135.L8 v4(162.76,51.56) ; v2(133.24,68.84) 132.74,68.34 U1.AV26 ; U137.L8 v4(162.76,79.75) ; U139.L8 v4(162.76,37.21) ; U136.L8 v4(162.76,65.66)
  03_SIG1 w0.173: 161.79,95.39 162.36,94.81 162.36,94.25 v4(162.76,93.85) 162.36,93.45 162.36,90.42 161.96,90.02 161.96,81.14 162.36,80.75 162.36,80.15 v4(162.76,79.75) 162.36,79.35 162.36,77.36 161.87,76.87 161.87,67.11 162.36,66.62 162.36,66.06 v4(162.76,65.66) 162.36,65.26 162.36,62.33 161.79,61.77 161.79,56.17 162.36,55.6 162.36,51.96 v4(162.76,51.56) 162.36,51.16 162.36,48.2 161.8,47.64 161.8,39.85 161.94,39.71 162.22,39.71 162.36,39.57 162.36,39.25 162.21,39.1 161.09,39.1 160.92,38.92 160.92,38.71 161.04,38.58 162.21,38.58 162.36,38.43 162.36,37.61 v4(162.76,37.21)
  03_SIG1 w0.292: 161.79,95.39 161.36,95.82 157.6,95.82 155.35,98.07 155.35,99.28 154.93,99.69 151.56,99.69 150.37,100.88 150.37,101.66 150.01,102.03 150.01,103.57 151,104.57 151,105.15 151.44,105.6 152.47,105.6 v1(153.1,104.97)
  05_SIG2 w0.173: 142.63,59.65 142.34,59.65 141.62,60.37 141.06,60.37 140.74,60.69 140.74,61.06 140.45,61.34 140.03,61.34 139.74,61.64 139.74,62.05 139.44,62.34 139.03,62.34 138.74,62.64 138.74,63.05 138.44,63.34 138.03,63.34 137.74,63.64 137.74,64.05 137.44,64.34 137.03,64.34 136.74,64.64 136.74,65.01 136.41,65.34 136.03,65.34 134.74,66.64 134.74,67.05 134.44,67.34 134.03,67.34 133.74,67.64 133.74,68.06 133.24,68.56 v2(133.24,68.84) ; v4(162.76,37.21) 162.36,37.61 162.36,38.32 161.8,38.88 161.8,39.35 ; 161.73,49.45 153.97,49.45 ; 153.97,52.6 154.25,52.88
  05_SIG2 w0.292: 142.63,59.65 142.93,59.65 148.89,53.69 154.13,53.69 154.56,54.12 157.14,54.12 157.36,54.34 158.56,54.34 158.78,54.12 159.91,54.12 160.37,53.66 160.37,53.13 160.13,52.88 154.25,52.88 ; 161.8,39.35 161.8,43.9 161.44,44.27 160.28,44.27 160.13,44.11 160.13,43.59 159.97,43.44 159.65,43.44 159.5,43.59 159.5,44.11 159.34,44.27 159.02,44.27 158.87,44.11 158.87,43.59 158.71,43.44 158.39,43.44 158.24,43.59 158.24,44.11 158.08,44.27 157.76,44.27 157.61,44.11 157.61,43.59 157.45,43.44 157.13,43.44 156.98,43.59 156.98,44.11 156.82,44.27 156.5,44.27 156.35,44.11 156.35,43.59 156.19,43.44 155.87,43.44 155.72,43.59 155.72,44.11 155.56,44.27 154.5,44.27 153.77,45 153.77,48.67 153.93,48.82 154.38,48.82 154.54,48.67 154.54,48.18 154.7,48.03 155.01,48.03 155.17,48.18 155.17,48.67 155.33,48.82 155.64,48.82 155.8,48.67 155.8,48.18 155.96,48.03 156.27,48.03 156.43,48.18 156.43,48.67 156.59,48.82 156.9,48.82 157.06,48.67 157.06,48.18 157.22,48.03 157.53,48.03 157.69,48.18 157.69,48.67 157.85,48.82 158.16,48.82 158.32,48.67 158.32,48.18 158.48,48.03 158.79,48.03 158.95,48.18 158.95,48.67 159.11,48.82 159.42,48.82 159.58,48.67 159.58,48.18 159.74,48.03 160.05,48.03 160.21,48.18 160.21,48.67 160.37,48.82 160.68,48.82 160.84,48.67 160.84,48.18 161,48.03 161.31,48.03 161.47,48.18 161.47,48.67 161.63,48.82 161.73,48.82 161.89,48.98 161.89,49.3 161.73,49.45 ; 153.97,52.6 153.8,52.43 153.8,49.61 153.95,49.45 153.97,49.45
  BOTTOM w0.279: v1(153.1,104.97) 152.94,104.81 R923.2
DDR4_C2_ACT_B: length 185.7
  TOP w0.152: v2(128.24,67.84) 127.74,67.34 U1.AN25 ; U136.L3 v4(163.56,61.66) ; U135.L3 v4(163.56,47.56) ; U137.L3 v4(163.56,75.75) ; U138.L3 v4(163.56,89.85) ; U139.L3 v4(163.56,33.21)
  03_SIG1 w0.173: 163.76,95.39 164.01,95.14 164.01,90.3 v4(163.56,89.85) U138.L3 163.16,81.52 163.96,80.72 163.96,76.15 v4(163.56,75.75) 163.16,75.35 163.16,73.11 163.25,73.03 163.25,72.05 163.03,71.83 163.03,67.71 163.96,66.79 163.96,62.06 v4(163.56,61.66) U136.L3 163.16,56.64 163.69,56.11 163.69,53.09 163.96,52.82 163.96,47.96 v4(163.56,47.56) U135.L3 163.16,44.63 163.01,44.47 162.79,44.47 162.64,44.32 162.64,44.11 162.79,43.96 163.34,43.96 163.49,43.8 163.49,43.45 163.39,43.34 163.15,43.34 163.07,43.26 163.07,40.32 163.23,40.16 163.74,40.16 163.96,39.95 163.96,39.58 163.79,39.41 163.73,39.41 163.55,39.24 163.55,38.89 163.73,38.72 163.79,38.72 163.96,38.55 163.96,33.61 v4(163.56,33.21)
  03_SIG1 w0.292: v1(155.07,104.89) 156.76,103.2 156.76,100.56 158.04,99.28 158.04,98.17 158.32,97.89 161.26,97.89 163.76,95.39
  05_SIG2 w0.173: v4(163.56,33.21) 163.16,32.81 162.5,32.81 162.34,32.97 162.34,33.17 162.22,33.29 161.77,33.29 161.62,33.14 161.62,32.65 161.78,32.5 162.2,32.5 162.35,32.35 162.35,32.13 162.2,31.98 161.78,31.98 161.62,31.83 161.62,31.64 161.8,31.46 162.18,31.46 162.36,31.28 162.36,31.04 162.25,30.93 161.8,30.93 161.62,30.76 161.62,30.62 ; 142.63,53.33 141.62,54.34 141.03,54.34 140.74,54.64 140.74,55.05 140.44,55.34 140.03,55.34 139.74,55.64 139.74,56.05 139.44,56.34 139.03,56.34 138.74,56.64 138.74,57.05 138.44,57.34 138.03,57.34 137.74,57.64 137.74,58.05 137.44,58.34 137.03,58.34 136.74,58.64 136.74,59.05 136.44,59.34 136.03,59.34 135.74,59.64 135.74,60.05 135.44,60.34 135.03,60.34 134.74,60.64 134.74,61.05 134.44,61.34 134.03,61.34 133.74,61.64 133.74,62.05 133.44,62.34 133.03,62.34 132.74,62.64 132.74,63.05 132.44,63.34 132.03,63.34 131.74,63.64 131.74,64.05 131.44,64.34 131.03,64.34 130.74,64.64 130.74,65.05 130.02,65.77 129.6,65.77 128.74,66.64 128.74,67.34 v2(128.24,67.84) ; 153.99,32.14 153.97,32.14 ; 153.97,30.7 154.03,30.7
  05_SIG2 w0.292: 161.62,30.62 161.62,30.5 161.92,30.21 162.97,30.21 163.27,29.91 163.27,29.06 163,28.79 163,27.19 162.6,26.79 161.99,26.79 161.37,27.41 161.37,27.8 162.28,28.72 162.28,28.98 161.98,29.29 161.67,29.29 160.75,28.37 160.41,28.37 160.14,28.64 160.14,28.99 160.96,29.81 160.96,30.05 160.73,30.28 160.46,30.28 159.58,29.39 159.39,29.39 159.24,29.54 158.94,29.54 158.78,29.7 158.78,30.18 158.62,30.34 158.31,30.34 158.15,30.18 158.15,29.7 157.99,29.54 157.68,29.54 157.52,29.7 157.52,30.18 157.36,30.34 157.05,30.34 156.89,30.18 156.89,29.5 156.73,29.34 156.42,29.34 156.26,29.5 156.26,30.18 156.1,30.34 155.79,30.34 155.63,30.18 155.63,29.5 155.47,29.34 155.16,29.34 155,29.5 155,30.18 154.85,30.34 154.53,30.34 154.37,30.18 154.37,29.98 154.15,29.76 152.54,29.76 152.24,30.06 152.24,30.39 152.55,30.7 153.97,30.7 ; 142.63,53.33 145.34,50.62 145.34,40.34 144.12,39.12 144.12,34.8 145.46,33.46 145.46,31.67 146.83,30.3 147.73,30.3 147.95,30.52 147.95,30.98 148.21,31.24 148.63,31.24 148.83,31.05 148.83,30.42 149.08,30.16 149.45,30.16 149.96,30.68 150.32,30.68 150.84,30.16 151.27,30.16 151.56,30.46 151.56,31.2 152.02,31.65 152.43,31.65 152.79,31.29 153.23,31.29 153.42,31.49 153.42,31.92 153.64,32.14 153.97,32.14 ; 153.99,32.14 154.28,31.85 154.28,30.96 154.03,30.7
  BOTTOM w0.279: v1(155.07,104.89) 155.22,104.74 R924.2
DDR4_C2_ALERT_B: length 177.6
  TOP w0.152: U138.P9 v4(165.96,94.65) ; U139.P9 v4(165.96,38.01) ; U137.P9 v4(165.96,80.55) ; U136.P9 v4(165.96,66.46) ; U1.AR29 129.74,71.34 v2(130.24,71.84) ; U135.P9 v4(165.96,52.36)
  07_SIG3 w0.173: 167.16,30.45 167.16,30.97 166.92,31.21 166.59,31.21 166.36,31.44 166.36,37.61 v4(165.96,38.01) 165.96,38.59 165.73,38.81 165.73,38.99 166.16,39.42 166.16,39.63 166,39.78 165.79,39.78 165.53,39.52 165.36,39.52 165.2,39.67 165.2,40.25 165.35,40.4 165.51,40.4 165.66,40.55 165.66,40.77 165.51,40.92 165.35,40.92 165.2,41.07 165.2,41.41 165.35,41.57 165.79,41.57 165.94,41.72 165.94,41.93 165.79,42.08 165.35,42.08 165.2,42.24 165.2,43 165.56,43.36 165.56,51.96 v4(165.96,52.36) 165.69,52.63 165.69,56.37 165.56,56.5 U136.P9 v4(165.96,66.46) 165.38,67.03 165.38,72.59 165.56,72.77 165.56,80.15 v4(165.96,80.55) 165.23,81.28 165.23,85.88 165.56,86.21 U138.P9 v4(165.96,94.65) 165.22,95.39 ; 138.62,42.37 138.71,42.46 138.71,44.01 138.44,44.28 137.98,44.28 137.76,44.5 137.76,45.99 137.44,46.3 136.95,46.3 136.74,46.51 136.74,48.04 136.48,48.3 135.98,48.3 135.75,48.54 135.75,49.03 135.45,49.33 134.98,49.33 134.76,49.54 134.76,50.01 134.5,50.27 133.94,50.27 133.77,50.45 133.77,50.97 133.46,51.28 132.99,51.28 132.8,51.47 132.8,52.01 132.49,52.32 131.98,52.32 131.72,52.59 131.72,65.05 131.48,65.29 130.72,65.29 129.71,66.3 129.71,67.11 129.5,67.32 128.97,67.32 128.7,67.59 128.7,68.14 128.53,68.31 127.94,68.31 127.68,68.57 127.68,69.17 127.52,69.33 126.9,69.33 126.74,69.49 126.74,71.05 127.03,71.34 129.41,71.34 129.91,71.84 v2(130.24,71.84)
  07_SIG3 w0.292: 138.62,42.37 138.62,37.71 140.32,36.01 140.32,35.65 139.36,34.69 139.36,34.32 139.62,34.07 139.98,34.07 140.94,35.03 141.31,35.03 141.56,34.77 141.56,34.41 140.6,33.45 140.6,33.08 140.86,32.83 141.22,32.83 142.18,33.79 142.54,33.79 142.97,33.37 142.97,32.66 143.77,31.86 144.41,31.86 146.11,30.17 146.11,29.72 149.12,26.7 150.92,26.7 151.38,26.25 156.1,26.25 156.48,26.63 162.77,26.63 163.22,26.18 165.99,26.18 167.16,27.35 167.16,30.45 ; 165.22,95.39 164.91,95.7 164.91,96.82 163.1,98.63 163.1,99.39 162.18,100.3 157.4,100.3 156.54,101.17 v1(155.99,101.17)
  BOTTOM w0.279: R922.2 156.11,101.05 v1(155.99,101.17)
DDR4_C2_BA0: length 176.9
  TOP w0.152: U139.N2 v4(165.16,31.61) ; U137.N2 v4(165.16,74.15) ; U136.N2 v4(165.16,60.06) ; U138.N2 v4(165.16,88.25) ; U1.AR25 129.74,67.34 v2(130.24,67.84) ; U135.N2 v4(165.16,45.96)
  05_SIG2 w0.173: 153.97,34.37 154.53,34.37 154.69,34.22 154.69,33.83 154.84,33.68 155.05,33.68 155.2,33.83 155.2,34.22 155.36,34.37 155.57,34.37 155.72,34.22 155.72,33.83 155.87,33.68 156.09,33.68 156.24,33.83 156.24,34.22 156.39,34.37 156.61,34.37 156.76,34.22 156.76,33.83 156.91,33.68 157.13,33.68 157.28,33.83 157.28,34.22 157.43,34.37 157.64,34.37 157.8,34.22 157.8,33.83 157.95,33.68 158.16,33.68 158.31,33.83 158.31,34.22 158.47,34.37 166.89,34.37 167.16,34.1 167.16,32.24 166.92,32.01 166.6,32.01 166.59,32.01 166.36,31.77 166.36,31.42 166.14,31.21 165.56,31.21 v4(165.16,31.61) ; v2(130.24,67.84) 130.24,67.6 130.74,67.1 130.74,66.42 131.07,66.08 131.86,66.08 132.74,65.21 132.74,64.64 133.03,64.34 133.44,64.34 133.74,64.05 133.74,63.64 134.03,63.34 134.44,63.34 134.74,63.05 134.74,62.64 135.03,62.34 135.44,62.34 135.74,62.05 135.74,61.64 136.03,61.34 136.44,61.34 136.74,61.05 136.74,60.64 137.03,60.34 137.44,60.34 137.74,60.05 137.74,59.64 138.03,59.34 138.44,59.34 138.74,59.05 138.74,58.64 139.03,58.34 139.44,58.34 139.74,58.05 139.74,57.64 140.03,57.34 140.44,57.34 140.74,57.05 140.74,56.64 141.03,56.34 141.89,56.34 142.63,55.61
  05_SIG2 w0.292: 142.63,55.61 147.66,50.58 147.66,40.45 145.52,38.32 145.52,38.06 145.72,37.86 145.97,37.86 148.07,39.95 148.28,39.95 148.61,39.62 148.61,39.4 147.23,38.02 147.23,37.79 147.45,37.57 147.67,37.57 149.06,38.95 149.28,38.95 149.5,38.73 149.5,38.51 148.82,37.83 148.82,37.59 149.04,37.36 149.25,37.36 150.33,38.45 150.56,38.45 150.8,38.2 150.8,38.03 149.82,37.05 149.82,36.81 150.04,36.59 150.25,36.59 151.17,37.5 151.37,37.5 151.59,37.28 151.59,37.04 150.27,35.71 150.27,35.35 150.49,35.13 150.72,35.13 152.48,36.88 152.7,36.88 152.93,36.66 152.93,36.56 150.82,34.45 150.82,34.26 151.04,34.03 151.26,34.03 151.59,34.36 151.81,34.36 152.16,34.02 152.38,34.02 152.61,34.24 152.61,34.46 152.26,34.81 152.26,35.03 152.62,35.39 152.84,35.39 153.86,34.37 153.97,34.37
  14_SIG4 w0.089: 164.03,95.39 164.03,95.01 164.45,94.59 164.45,91.29 164.76,90.98 164.76,88.65 v4(165.16,88.25) 164.76,87.85 164.76,74.55 v4(165.16,74.15) 164.76,73.76 164.76,60.45 v4(165.16,60.06) 164.76,59.66 164.76,56.59 164.74,56.59 164.57,56.41 164.57,54.45 164.76,54.25 164.76,46.36 v4(165.16,45.96) 164.76,45.56 164.76,41.9 164.6,41.74 164.6,41.11 164.78,40.94 164.97,40.94 165.09,40.82 165.09,40.57 164.97,40.44 164.88,40.44 164.76,40.32 164.76,40.07 164.88,39.95 164.97,39.95 165.09,39.82 165.09,39.57 164.97,39.45 164.88,39.45 164.76,39.32 164.76,32.01 v4(165.16,31.61)
  14_SIG4 w0.157: v1(161.57,104.96) 161.57,104.27 163.13,102.72 163.13,98.47 163.55,98.05 163.55,95.97 164.03,95.48 164.03,95.39
  BOTTOM w0.279: R902.2 v1(161.57,104.96)
DDR4_C2_BA1: length 183.1
  TOP w0.152: U1.AU28 131.74,70.34 v2(132.24,70.84) ; U137.N8 v4(165.16,79.75) ; U138.N8 v4(165.16,93.85) ; U139.N8 v4(165.16,37.21) ; U136.N8 v4(165.16,65.66) ; U135.N8 v4(165.16,51.56)
  03_SIG1 w0.173: 165.56,95.39 165.56,94.25 v4(165.16,93.85) U138.N8 164.76,80.15 v4(165.16,79.75) U137.N8 164.76,66.06 v4(165.16,65.66) U136.N8 164.76,58.41 164.71,58.36 164.71,56.16 164.54,55.99 164.54,54.22 164.71,54.05 164.71,52.01 v4(165.16,51.56) 164.76,51.16 164.76,44.75 165.2,44.31 165.2,43.99 165.35,43.84 165.68,43.84 165.83,43.69 165.83,43.47 165.68,43.32 165.35,43.32 165.2,43.17 165.2,42.23 165.57,41.85 165.57,41.7 165.42,41.55 165.15,41.55 165,41.39 165,41.18 165.15,41.03 165.42,41.03 165.57,40.88 165.57,40.66 165.42,40.51 165.15,40.51 165,40.36 165,40.14 165.15,39.99 165.42,39.99 165.57,39.84 165.57,39.3 164.76,38.49 164.76,37.3 164.85,37.21 v4(165.16,37.21)
  03_SIG1 w0.292: v1(152.3,101.15) 153.7,102.55 153.7,103.62 154.41,104.32 154.41,105.31 154.19,105.52 154.19,105.94 154.6,106.35 156.95,106.35 157.48,105.82 157.77,105.82 158.37,105.22 158.37,104.68 159.58,103.47 159.58,102.5 160.58,101.5 160.58,101.08 161.15,100.51 162.17,100.51 163.1,99.58 163.1,97.98 165.56,95.52 165.56,95.39
  07_SIG3 w0.173: 142.54,46.36 142.32,46.58 141.83,46.58 141.67,46.74 141.67,47.15 141.5,47.31 140.93,47.31 140.73,47.52 140.73,48.09 140.51,48.3 140.03,48.3 139.76,48.57 139.76,48.96 139.39,49.32 139.09,49.32 138.79,49.62 138.79,50.04 138.52,50.31 137.97,50.31 137.72,50.56 137.72,51.08 137.42,51.39 136.94,51.39 136.76,51.57 136.76,52.1 136.52,52.35 135.97,52.35 135.74,52.58 135.74,65.03 134.98,65.79 134.44,65.79 133.78,66.45 133.78,66.99 133.4,67.37 132.96,67.37 132.72,67.61 132.72,68.02 132.41,68.33 132,68.33 131.74,68.59 131.74,70.34 v2(132.24,70.84) ; 163.67,30.26 163.96,30.56 163.96,33.37 164.42,33.84 164.42,36.64 164.99,37.21 v4(165.16,37.21)
  07_SIG3 w0.292: 142.54,46.36 142.54,46.01 141.84,45.31 141.84,45.07 142.16,44.75 142.38,44.75 143.08,45.45 143.3,45.45 143.52,45.23 143.52,45.01 142.83,44.31 142.83,44.09 143.05,43.86 143.27,43.86 144.01,44.6 144.24,44.6 144.46,44.38 144.46,44.16 143.72,43.42 143.72,43.2 143.94,42.97 144.16,42.97 144.73,43.54 144.94,43.54 145.16,43.31 145.16,43.08 144.48,42.39 144.48,42.16 144.7,41.94 144.91,41.94 145.75,42.78 145.97,42.78 146.2,42.56 146.2,42.33 145.5,41.64 145.5,41.41 145.72,41.19 145.94,41.19 146.64,41.89 146.86,41.89 147.09,41.67 147.09,41.44 146.39,40.75 146.39,40.52 146.61,40.3 146.84,40.3 147.53,41 147.76,41 147.98,40.77 147.98,40.55 147.28,39.85 147.28,39.63 147.59,39.33 148.39,39.33 151.15,36.57 151.96,36.57 152.2,36.33 152.2,35.72 151.97,35.49 151.14,35.49 150.98,35.34 150.98,35.02 151.14,34.86 152.11,34.86 152.27,34.71 152.27,34.39 152.11,34.23 151.14,34.23 150.98,34.08 150.98,33.76 151.14,33.6 152.18,33.6 152.3,33.48 152.3,33.16 152.18,33.03 151.26,33.03 151.1,32.87 151.1,32.68 151.25,32.53 152.08,32.53 152.33,32.28 152.33,31.47 153.53,30.26 163.67,30.26
  BOTTOM w0.279: R921.2 v1(152.3,101.15)
DDR4_C2_BG0: length 176.2
  TOP w0.152: U138.M2 v4(164.36,88.25) ; U137.M2 v4(164.36,74.15) ; U135.M2 v4(164.36,45.96) ; U136.M2 v4(164.36,60.06) ; U1.AU27 131.74,69.34 v2(132.24,69.84) ; U139.M2 v4(164.36,31.61)
  03_SIG1 w0.173: 139.74,42.67 139.74,48.08 139.48,48.34 139.04,48.34 138.74,48.64 138.74,59.05 138.44,59.34 138.03,59.34 137.74,59.64 137.74,60.05 137.44,60.34 137.03,60.34 136.74,60.64 136.74,61.05 136.44,61.34 136.03,61.34 135.74,61.64 135.74,62.05 135.44,62.34 135.03,62.34 134.74,62.64 134.74,63.05 134.44,63.34 134.03,63.34 133.74,63.64 133.74,65.05 132.92,65.86 132.51,65.86 131.74,66.64 131.74,69.08 132.24,69.58 v2(132.24,69.84) ; 161.64,30.62 161.98,30.95 161.98,31.62 162.36,32.01 U139.M2 v4(164.36,31.61)
  03_SIG1 w0.292: 139.74,42.67 139.74,42.04 139.49,41.79 139.49,41.57 139.73,41.33 139.73,41.11 139.42,40.81 138.22,40.81 137.95,40.54 137.95,40.07 138.17,39.85 138.82,39.85 139.59,39.08 145.08,39.08 145.38,38.79 145.38,38.47 145.22,38.31 142.01,38.31 141.78,38.09 141.78,37.85 142.06,37.58 144.9,37.58 145.19,37.28 145.19,37.01 145.04,36.85 142.41,36.85 142.11,36.56 142.11,36.3 142.27,36.14 145,36.14 145.22,35.93 145.22,35.62 145.02,35.43 142.42,35.43 142.25,35.25 142.25,35.01 142.48,34.78 145.03,34.78 147.4,32.41 147.4,30.68 148.06,30.02 148.31,30.02 148.49,30.2 148.49,30.84 148.78,31.14 149.07,31.14 149.37,30.84 149.37,30.06 149.67,29.75 149.98,29.75 150.46,30.23 150.92,30.23 151.4,29.75 152.19,29.75 152.88,29.06 153.28,29.06 153.44,28.9 153.44,28.41 153.59,28.26 153.91,28.26 154.07,28.41 154.07,28.54 154.25,28.73 155.37,28.73 155.52,28.57 155.52,28.37 155.68,28.22 156.1,28.22 156.95,29.06 157.91,29.06 159.14,30.28 161.31,30.28 161.64,30.62
  14_SIG4 w0.089: 163.1,95.39 163.16,95.33 163.16,94.49 163.39,94.25 163.72,94.25 163.96,94.01 163.96,88.65 v4(164.36,88.25) 163.96,87.85 163.96,85.95 164.24,85.67 164.24,84.42 163.96,84.15 163.96,74.55 v4(164.36,74.15) 163.96,73.76 163.96,73.19 163.98,73.17 163.98,63.17 163.96,63.15 163.96,60.45 v4(164.36,60.06) 163.96,59.66 163.96,57.63 164.2,57.4 164.2,56.6 163.96,56.37 163.96,46.36 v4(164.36,45.96) 163.96,45.56 163.96,44.17 163.96,44.17 163.96,43.28 164.12,43.11 164.12,42.53 163.96,42.36 163.96,32.01 v4(164.36,31.61)
  14_SIG4 w0.157: 163.1,95.39 162.56,95.93 162.56,98.02 161.73,98.84 161.73,99.72 160.52,100.93 160.52,103.48 v1(159.03,104.96)
  BOTTOM w0.279: R911.2 v1(159.03,104.96)
DDR4_C2_CK_C: length 175.1
  TOP w0.145: v4(161.96,93.85) U138.K8 ; v4(161.96,79.75) U137.K8 ; U139.K8 v4(161.96,37.21) ; v4(161.96,51.56) U135.K8 ; v2(131.24,69.84) 130.74,69.34 U1.AT27 ; v4(161.96,65.66) U136.K8
  05_SIG2 w0.127: v2(131.24,69.84) 131.24,69.58 131.36,69.45 131.58,69.45 131.84,69.18 131.84,68.68 132.08,68.45 132.49,68.45 132.84,68.09 132.84,67.68 133.07,67.45 133.48,67.45 133.84,67.09 133.84,66.18 134.84,65.18 134.84,64.68 135.07,64.45 135.61,64.45 135.84,64.21 135.84,63.68 136.08,63.45 136.49,63.45 136.84,63.09 136.84,62.68 137.08,62.45 137.5,62.45 137.84,62.1 137.84,61.68 138.07,61.45 138.48,61.45 138.84,61.09 138.84,60.68 139.08,60.45 139.49,60.45 139.84,60.09 139.84,59.68 140.07,59.45 141.49,59.45 142.11,58.83 142.17,58.83 142.2,58.8 ; v4(161.96,37.21) 161.57,37.6 161.57,38.33 161.25,38.66 160.95,38.66 160.76,38.85
  05_SIG2 w0.178: 142.63,58.4 142.59,58.43 142.57,58.43 142.2,58.8
  05_SIG2 w0.208: 142.63,58.4 147.69,53.34 148.27,53.34 148.59,53.02 148.59,52.01 148.73,51.87 149,51.87 149.14,52.01 149.14,52.57 149.55,52.97 150.24,52.97 150.48,52.73 151.36,52.73 151.6,52.97 152.65,52.97 153.03,52.59 153.03,50.9 152.58,50.44 152.58,42.9 153.05,42.43 153.53,42.43 153.68,42.58 160.66,42.58 161.07,42.17 161.07,41.06 160.74,40.72 152.82,40.72 151.21,42.34 151.21,44.84 150.8,45.24 150.8,45.8 151.21,46.2 151.21,50.5 151.07,50.64 149.42,50.64 149.28,50.5 149.28,49.75 149.42,49.61 149.59,49.61 149.91,49.29 149.91,48.62 149.59,48.3 149.42,48.3 149.28,48.16 149.28,47.6 149.89,47 149.89,46.22 149.28,45.61 149.28,44.62 149.42,44.48 149.91,44.48 150.27,44.13 150.27,43.67 149.91,43.32 149.42,43.32 149.28,43.18 149.28,41.34 149.58,41.04 151.39,41.04 152.79,39.64 157.23,39.64 157.36,39.78 157.36,39.9 157.5,40.04 157.78,40.04 157.92,39.9 157.92,39.78 158.06,39.64 158.34,39.64 158.48,39.78 158.48,40.03 158.62,40.17 158.9,40.17 159.04,40.03 159.04,39.78 159.18,39.64 159.96,39.64 160.76,38.85
  14_SIG4 w0.102: 161.28,39 161.28,39.02 161.27,39.03 161.27,39.69 161.37,39.79 161.43,39.79 161.54,39.89 161.54,40.1 161.44,40.2 161.37,40.2 161.27,40.3 161.27,43.63 162.02,44.38 162.02,44.68 162.02,44.69 162.02,44.71 ; 162.1,81.29 162.1,81.31 162.09,81.32 162.09,86.97 162.1,86.98 162.1,87 ; 162.25,53.09 162.25,53.13 162.24,53.14 162.24,58.8 162.25,58.81 ; 162.07,67.19 162.07,67.22 162.06,67.23 162.06,72.88 162.07,72.88 162.07,72.91
  14_SIG4 w0.108: 162.1,81.29 162.1,81.03 162.35,80.77 162.35,80.4 161.96,80 v4(161.96,79.75) 162.12,79.59 162.16,79.59 162.35,79.4 162.35,77 162.07,76.72 162.07,72.91 ; v4(161.96,37.21) 161.96,37.46 161.57,37.85 161.57,38.19 161.28,38.48 161.28,39 ; 162.02,44.71 162.02,48.67 162.21,48.85 162.21,49.65 162.36,49.8 162.36,51.16 v4(161.96,51.56) 162.35,51.95 162.35,52.56 162.25,52.66 162.25,53.09 ; 162.07,67.19 162.07,67 162.36,66.72 162.36,66.06 v4(161.96,65.66) 162.35,65.26 162.35,63.81 162.32,63.77 162.32,62.97 162.25,62.9 162.25,58.81 162.25,58.81 ; 162.1,87 162.1,90.8 162.35,91.05 162.35,93.63 162.13,93.85 v4(161.96,93.85)
  BOTTOM w0.145: v4(161.96,93.85) 162.36,93.45 162.36,91.9 162.76,91.5 163.2,91.5 163.22,91.52
  BOTTOM w0.188: R898.1 169.31,91.52 163.22,91.52
DDR4_C2_CK_T: length 175.1
  TOP w0.145: U135.K7 v4(161.96,49.96) ; U137.K7 v4(161.96,78.15) ; U1.AT26 130.74,68.34 v2(131.24,68.84) ; U136.K7 v4(161.96,64.06) ; U138.K7 v4(161.96,92.25) ; U139.K7 v4(161.96,35.61)
  05_SIG2 w0.127: v4(161.96,35.61) 161.57,36 161.57,36.58 161.34,36.81 160.94,36.81 160.77,36.98 160.77,38.36 160.47,38.66 ; 141.99,58.6 141.97,58.6 141.96,58.61 141.96,58.68 141.4,59.24 139.99,59.24 139.63,59.59 139.63,60 139.4,60.24 138.99,60.24 138.63,60.6 138.63,61.01 138.4,61.24 137.99,61.24 137.63,61.59 137.63,62.01 137.41,62.24 136.99,62.24 136.63,62.59 136.63,63 136.4,63.24 135.99,63.24 135.63,63.59 135.63,64.13 135.52,64.24 134.99,64.24 134.63,64.59 134.63,65.09 133.63,66.1 133.63,67.01 133.4,67.24 132.99,67.24 132.63,67.59 132.63,68 132.4,68.24 131.99,68.24 131.63,68.59 131.63,69.09 131.49,69.24 131.36,69.24 131.24,69.11 v2(131.24,68.84)
  05_SIG2 w0.178: 142.63,57.97 142.38,58.21 142.38,58.23 142.01,58.6 141.99,58.6
  05_SIG2 w0.208: 142.63,57.97 147.56,53.03 148.14,53.03 148.28,52.89 148.28,51.88 148.6,51.57 149.13,51.57 149.45,51.88 149.45,52.45 149.67,52.67 150.11,52.67 150.36,52.42 151.48,52.42 151.73,52.67 152.52,52.67 152.73,52.46 152.73,51.03 152.27,50.57 152.27,42.78 152.92,42.13 153.7,42.13 153.84,42.28 160.54,42.28 160.76,42.05 160.76,41.18 160.61,41.03 152.95,41.03 151.51,42.47 151.51,44.96 151.1,45.37 151.1,45.67 151.51,46.08 151.51,50.62 151.19,50.94 149.3,50.94 148.98,50.62 148.98,49.62 149.3,49.3 149.47,49.3 149.61,49.16 149.61,48.74 149.47,48.6 149.3,48.6 148.98,48.29 148.98,47.48 149.58,46.87 149.58,46.34 148.98,45.74 148.98,44.5 149.3,44.18 149.78,44.18 149.96,44 149.96,43.8 149.78,43.62 149.3,43.62 148.98,43.3 148.98,41.21 149.45,40.74 151.26,40.74 152.66,39.34 159.32,39.34 159.33,39.35 159.78,39.35 160.47,38.66
  14_SIG4 w0.102: 161.78,44.71 161.78,44.69 161.79,44.68 161.79,44.48 161.04,43.73 161.04,39.03 161.03,39.02 161.03,39 ; 161.82,67.19 161.82,67.22 161.83,67.23 161.83,67.61 161.68,67.76 161.68,68.04 161.83,68.2 161.83,72.88 161.82,72.88 161.82,72.91 ; 161.85,87 161.85,86.98 161.86,86.97 161.86,82.73 161.63,82.5 161.63,82.24 161.86,82.01 161.86,81.32 161.85,81.31 161.85,81.29 ; 162,53.09 162,53.15 162.01,53.16 162.01,58.8 162,58.81
  14_SIG4 w0.108: v4(161.96,92.25) 162.1,92.11 162.1,91.15 161.85,90.9 161.85,87 ; 161.03,39 161.03,38.5 160.75,38.22 160.75,37.85 160.99,37.61 161.32,37.61 161.56,37.37 161.56,36.25 161.96,35.85 v4(161.96,35.61) ; 161.82,67.19 161.82,67.01 161.56,66.74 161.56,64.45 v4(161.96,64.06) 162.07,63.94 162.07,63.07 162,63 162,58.81 162,58.81 ; 161.82,72.91 161.82,76.82 162.1,77.1 162.1,78.01 v4(161.96,78.15) 161.55,78.56 161.55,80.77 161.85,81.07 161.85,81.29 ; 161.78,44.71 161.78,48.78 161.96,48.96 v4(161.96,49.96) 161.57,50.35 161.57,52.56 162,53 162,53.09
  BOTTOM w0.145: v4(161.96,92.25) 162.05,92.16 162.05,91.84 162.65,91.25 163.19,91.25 163.22,91.22
  BOTTOM w0.188: R897.1 169.4,90.18 169.27,90.05 168.93,90.05 168.78,90.2 168.78,91.1 168.67,91.22 163.22,91.22
DDR4_C2_CKE: length 179.2
  TOP w0.152: U136.K2 v4(162.76,60.06) ; U139.K2 v4(162.76,31.61) ; U135.K2 v4(162.76,45.96) ; U137.K2 v4(162.76,74.15) ; U138.K2 v4(162.76,88.25) ; v2(134.24,70.84) 133.74,70.34 U1.AW28
  14_SIG4 w0.089: 168.01,34.53 167.16,33.67 167.16,31.44 166.92,31.21 163.39,31.21 163.32,31.28 163.08,31.28 v4(162.76,31.61) 163.16,32.01 163.16,34.65 162.36,35.44 162.36,39.89 162.48,40.01 163.06,40.01 163.16,40.12 163.16,40.37 163.01,40.51 162.48,40.51 162.36,40.64 162.36,40.89 162.48,41.01 163.06,41.01 163.16,41.11 163.16,41.36 163.01,41.51 162.48,41.51 162.36,41.63 162.36,43.27 163.16,44.06 163.16,45.56 v4(162.76,45.96) 163.16,46.36 163.16,59.66 v4(162.76,60.06) 163.16,60.45 163.16,66.87 163.11,66.91 163.11,71.98 163.27,72.14 163.27,72.82 163.16,72.94 163.16,73.76 v4(162.76,74.15) 163.16,74.55 163.16,84.02 163.06,84.11 163.06,86.98 163.16,87.08 163.16,87.85 v4(162.76,88.25) 163.16,88.65 163.16,94.01 162.92,94.25 162.59,94.25 162.36,94.49 162.36,95.03 162.01,95.39 ; 134.67,41.92 134.74,41.98 134.74,44.05 134.44,44.34 134.36,44.34 134.36,44.34 134.03,44.34 133.74,44.64 133.74,45.05 133.75,45.06 133.75,45.07 133.47,45.34 133.44,45.34 133.44,45.34 132.86,45.34 132.74,45.47 132.74,65.6 133.75,66.62 133.75,67.05 134.06,67.36 134.47,67.36 134.75,67.64 134.75,70.33 v2(134.24,70.84)
  14_SIG4 w0.157: 162.01,95.39 160.46,96.93 160.46,99.17 159.28,100.35 150.56,100.35 v1(149.76,101.15) ; 134.67,41.92 134.38,41.63 134.38,37.69 140.49,31.58 143.35,31.58 144.18,30.75 144.18,30.4 145.19,29.39 146.4,29.39 148.12,27.67 154.39,27.67 154.55,27.51 155.49,27.51 155.76,27.78 161.15,27.78 162.1,28.74 167.2,28.74 168.61,30.15 168.61,33.37 168.8,33.56 169.01,33.56 169.13,33.68 169.13,34.39 168.92,34.61 168.09,34.61 168.01,34.53
  BOTTOM w0.279: R915.2 v1(149.76,101.15)
DDR4_C2_CS_B: length 180.1
  TOP w0.152: U137.L7 v4(162.76,78.15) ; U136.L7 v4(162.76,64.06) ; U139.L7 v4(162.76,35.61) ; U1.AY29 134.74,71.34 v2(135.24,71.84) ; U135.L7 v4(162.76,49.96) ; U138.L7 v4(162.76,92.25)
  TOP w0.279: R1106.2 149.3,104.47 v1(149.55,104.71)
  05_SIG2 w0.173: 161.06,95.39 161.56,94.89 161.56,92.85 161.76,92.65 162.36,92.65 v4(162.76,92.25) 161.65,91.15 161.65,83.45 162.36,82.75 162.36,78.55 v4(162.76,78.15) 161.8,77.2 161.8,67.48 162.36,66.93 162.36,64.46 v4(162.76,64.06) 162.36,63.66 162.36,50.36 v4(162.76,49.96) 162.36,49.56 162.36,44.65 162.51,44.49 162.64,44.49 162.8,44.34 162.8,44.13 162.64,43.98 162.51,43.98 162.36,43.82 162.36,43.61 162.51,43.46 162.6,43.46 162.76,43.3 162.76,43.08 162.62,42.94 162.51,42.94 162.36,42.79 162.36,42.57 162.51,42.42 162.61,42.42 162.76,42.27 162.76,42.05 162.61,41.9 162.51,41.9 162.36,41.75 162.36,41.54 162.51,41.38 162.64,41.38 162.8,41.23 162.8,41.02 162.64,40.87 162.51,40.87 162.36,40.71 162.36,40.5 162.51,40.35 162.64,40.35 162.8,40.2 162.8,39.98 162.64,39.83 162.51,39.83 162.31,39.63 162.31,39.16 162.47,39 162.99,39 163.16,38.83 163.16,36.01 v4(162.76,35.61)
  05_SIG2 w0.292: 161.06,95.39 160.14,96.31 151.42,96.31 149.02,98.7 149.02,101.43 150,102.41 150,104.26 v1(149.55,104.71)
  07_SIG3 w0.089: 163.16,39.01 163.09,39.07
  07_SIG3 w0.173: 163.16,39.01 163.16,36.01 v4(162.76,35.61) ; v2(135.24,71.84) 134.74,71.34 134.74,67.64 135.03,67.34 135.44,67.34 135.74,67.05 135.74,66.64 136.26,66.11 136.68,66.11 137.74,65.05 137.74,52.65 138.05,52.34 138.54,52.34 138.79,52.09 138.79,51.62 139.14,51.27 139.61,51.27 139.79,51.09 139.79,50.61 140.02,50.38 141.39,50.38 141.71,50.06
  07_SIG3 w0.292: 141.71,50.06 149.77,41.99 149.77,41.48 150.44,40.82 150.87,40.82 151.48,40.21 152.03,40.21 152.91,39.33 154.6,39.33 155.72,40.46 156.67,40.46 156.94,40.18 156.94,38.86 157.1,38.7 157.42,38.7 157.57,38.86 157.57,39.55 162.59,44.57 162.9,44.57 163.04,44.43 163.04,44.18 158.78,39.92 158.78,39.65 158.8,39.65 158.99,39.45 159.29,39.45 162.63,42.8 162.93,42.8 163.07,42.66 163.07,42.28 159.85,39.06 159.85,38.65 159.93,38.57 160.2,38.57 163.13,41.5 163.47,41.5 163.66,41.3 163.66,41.04 161.56,38.94 161.56,38.78 161.85,38.49 162.05,38.49 162.75,39.2 162.97,39.2 163.09,39.07
DDR4_C2_DM0: length 66.1
  TOP w0.152: U135.E7 v4(157.96,49.96) ; v2(140.24,74.84) U1.BE32
  07_SIG3 w0.173: v4(157.96,49.96) U135.E7 158.36,50.92 158.59,51.16 160.52,51.16 160.76,51.39 160.76,53.09 ; 141.71,75.34 140.74,75.34 v2(140.24,74.84)
  07_SIG3 w0.262: 160.76,53.09 160.76,53.92 160.99,54.15 161.64,54.15 161.87,54.38 161.87,54.71 161.64,54.94 160.99,54.94 160.76,55.17 160.76,55.49 160.99,55.72 161.64,55.72 161.87,55.95 161.87,56.28 161.64,56.51 160.99,56.51 160.76,56.74 160.76,57.02 160.34,57.43 159.93,57.43 159.7,57.66 159.7,58.44 159.47,58.67 159.14,58.67 158.91,58.44 158.91,57.66 158.68,57.43 158.36,57.43 158.13,57.66 158.13,58.44 157.9,58.67 157.57,58.67 157.34,58.44 157.34,57.66 157.11,57.43 156.79,57.43 156.56,57.66 156.56,58.44 156.33,58.67 156,58.67 155.77,58.44 155.77,57.66 155.54,57.43 155.22,57.43 154.99,57.66 154.99,58.44 154.76,58.67 154.43,58.67 154.2,58.44 154.2,57.66 153.97,57.43 152.75,57.43 152.49,57.69 152.49,59.58 152.63,59.72 153.68,59.72 153.82,59.86 153.82,60.14 153.68,60.28 152.63,60.28 152.49,60.42 152.49,60.7 152.63,60.84 153.68,60.84 153.82,60.98 153.82,61.26 153.68,61.4 152.63,61.4 152.49,61.54 152.49,64.83 152.68,65.03 153.58,65.03 153.87,65.31 153.87,65.59 153.73,65.73 152.65,65.73 152.51,65.87 152.51,66.25 152.65,66.39 153.69,66.39 153.81,66.51 153.81,66.9 153.64,67.07 152.64,67.07 152.49,67.22 152.49,68.22 150.01,70.7 149.25,70.7 148.98,70.97 148.98,71.96 145.96,74.99 145.95,74.99 145.9,75.03 142.02,75.03 141.71,75.34
DDR4_C2_DM1: length 53.4
  TOP w0.152: U1.BB31 v2(137.24,73.84) ; U135.E2 v4(157.96,45.96)
  14_SIG4 w0.089: 141.66,76.14 141.46,76.34 140.03,76.34 139.74,76.05 139.74,75.64 139.44,75.34 139.03,75.34 138.74,75.05 138.74,74.64 138.44,74.34 137.76,74.34 137.26,73.84 v2(137.24,73.84) ; v4(157.96,45.96) 158.36,46.36 158.36,47.77 158.55,47.96 159.38,47.96 159.58,48.16 159.58,48.72 159.31,48.99 156.23,48.99 155.96,48.72 155.45,48.72 155.16,48.43 155.16,47.4 154.92,47.16 154.54,47.16 154.4,47.02 153.97,47.02
  14_SIG4 w0.14: 141.66,76.14 146.22,71.59 146.22,64.63 146.6,64.25 146.6,60.68 147.95,59.33 147.95,53.91 149.77,52.1 149.77,50.07 150.28,49.56 150.69,49.56 152.63,47.61 152.63,47.33 152.94,47.02 153.97,47.02
DDR4_C2_DM2: length 43.9
  TOP w0.152: U136.E7 v4(157.96,64.06) ; 132.74,75.34 v2(133.24,75.84)
  05_SIG2 w0.173: 154.15,67.19 154.15,66.36 154.45,66.06 155.02,66.06 155.16,65.92 155.16,65.45 155.36,65.26 158.19,65.26 158.36,65.09 U136.E7 v4(157.96,64.06) ; v2(133.24,75.84) 133.74,75.34 134.44,75.34 134.74,75.05 134.74,74.64 135.03,74.34 135.44,74.34 135.74,74.05 135.74,73.64 136.03,73.34 136.44,73.34 136.74,73.05 136.74,72.64 137.03,72.34 137.44,72.34 137.74,72.05 137.74,71.64 138.03,71.34 138.44,71.34 138.74,71.05 138.74,70.64 139.03,70.34 139.44,70.34 139.74,70.05 139.74,69.64 140.03,69.34 142.23,69.34 142.63,68.95
  05_SIG2 w0.262: 142.63,68.95 143.66,67.92 143.82,67.92 144.36,68.46 144.56,68.46 144.76,68.26 144.76,68.07 144.22,67.52 144.22,67.33 144.41,67.13 144.61,67.13 145.6,68.12 145.8,68.12 146,67.92 146,67.73 145.01,66.73 145.01,66.54 145.26,66.28 146.14,66.28 147.48,67.62 147.85,67.62 148.14,67.91 148.14,68.3 148.32,68.49 148.85,68.49 148.99,68.35 148.99,67.43 149.13,67.29 149.41,67.29 149.55,67.43 149.55,68.35 149.69,68.49 154.01,68.49 154.15,68.35 154.15,67.19
DDR4_C2_DM3: length 61.2
  TOP w0.152: U136.E2 v4(157.96,60.06) ; U1.AR32 v2(130.24,74.84)
  03_SIG1 w0.173: 155.97,67.19 155.96,67.17 155.96,65.49 156.19,65.26 156.52,65.26 156.76,65.02 156.76,61.63 156.76,61.49 156.99,61.26 157.41,61.26 157.56,61.41 157.56,61.49 157.56,61.95 158.99,63.38 159.47,63.38 159.56,63.29 159.56,62.14 159.47,62.06 158.59,62.06 158.36,61.82 158.36,60.6 157.96,60.2 v4(157.96,60.06) ; v2(130.24,74.84) 129.74,75.34 129.74,76.05 130.03,76.34 130.44,76.34 130.74,76.64 130.74,77.05 131.03,77.34 131.44,77.34 131.74,77.64 131.74,78.05 132.03,78.34 132.44,78.34 132.74,78.64 132.74,79.05 133.03,79.34 140.44,79.34 140.74,79.64 140.74,80.05 141.03,80.34 141.44,80.34 142.44,81.34 142.63,81.34
  03_SIG1 w0.262: 155.97,67.19 157.12,68.34 157.12,69.7 155.57,71.25 154.63,71.25 153.79,70.41 152.62,70.41 151.31,71.72 151.31,79.79 150.89,80.22 150.55,80.22 149.43,81.34 142.63,81.34
DDR4_C2_DM4: length 43.3
  TOP w0.152: U137.E7 v4(157.96,78.15) ; v2(138.24,76.84) U1.BC34
  07_SIG3 w0.173: 141.86,79.32 141.01,79.32 140.74,79.05 140.74,78.73 140.35,78.34 140.03,78.34 139.74,78.05 139.74,77.48 139.55,77.29 138.98,77.29 138.53,76.84 v2(138.24,76.84) ; 153.97,78.44 154.04,78.36 154.28,78.36 154.47,78.55 157.56,78.55 v4(157.96,78.15)
  07_SIG3 w0.262: 141.86,79.32 143.05,79.32 143.31,79.58 143.68,79.58 144.43,78.82 144.98,78.82 145.13,78.96 145.13,79.79 145.28,79.94 145.56,79.94 145.69,79.81 145.69,78.97 145.83,78.82 146.11,78.82 146.24,78.96 146.24,79.79 146.39,79.94 146.67,79.94 146.8,79.81 146.8,78.97 146.95,78.82 147.23,78.82 147.36,78.96 147.36,79.79 147.51,79.94 147.79,79.94 147.92,79.81 147.92,78.47 148.11,78.28 148.35,78.28 148.48,78.41 148.48,79.79 148.63,79.94 148.91,79.94 149.04,79.81 149.04,78.49 149.25,78.28 149.5,78.28 149.76,78.54 150,78.54 150.17,78.37 150.17,77.9 150.02,77.75 149.13,77.75 149.01,77.63 149.01,77.35 149.15,77.21 150.01,77.21 150.15,77.06 150.15,76.86 150.14,76.86 149.92,76.64 149.92,76.37 150.24,76.05 150.52,76.05 150.91,76.44 151.07,76.44 151.26,76.25 151.26,75.75 151.42,75.59 151.69,75.59 151.88,75.78 151.88,77.02 151.73,77.16 151.42,77.16 151.05,77.53 151.05,77.79 151.34,78.08 151.6,78.08 151.78,77.89 152.09,77.89 152.27,78.08 152.27,78.44 152,78.71 152,79.07 152.12,79.2 152.61,79.2 152.89,78.93 153.48,78.93 153.97,78.44
