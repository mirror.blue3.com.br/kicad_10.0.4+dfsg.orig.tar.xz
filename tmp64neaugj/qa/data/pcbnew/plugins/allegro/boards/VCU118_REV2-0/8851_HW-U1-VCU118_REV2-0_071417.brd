# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC1V2: length 26.2
  TOP w0.14: v1(226.64,60.7) 226.95,60.39 226.95,59.25 226.65,58.95 R1172.1
  TOP w0.152: v1(227.97,54.28) 227.71,54.03 224.41,54.03 224.26,54.17 L74.2
  TOP w0.254: R104.2 v1(224.15,70.01)
  05_SIG2 w0.254: v1(224.15,70.01) 224.28,69.88 224.28,68.83 222.91,67.46 222.91,64.85 223.9,63.86 225.25,63.86 226.76,62.34 226.76,61.07 226.64,60.95 v1(226.64,60.7)
  BOTTOM w0.152: v1(227.97,54.28) 227.84,54.15 Z103.2
  BOTTOM w0.381: v1(222.36,56.19) 222.37,56.18 R1155.1
  vias: v1(218.35,60.5) v1(219.49,60.5) v1(219.49,59.23) v1(220.76,60.5) v1(220.76,59.23) v1(222.03,60.5) v1(222.03,59.23) v1(223.3,60.5) v1(223.3,59.23) v1(224.57,60.5) v1(224.57,59.23)
VCC1V2_DH_R: length 19.6
  TOP w0.381: Q43.1 v1(228.63,45.94)
  03_SIG1 w0.381: v1(228.63,45.94) 228.26,45.57 222.51,45.57 220.38,47.7 219.65,47.7 219.18,48.17 219.18,52.68 v1(217.47,54.38)
  BOTTOM w0.381: R1114.2 217.99,53.87 v1(217.47,54.38)
VCC1V2_DL: length 7.2
  TOP w0.254: Q43.7 224.15,46.59 223.65,47.09 v1(223.65,47.3)
  05_SIG2 w0.381: v1(223.65,47.3) 222,47.3 v1(220.18,49.12)
  BOTTOM w0.254: U4.19 219.55,48.73 219.95,49.12 v1(220.18,49.12)
VCC1V2_FET_SWITCH: length 25.5
  TOP w0.152: L74.1 224.26,53.37 224.41,53.52 227.71,53.52 v1(227.97,53.26)
  TOP w0.381: v1(216.43,54.43) 216.35,54.52 R1137.1 ; Q43.2 228.56,46.59 v1(228.89,46.92)
  BOTTOM w0.152: R1107.2 227.71,53.52 v1(227.97,53.26)
  BOTTOM w0.254: C1524.2 219.12,53.56 218.8,53.25 218.8,51.85 218.22,51.26 U4.16
  BOTTOM w0.381: R1161.2 216.85,54.02 v1(216.43,54.43) 216.82,54.82 216.82,55.13 217.2,55.5 218.96,55.5 219.64,54.81 C1524.2 220.16,53.56 222.06,51.66 223.09,51.66
  vias: v1(228.25,51.61) v1(228.25,50.34) v1(228.25,49.07) v1(228.76,48.31) v1(229.52,49.07) v1(229.52,47.8) v1(229.57,51.44) v1(229.55,50.17)
VCC1V2_FPGA: length 504.9
  TOP w0.14: v1(227.51,60.7) 227.24,60.43 227.24,59.13 227.41,58.95 R1172.2
  TOP w0.254: v4(74.76,35.04) 74.7,34.99 C498.1 ; C755.1 72.71,99.35 72.91,99.15 72.91,98.88 v4(73.16,98.63) ; v4(74.76,98.63) 74.56,98.83 C721.1 ; v4(73.16,56.34) 72.44,57.06 C494.1 ; C434.1 74.56,56.54 v4(74.76,56.34) ; v4(78.76,42.24) 78.99,42.47 C496.1 ; v4(69.16,49.14) 68.99,48.97 C349.1 ; C437.1 68.28,56.41 v4(68.36,56.34) ; C441.1 81.16,42.25 v4(81.16,42.24) ; v4(74.76,49.94) 74.36,50.33 C435.1 ; C719.1 74.56,70.63 v4(74.76,70.44) ; v4(81.16,98.63) 81.16,98.64 C722.1 ; v4(74.76,84.53) 74.56,84.73 C1072.1 ; C354.1 78.76,34.84 v4(78.76,35.04) ; C749.1 78.99,70.67 v4(78.76,70.44) ; v4(73.16,70.44) 72.89,70.7 72.89,71.05 72.79,71.15 C752.1 ; v4(78.76,63.24) 78.76,63.03 C702.1 ; v1(70.03,44.61) C556.1 70.92,44.79 R556.1 ; C1139.1 72.44,85.25 v4(73.16,84.53) ; R299.1 64.78,87.29 64.54,87.53 U24.2 ; C492.1 74.7,49.08 v4(74.76,49.14) ; v4(78.76,98.63) 78.99,98.86 C756.1 ; v4(68.36,42.24) 68.28,42.32 C438.1 ; R103.2 v1(225.01,70.01) ; C705.1 78.76,91.23 v4(78.76,91.43) ; C717.1 74.36,64.43 v4(74.76,64.04) ; C353.1 68.99,34.87 v4(69.16,35.04) ; C1073.1 68.28,84.61 v4(68.36,84.53) ; C440.1 74.56,42.44 v4(74.76,42.24) ; C703.1 68.99,63.07 v4(69.16,63.24) ; v4(81.16,56.34) 81.16,56.34 C436.1 ; v4(78.76,84.53) 78.99,84.76 C1141.1 ; C750.1 81.3,63.09 v4(81.16,63.24) ; v4(69.16,77.33) 68.99,77.16 C1052.1 ; C706.1 68.99,91.26 v4(69.16,91.43) ; C751.1 74.7,63.18 v4(74.76,63.24) ; C495.1 81.3,34.9 v4(81.16,35.04) ; v4(73.16,42.24) 72.86,42.54 72.86,42.77 72.67,42.96 C497.1 ; v1(70.03,58.71) C695.1 70.92,58.89 R706.1 ; v4(74.76,35.84) 74.36,36.24 C439.1 ; R894.1 70.92,72.47 C953.1 ; v4(81.16,70.44) 81.16,70.44 C716.1 ; R558.1 70.92,30.69 C558.1 v1(70.03,30.51) ; v4(74.76,91.43) 74.7,91.37 C754.1 ; v4(78.76,56.34) 78.99,56.57 C493.1 ; v4(68.36,70.44) 68.28,70.51 C718.1 ; v4(81.16,84.53) 81.16,84.54 C1070.1
  TOP w0.305: v4(74.76,78.13) 74.18,78.71 C1071.1 ; v4(81.16,91.43) 81.47,91.74 81.89,91.74 C639.1
  TOP w0.381: U136.F2 v4(158.76,60.06) ; U142.E9 v2(78.32,114.17) ; v2(102.24,57.84) 102.74,58.34 U1.H16 ; v1(57.73,72.48) 57.52,72.27 SW12.5 ; U142.B6 v2(81.32,118.17) ; v1(149.83,31.24) 149.83,29.86 C168.1 150.98,29.81 v1(150.98,31.24) ; v2(103.24,75.84) 103.74,75.34 ; U135.L9 v4(162.76,52.36) ; v1(85.34,61.97) 85.34,61.98 85.29,62.03 C1577.1 ; U136.L9 v4(162.76,66.46) ; R24.1 v1(82.8,51.89) ; U141.B8 v2(95.23,122.32) ; U135.D1 v4(157.16,45.16) ; C1232.1 101.47,119.57 v2(101.23,119.32) ; U138.D9 v4(157.16,94.65) ; U141.A9 v2(96.23,123.32) ; U1.AU35 v2(132.24,77.84) ; U138.D1 v4(157.16,87.45) ; U141.K10 v2(97.23,113.32) ; U142.E5 v2(78.32,119.17) ; v2(128.24,69.84) 127.74,69.34 U1.AN27 ; v2(99.24,77.84) U1.E35 ; R597.1 v1(82.8,68.27) ; C1053.1 76.73,76.82 76.36,77.2 v4(76.36,77.33) ; v4(161.16,73.35) 161.15,73.36 161.55,73.75 U137.J1 ; U139.D1 v4(157.16,30.81) ; U138.A1 v4(154.76,87.45) ; U139.L9 v4(162.76,38.01) ; U139.B9 v4(155.56,38.01) ; U138.L9 v4(162.76,94.65) ; C491.1 72.29,49.07 v4(72.36,49.14) ; U137.F8 v4(158.76,79.75) ; U138.G1 v4(159.56,87.45) ; v1(57.73,68.67) 57.52,68.46 SW12.8 ; U138.J2 v4(161.16,88.25) ; v2(105.24,58.84) 105.74,59.34 U1.L17 ; v2(103.24,64.84) U1.J23 ; v4(74.76,77.33) 74.7,77.28 C1140.1 ; U141.C3 v2(89.23,121.32) ; v2(100.24,53.84) U1.F12 ; U1.AU25 131.74,67.34 v2(132.24,67.84) ; U136.D1 v4(157.16,59.26) ; SW12.6 57.52,71 v1(57.73,71.21) ; U135.T9 v4(167.56,52.36) ; U1.M24 v2(106.24,66.84) ; U139.J2 v4(161.16,31.61) ; U141.E9 v2(96.23,119.32) ; U135.F8 v4(158.76,51.56) ; v1(87.89,99.24) 88.15,99.24 88.26,99.35 Q27.1 ; 232.62,52.93 J101.1 ; J101.1 231.82,54.81 ; J101.1 233.43,54.81 ; J101.1 232.62,55.07 ; J101.1 231.82,53.2 ; J101.1 233.43,53.2 ; J101.1 233.69,54 ; J101.1 231.55,54 ; C723.1 68.28,98.7 v4(68.36,98.63) ; U1.E15 99.74,57.34 v2(99.24,56.84) ; U1.AY26 134.74,68.34 v2(135.24,68.84) ; SW12.7 57.52,69.73 v1(57.73,69.94) ; v2(73.32,114.17) U142.J9 ; v2(101.24,50.84) U1.G9 ; v4(161.16,59.26) 161.15,59.26 161.55,59.66 U136.J1 ; U1.D18 v2(98.24,59.84) ; U142.L11 v2(71.32,112.17) ; U141.J5 v2(91.23,114.32) ; v2(73.32,110.17) U142.J13 ; C706.1 68.75,90.48 C698.1 ; U135.B3 v4(155.56,47.56) ; U1.A17 95.74,59.34 v2(95.24,58.84) ; v1(82.85,73.48) 83.19,73.48 83.42,73.71 R178.1 ; U137.A1 v4(154.76,73.35) ; U142.B8 v2(81.32,115.17) ; U139.C1 v4(156.36,30.81) ; U1.N31 v2(107.24,73.84) ; U136.B9 v4(155.56,66.46) ; C953.1 70.38,72.3 v1(70.05,72.62) ; U135.C1 v4(156.36,45.16) ; U136.J9 v4(161.16,66.46) ; U137.G9 v4(159.56,80.55) ; U141.J9 v2(96.23,114.32) ; U138.J1 161.55,87.85 161.15,87.45 v4(161.16,87.45) ; U1.C21 v2(97.24,62.84) ; v1(85.34,63.35) 85.34,63.33 85.31,63.3 C1451.1 C1576.1 ; U139.G9 v4(159.56,38.01) ; C348.1 76.36,48.8 v4(76.36,49.14) ; v2(101.23,113.32) 101.3,113.39 C1292.1 ; v2(105.24,69.84) 105.74,69.34 U1.L27 ; U138.G7 v4(159.56,92.25) ; U141.D4 v2(90.23,120.32) ; U135.A9 v4(154.76,52.36) ; U1.P18 v2(108.24,59.84) ; U1.K30 v2(104.24,72.84) ; v1(70.03,30.51) 69.94,30.51 68.99,31.47 C353.1 ; U137.A9 v4(154.76,80.55) ; v1(64.48,84.38) 63.7,84.38 C519.1 63.59,85.16 v1(64.48,85.16) ; v1(64.08,44.88) 64.9,44.88 65.15,45.13 C156.1 63.8,46.22 63.42,45.84 v1(63.42,45.31) ; U1.C31 v2(97.24,73.84) ; U142.N5 v2(69.32,119.17) ; v4(72.36,77.33) 72.29,77.26 C1138.1 ; U139.A9 v4(154.76,38.01) ; U139.J8 v4(161.16,37.21) ; U1.E25 v2(99.24,67.84) ; v2(134.24,81.84) 133.74,81.34 U1.AW39 ; U142.M8 v2(70.32,115.17) ; U139.B3 v4(155.56,33.21) ; v2(138.24,69.84) 137.74,69.34 U1.BC27 ; v2(134.24,71.84) 133.74,71.34 U1.AW29 ; v2(138.24,79.84) U1.BC37 ; U137.R1 v4(166.76,73.35) ; C1235.1 66.7,113.86 65.93,113.86 v1(65.88,113.9) ; U142.K10 v2(72.32,113.17) ; U137.L9 v4(162.76,80.55) ; U138.T9 v4(167.56,94.65) ; v1(85.34,72.47) 85.19,72.31 C1574.1 ; U139.G1 v4(159.56,30.81) ; U142.A9 v2(82.32,114.17) ; U138.F2 v4(158.76,88.25) ; v4(81.16,91.43) 81.3,91.29 C753.1 ; v2(73.32,123.17) U142.J1 ; U137.B3 v4(155.56,75.75) ; v2(100.24,74.84) U1.F32 ; U141.J1 v2(87.23,114.32) ; U139.D9 v4(157.16,38.01) ; v2(101.24,60.84) U1.G19 ; U142.M6 v2(70.32,118.17) ; v1(71.25,87.64) 71.25,87.68 70.49,88.43 R708.1 ; v2(141.24,70.84) 140.74,70.34 U1.BF28 ; v1(82.8,71.28) 82.81,71.27 R596.1 ; U135.F2 v4(158.76,45.96) ; U141.E5 v2(91.23,119.32) ; U135.R1 v4(166.76,45.16) ; U139.A1 v4(154.76,30.81) ; U136.J8 v4(161.16,65.66) ; 135.74,75.34 v2(136.24,75.84) ; U1.BB30 v2(137.24,72.84) ; U138.A9 v4(154.76,94.65) ; U137.C1 v4(156.36,73.35) ; U138.B3 v4(155.56,89.85) ; v2(131.24,70.84) 130.74,70.34 U1.AT28 ; v2(102.24,78.84) U1.H36 ; C1454.1 v1(85.34,60.76) ; U142.A5 v2(82.32,119.17) ; U1.H26 v2(102.24,68.84) ; U1.AV32 v2(133.24,74.84) ; U139.J1 161.55,31.21 161.15,30.81 v4(161.16,30.81) ; U141.N5 v2(91.23,110.32) ; U136.L1 v4(163.56,59.26) ; U138.C1 v4(156.36,87.45) ; U135.L1 v4(163.56,45.16) ; U135.D9 v4(157.16,52.36) ; U139.R1 v4(166.76,30.81) ; U136.A1 v4(154.76,59.26) ; v2(141.24,80.84) 140.74,80.34 U1.BF38 ; U138.B9 v4(155.56,94.65) ; v2(108.24,70.84) 108.74,70.34 U1.P28 ; C720.1 74.26,91.93 v4(74.76,91.43) ; U138.F8 v4(158.76,93.85) ; U137.J8 v4(161.16,79.75) ; U1.AR31 v2(130.24,73.84) ; U1.A37 v2(95.24,79.84) ; U135.J2 v4(161.16,45.96) ; U135.J1 161.55,45.56 161.15,45.16 v4(161.16,45.16) ; U135.A1 v4(154.76,45.16) ; U136.G9 v4(159.56,66.46) ; U138.J8 v4(161.16,93.85) ; U142.L3 v2(71.32,121.17) ; U138.G9 v4(159.56,94.65) ; U1.G29 v2(101.24,71.84) ; U1.D28 98.74,70.34 v2(98.24,70.84) ; U139.F2 v4(158.76,31.61) ; U137.J2 v4(161.16,74.15) ; U135.G9 v4(159.56,52.36) ; U142.D4 v2(79.32,120.17) ; U1.A7 v2(95.24,48.84) ; U142.C3 v2(80.32,121.17) ; v2(137.24,82.84) 136.74,82.34 U1.BB40 ; U136.G1 v4(159.56,59.26) ; R900.1 146.18,105.83 145.83,106.19 145.78,106.19 v1(145.52,106.45) ; U141.N9 v2(96.23,110.32) ; U136.D9 v4(157.16,66.46) ; U135.G7 v4(159.56,49.96) ; U135.J9 v4(161.16,52.36) ; v2(96.24,55.84) 96.74,56.34 U1.B14 ; U1.G39 v2(101.24,81.84) ; R177.1 83.49,76.71 v1(82.93,77.27) ; v2(73.32,119.17) U142.J5 ; v2(98.24,80.84) 98.74,80.34 U1.D38 ; v2(95.24,69.84) 95.74,69.34 U1.A27 ; U142.K4 v2(72.32,120.17) ; U136.F8 v4(158.76,65.66) ; U137.D1 v4(157.16,73.35) ; U138.R1 v4(166.76,87.45) ; U1.T22 v2(110.24,63.84) ; U137.L1 v4(163.56,73.35) ; U1.R25 109.74,67.34 v2(109.24,67.84) ; v1(52.61,133.73) 52.61,133.08 C1386.1 53.79,133.13 v1(53.79,133.76) ; U135.G1 v4(159.56,45.16) ; U136.G7 v4(159.56,64.06) ; U141.M6 v2(92.23,111.32) ; U139.G7 v4(159.56,35.61) ; U142.C11 v2(80.32,112.17) ; SW5.1 SW5.2 105.26,127.33 v1(104.55,126.62) ; U141.M8 v2(95.23,111.32) ; U1.AY36 v2(135.24,78.84) ; U142.N9 v2(69.32,114.17) ; U136.T9 v4(167.56,66.46) ; U136.R1 v4(166.76,59.26) ; U135.J8 v4(161.16,51.56) ; v1(175.13,65.3) 176.34,65.3 C166.1 176.34,66.92 176.12,67.13 v1(175.13,67.13) ; U139.T9 v4(167.56,38.01) ; U137.B9 v4(155.56,80.55) ; U141.A5 v2(91.23,123.32) ; C1270.1 v1(83.59,122.87) ; U137.J9 v4(161.16,80.55) ; U139.L1 v4(163.56,30.81) ; U141.C11 v2(98.23,121.32) ; U141.B6 v2(92.23,122.32) ; U141.L11 v2(98.23,112.32) ; U1.B34 v2(96.24,76.84) ; U137.D9 v4(157.16,80.55) ; U138.J9 v4(161.16,94.65) ; U136.A9 v4(154.76,66.46) ; U1.N21 v2(107.24,62.84) ; U141.D10 v2(97.23,120.32) ; v2(139.24,76.84) U1.BD34 ; v1(64.36,83.26) 63.7,83.26 C520.1 63.7,82.37 v1(64.36,82.37) ; U136.B3 v4(155.56,61.66) ; v2(90.23,113.32) U141.K4 ; U135.B9 v4(155.56,52.36) ; v2(140.24,73.84) U1.BE31 ; U136.C1 v4(156.36,59.26) ; U141.J13 v2(100.23,114.32) ; v2(100.24,63.84) U1.F22 ; U141.L3 v2(89.23,112.32) ; U1.C11 v2(97.24,52.84) ; U136.J2 v4(161.16,60.06) ; R299.1 v1(66.22,87.29) ; U137.F2 v4(158.76,74.15) ; R23.1 v1(82.8,54.89) ; U1.B24 v2(96.24,66.84) ; U137.G1 v4(159.56,73.35) ; U137.T9 v4(167.56,80.55) ; U137.G7 v4(159.56,78.15) ; U1.K20 v2(104.24,61.84) ; U142.D10 v2(79.32,113.17) ; U138.L1 v4(163.56,87.45) ; U139.F8 v4(158.76,37.21) ; U139.J9 v4(161.16,38.01)
  05_SIG2 w0.254: v1(225.01,70.01) 224.95,69.96 224.95,68.56 223.58,67.19 223.58,65.12 224.18,64.52 225.52,64.52 227.43,62.62 227.43,61.04 227.51,60.95 v1(227.51,60.7)
  05_SIG2 w0.305: v2(133.24,74.84) 132.98,74.84 132.48,74.34 130.97,74.34 130.47,73.84 v2(130.24,73.84)
  05_SIG2 w0.381: 107.87,59.48 v2(108.24,59.84) 108.6,59.48 ; 106.87,63.21 v2(107.24,62.84) 107.6,63.21
  12_PWR3 w0.381: 89.3,129.14 J105.1 ; J105.1 89.56,128.34 ; J105.1 90.37,128.07 ; J105.1 91.43,129.14 ; J105.1 89.56,129.95 ; J105.1 91.17,129.95 ; J105.1 90.37,130.21 ; J105.1 91.17,128.34 ; 231.55,54 J101.1 ; J101.1 231.82,53.2 ; J101.1 232.62,52.93 ; J101.1 233.69,54 ; J101.1 231.82,54.81 ; J101.1 233.43,54.81 ; J101.1 233.43,53.2 ; J101.1 232.62,55.07
  14_SIG4 w0.305: v2(128.24,69.84) 128.74,70.34 130.74,70.34 v2(131.24,70.84)
  16_SIG5 w0.254: v2(104.24,72.84) 104.74,73.34 106.74,73.34 v2(107.24,73.84)
  18_SIG6 w0.254: v2(107.24,73.84) 106.74,74.34 106.74,75.11 106.5,75.34 103.74,75.34 v2(103.24,75.84)
  20_SIG7 w0.305: v2(97.24,52.84) 96.74,52.34 94.79,52.34 94.57,52.12 94.57,49.51 v2(95.24,48.84) ; v2(100.24,53.84) 100.74,53.34 100.74,51.55 101.24,51.05 v2(101.24,50.84)
  BOTTOM w0.173: v2(96.23,119.32) 95.74,118.83 94.73,118.83 94.63,118.93 C1759.1
  BOTTOM w0.191: v2(132.24,77.84) 132.24,78.03 132.74,78.54 132.74,84.07 132.97,84.3 133.42,84.3 133.76,84.64 133.76,85.09 134.01,85.34 135.46,85.34 135.74,85.62 135.74,85.64 135.74,86.07 136.01,86.34 136.46,86.34 136.74,86.62 136.74,87.07 137.01,87.34 137.48,87.34 137.74,87.6 137.74,88.07 138.01,88.34 140.78,88.34 141.14,87.98 145.1,87.98 146.04,87.05 151.25,87.05 Z107.2
  BOTTOM w0.203: R991.1 56.66,136.4 56.85,136.2 56.85,135.01 56.67,134.83 U143.2
  BOTTOM w0.254: v4(159.56,94.65) 159.36,94.85 C1202.1 ; C1201.1 154.68,87.37 v4(154.76,87.45) ; C1172.1 155.19,80.92 v4(155.56,80.55) ; v1(165.76,42.75) R935.1 165.09,42.41 165.28,42.22 C1143.1 ; C1188.1 159.36,52.56 v4(159.56,52.36) ; C1220.1 159.51,73.3 v4(159.56,73.35) ; C1152.1 165.28,84.45 165.09,84.63 R941.1 v1(165.76,85.04) ; v1(170.17,31.05) 170.23,30.99 C1161.1 ; C1215.1 167.83,66.72 v4(167.56,66.46) ; C1197.1 166.82,73.29 v4(166.76,73.35) ; v4(167.56,80.55) 167.83,80.82 C1217.1 ; v4(162.76,94.65) 163.29,95.19 C1175.1 ; v4(166.76,45.16) 166.82,45.1 C1189.1 ; C1214.1 159.51,59.21 v4(159.56,59.26) ; C1174.1 155.19,95.08 v4(154.76,94.65) ; U134.2 146.09,105.6 145.52,106.18 v1(145.52,106.45) ; C1211.1 156.25,48.25 v4(155.56,47.56) ; C1149.1 165.28,70.48 165.09,70.66 R939.1 v1(165.88,70.95) ; v4(162.76,38.01) 163.29,38.54 C1177.1 ; v4(155.56,33.21) 156.25,33.9 C1227.1 ; C1210.1 159.51,45.11 v4(159.56,45.16) ; v4(155.56,52.36) 155.19,52.73 C1166.1 ; v4(161.16,38.01) 161.36,38.21 C1228.1 ; v4(167.56,94.65) 167.83,94.92 C1223.1 ; v4(161.16,94.65) 161.36,94.85 C1221.1 ; C1190.1 161.41,46.21 v4(161.16,45.96) ; C1212.1 167.83,52.63 v4(167.56,52.36) ; v4(159.56,38.01) 159.36,38.21 C1207.1 ; C1205.1 154.68,30.73 v4(154.76,30.81) ; v4(161.16,60.06) 161.41,60.31 C1195.1 ; C1222.1 159.51,87.4 v4(159.56,87.45) ; C1193.1 166.82,59.2 v4(166.76,59.26) ; R937.1 165.58,56.85 165.7,56.96 v1(166.1,56.96) 166.19,56.87 C1146.1 ; v4(162.76,52.36) 163.48,53.08 C1165.1 ; v4(166.76,30.81) 166.82,30.75 C1204.1 ; v4(155.56,89.85) 156.25,90.54 C1224.1 ; v4(155.56,38.01) 155.19,38.37 C1178.1 ; v4(167.56,38.01) 167.83,38.28 C1225.1 ; v4(161.16,88.25) 161.43,88.52 C1200.1 ; C1209.1 161.48,52.68 v4(161.16,52.36)
  BOTTOM w0.305: C1213.1 161.48,66.78 v4(161.16,66.46) ; v4(159.56,66.46) 159.36,66.66 C1194.1 ; C1219.1 156.25,76.44 v4(155.56,75.75) ; v4(159.56,30.81) 159.51,30.76 C1226.1 ; C1196.1 159.21,80.91 v4(159.56,80.55) ; C1192.1 162.89,58.59 v4(163.56,59.26) ; v4(155.56,66.46) 155.19,66.82 C1169.1 ; C1198.1 161.41,74.4 v4(161.16,74.15) ; v4(155.56,61.66) 156.25,62.35 C1216.1 ; v4(163.56,45.16) 163.56,44.48 163.19,44.11 C1191.1 ; C1218.1 161.18,80.57 v4(161.16,80.55) ; v4(162.76,80.55) 163.12,80.91 C1171.1 ; C1168.1 162.8,66.46 v4(162.76,66.46) ; v4(161.16,31.61) 161.41,31.86 C1206.1
  BOTTOM w0.381: U60.L9 v4(73.16,42.24) ; U62.J8 v4(74.76,97.83) ; U64.L9 v4(73.16,56.34) ; v2(96.23,123.32) 96.3,123.4 C1293.1 ; U60.B3 v4(80.36,37.44) ; U63.A1 v4(81.16,77.33) ; U64.L1 v4(72.36,49.14) ; U63.J1 v4(74.76,77.33) ; R105.1 88.15,99.36 88.02,99.24 v1(87.89,99.24) ; U60.G1 v4(76.36,35.04) ; U63.F2 v4(77.16,78.13) ; U62.C1 v4(79.56,91.43) ; C1286.1 80.48,116.01 v2(81.32,115.17) ; U63.G7 v4(76.36,82.13) ; U61.B9 v4(80.36,70.44) ; U63.B9 v4(80.36,84.53) ; v1(52.61,133.73) 52.61,133.08 C1386.1 53.79,133.13 v1(53.79,133.76) ; U62.G7 v4(76.36,96.23) ; U62.A1 v4(81.16,91.43) ; U63.G9 v4(76.36,84.53) ; U61.L9 v4(73.16,70.44) ; U62.G1 v4(76.36,91.43) ; C1452.1 151.13,79.93 v1(150.75,79.55) ; U64.T9 v4(68.36,56.34) ; C1279.1 94.62,121.72 v2(95.23,122.32) ; v1(165.35,27.84) 165.09,28.1 R943.1 ; U64.J9 v4(74.76,56.34) ; U64.A9 v4(81.16,56.34) ; U63.F8 v4(77.16,83.73) ; U62.J2 v4(74.76,92.23) ; U60.F2 v4(77.16,35.84) ; U42.2 v1(233.19,79.88) 233.05,79.75 C74.1 ; U64.F8 v4(77.16,55.54) ; U61.G9 v4(76.36,70.44) ; R989.1 100.36,109.19 v2(100.23,109.32) ; U61.A9 v4(81.16,70.44) ; U64.J8 v4(74.76,55.54) ; R17.1 153.54,66.75 153.84,66.46 v4(154.76,66.46) ; C1163.1 v1(169.4,93.76) ; U64.G1 v4(76.36,49.14) ; U60.B9 v4(80.36,42.24) ; U60.G9 v4(76.36,42.24) ; v4(166.76,87.45) 166.5,87.2 C1203.1 ; U61.L1 v4(72.36,63.24) ; U61.J2 v4(74.76,64.04) ; J101.1 232.62,55.07 ; J101.1 231.82,53.2 ; J101.1 231.82,54.81 ; J101.1 233.43,54.81 ; J101.1 233.69,54 ; J101.1 231.55,54 ; U62.J1 v4(74.76,91.43) ; U61.J9 v4(74.76,70.44) ; U60.R1 v4(69.16,35.04) ; R1195.1 100.4,125.48 v1(99.52,125.48) 99.27,125.72 R1193.1 ; U61.G1 v4(76.36,63.24) ; U62.B3 v4(80.36,93.83) ; U62.B9 v4(80.36,98.63) ; v2(73.32,110.17) 73.27,110.11 C1391.1 ; Q28.1 173.4,27.59 173.3,27.49 R219.1 172.68,27.49 v1(172.09,26.9) ; U64.G9 v4(76.36,56.34) ; U64.J1 v4(74.76,49.14) ; U60.F8 v4(77.16,41.44) ; U64.G7 v4(76.36,53.94) ; C1235.1 66.07,113.21 v1(65.53,113.21) ; U61.D9 v4(78.76,70.44) ; U64.B9 v4(80.36,56.34) ; U60.J1 v4(74.76,35.04) ; C1272.1 74.65,108.83 v2(74.32,109.16) ; C1299.1 80.27,109.11 v2(80.32,109.17) ; C1575.1 151.22,76.63 150.84,77.01 v1(150.75,77.01) 150.75,77.39 151,77.65 C1450.1 ; U60.J2 v4(74.76,35.84) ; C72.1 v1(222,69.13) ; U62.F2 v4(77.16,92.23) ; U61.J8 v4(74.76,69.64) ; U62.D1 v4(78.76,91.43) ; U62.R1 v4(69.16,91.43) ; C1453.1 150.88,78.28 v1(150.75,78.28) ; U64.D9 v4(78.76,56.34) ; U63.D1 v4(78.76,77.33) ; C1285.1 71.03,115.87 v2(70.32,115.17) ; U63.C1 v4(79.56,77.33) ; U64.A1 v4(81.16,49.14) ; U60.L1 v4(72.36,35.04) ; U61.G7 v4(76.36,68.04) ; U64.D1 v4(78.76,49.14) ; U60.C1 v4(79.56,35.04) ; U64.C1 v4(79.56,49.14) ; U64.B3 v4(80.36,51.54) ; U63.L9 v4(73.16,84.53) ; U62.D9 v4(78.76,98.63) ; U60.G7 v4(76.36,39.84) ; U63.J9 v4(74.76,84.53) ; U62.L9 v4(73.16,98.63) ; U64.J2 v4(74.76,49.94) ; U63.T9 v4(68.36,84.53) ; Q22.1 177.44,27.17 177.54,27.07 R210.1 177.54,26.15 v1(177.09,25.7) ; U61.R1 v4(69.16,63.24) ; U60.J8 v4(74.76,41.44) ; U60.D1 v4(78.76,35.04) ; U62.G9 v4(76.36,98.63) ; R991.1 v1(56.24,137.28) ; U61.D1 v4(78.76,63.24) ; U62.L1 v4(72.36,91.43) ; v2(95.23,111.32) 94.72,111.83 C1298.1 ; U60.A1 v4(81.16,35.04) ; U64.F2 v4(77.16,49.94) ; U63.L1 v4(72.36,77.33) ; U62.A9 v4(81.16,98.63) ; U61.J1 v4(74.76,63.24) ; U41.2 v1(218.06,71.05) ; U61.A1 v4(81.16,63.24) ; v4(154.76,73.35) 154.81,73.31 C1199.1 154.81,70.78 153.77,69.75 R18.1 ; U61.B3 v4(80.36,65.64) ; U62.T9 v4(68.36,98.63) ; U62.J9 v4(74.76,98.63) ; U62.F8 v4(77.16,97.83) ; U61.T9 v4(68.36,70.44) ; U63.D9 v4(78.76,84.53) ; U60.J9 v4(74.76,42.24) ; U63.J8 v4(74.76,83.73) ; U63.R1 v4(69.16,77.33) ; U61.F8 v4(77.16,69.64) ; U60.D9 v4(78.76,42.24) ; U63.G1 v4(76.36,77.33) ; U63.A9 v4(81.16,84.53) ; U61.C1 v4(79.56,63.24) ; U63.J2 v4(74.76,78.13) ; U63.B3 v4(80.36,79.73) ; R1194.1 96.87,125.85 v1(97.08,126.06) ; U60.T9 v4(68.36,42.24) ; U60.A9 v4(81.16,42.24) ; U64.R1 v4(69.16,49.14) ; U61.F2 v4(77.16,64.04)
  vias: v1(145.92,110.77) v1(146.35,110.14) v1(146.39,109.32) v1(170.36,37.69) v1(170.48,37.02) v1(229.52,58.35) v1(229.52,56.95) v1(229.52,55.68) v1(229.62,60.5) v1(229.62,59.49) v1(230.77,60.43) v1(230.77,59.16) v1(230.77,57.89) v1(232.04,60.43) v1(232.04,59.16) v1(232.04,57.89)
VCC1V2_FPGA_SNS_N: length 122
  16_SIG5 w0.089: v1(217.18,42.52) 216.77,42.12 216.77,41.6 212.23,37.06 203.26,37.06 200.84,39.48 200.84,41.29 191.4,50.72 181.08,50.72 177.5,47.14 173.23,47.14 171.73,48.63 171.73,57.73 169.85,59.61 169.85,63.81 171.03,65 171.03,68.57 170.61,68.99 170.61,71.23 170.94,71.55 171.18,71.55 v1(171.52,71.89)
  BOTTOM w0.104: U4.26 217.72,44.86 216.9,44.04 216.9,43.78 C1534.2 ; v1(217.18,42.52) 217.2,42.54 C1534.2 ; C1534.2 C1447.1 ; Z108.1 152.29,86.74 153.4,86.74 154.22,85.92 160.78,85.92 164.72,81.97 164.72,81.1 164.31,80.7 164.31,77.86 164.78,77.39 167.13,77.39 168.1,76.43 168.1,74.93 168.53,74.5 170.59,74.5 172.12,72.97 173.72,72.97 173.92,72.77 173.92,71.83 173.62,71.53 171.89,71.53 v1(171.52,71.89)
VCC1V2_FPGA_SNS_P: length 165.8
  TOP w0.104: U29.8 225.34,68.45 225.6,68.71 225.6,69.32 225.71,69.43 v1(225.71,69.54)
  03_SIG1 w0.135: v1(225.71,69.54) 225.2,69.03 225.2,67.78 225.88,67.11 225.88,63.55 228.37,61.06 228.37,55.68 230.91,53.14 230.91,45.39 228.93,43.41 216.87,43.41 v1(216.06,42.6)
  16_SIG5 w0.089: v1(216.06,42.6) 216.37,42.6 216.49,42.47 216.49,41.72 216.23,41.45 215.77,41.45 215.61,41.3 215.61,41.11 215.66,41.06 215.66,40.88 212.12,37.34 203.38,37.34 201.12,39.6 201.12,41.4 191.52,51 180.97,51 177.38,47.42 173.34,47.42 172.01,48.75 172.01,57.84 170.13,59.72 170.13,63.7 171.31,64.88 171.31,68.68 170.89,69.1 170.89,71.11 171.05,71.27 171.18,71.27 v1(171.52,70.93)
  BOTTOM w0.104: v1(171.52,70.93) 171.89,71.3 173.71,71.3 174.15,71.74 174.15,72.86 173.81,73.2 172.21,73.2 170.69,74.73 168.62,74.73 168.33,75.02 168.33,76.52 167.23,77.62 164.87,77.62 164.54,77.95 164.54,80.6 164.95,81.01 164.95,82.07 160.87,86.14 154.32,86.14 153.49,86.97 152.31,86.97 Z107.1 ; v1(216.06,42.6) 216.31,42.85 216.31,43.37 C1534.1 216.2,43.98 216.47,44.25 216.71,44.25 217.22,44.76 U4.27
VCC1V2_FPGA_VIN: length 5.4
  TOP w0.152: R103.1 224.84,68.68 U29.9 224.84,66.74 v1(225.04,66.55) 224.78,66.29 224.78,65.95 224.36,65.53 223.73,65.53 223.41,65.21 C117.1
VCC1V2_PGOOD: length 186.5
  16_SIG5 w0.381: v1(205.92,149.7) 205.55,150.07 200.68,150.07 199.58,151.17 199.58,155.23 198.83,155.98 198.83,166.78 196.09,169.52 v1(196.09,170.37)
  18_SIG6 w0.381: v1(214.05,44.81) 214.05,48.94 216.29,51.17 216.29,53.64 215.15,54.78 215.15,58.84 216.26,59.94 216.26,71.7 210.11,77.85 210.11,125.4 204.75,130.76 192.81,130.76 188.57,135 184.45,135 183.11,136.34 183.11,144 185.93,146.81 190.32,146.81 194.74,151.23 197.23,151.23 198.07,152.07 202.92,152.07 204.9,150.09 205.53,150.09 v1(205.92,149.7)
  BOTTOM w0.254: RP2.5 201.32,151.49 201.67,151.49 203.06,150.09 U51.6 ; U4.32 214.72,45.32 214.2,44.81 v1(214.05,44.81)
  BOTTOM w0.381: D4.1 v1(196.09,170.37) ; v1(205.92,149.7) 205.53,150.09 U51.6
VCC1V2_TEMPX: length 22.4
  BOTTOM w0.254: U4.7 213.57,49.23 212.66,50.15 212.66,50.62 212.25,51.03 C1540.1 211.59,51.28 211.59,51.8 217.19,57.41 224.46,57.41 225.05,56.81 Q49.1 225.05,55.27 Q49.2
VCC1V2_VIN: length 4.8
  TOP w0.152: R104.1 224.34,68.66 U29.10 224.34,66.73 v1(224.17,66.55) 224.42,66.29 224.42,66.1 224.21,65.89 223.73,65.89 223.41,66.21 C117.2
VCC1V8: length 114.8
  TOP w0.14: R1171.1 146.32,126.72 146.25,126.78 145.01,126.78 v1(144.84,126.61)
  TOP w0.152: v1(152.63,128.25) 153.03,127.84 153.03,125.15 152.58,124.69 L80.2
  TOP w0.381: v1(53.32,147.95) 53.55,147.71 54.32,147.71 54.34,147.74 U19.1 ; SW16.7 31.19,116.33 v1(30.66,116.87) 30.23,116.87 29.92,116.56 SW16.6 ; v1(129.06,14.83) 129.34,14.83 129.41,14.91 U53.6 ; v1(10.11,154.43) 10.11,152.73 10.48,152.36 U115.9 12.15,152.36 12.42,152.63 v1(12.42,154.45) ; SW16.5 28.65,115.95 28.07,116.54 v1(28.07,116.76)
  18_SIG6 w0.381: v1(67.29,136.26) 66.6,136.95 61.46,136.95 60.98,137.43 v1(59.71,137.43)
  BOTTOM w0.14: R100.2 144.72,126.74 v1(144.84,126.61)
  BOTTOM w0.152: Z97.2 152.97,122.83 152.97,127.91 v1(152.63,128.25)
  BOTTOM w0.203: v1(55.25,77.51) 54.68,78.07 U33.6 ; U13.6 35.18,67.28 34.67,66.77 v1(34.39,66.77) ; U22.6 51.25,77.88 v1(51.57,77.56)
  BOTTOM w0.381: R840.1 209.04,29.71 210.3,28.44 v1(212.32,28.44) ; v1(100.44,137.6) 100.44,136.6 R53.1 100.97,135.44 100.76,135.22 92.99,135.22 90.77,137.44 68.47,137.44 v1(67.29,136.26) ; v1(133.1,26.47) 133.1,29.26 133.86,30.02 R547.1 ; R16.1 v1(26.84,88.36) ; R72.1 46.29,142.87 v1(46.13,143.03) ; Q21.1 227.25,39.16 227.35,39.26 R324.1 228.91,39.26 v1(229.23,38.94) ; R1092.1 62.84,64.8 v1(63.27,65.23) ; C41.1 R861.1 v1(56.2,150.11) ; C126.1 v1(55.25,77.51) ; R838.1 v1(221.74,22.5) ; v1(56.84,62.33) C66.1 56.84,60.82 57.15,60.5 U3.2 ; C62.1 52.07,77.06 v1(51.57,77.56) ; R839.1 v1(223.14,34.64) ; R837.1 220.69,15.61 220.95,15.87 220.95,15.88 v1(221.33,16.26) ; v1(150.67,121.08) 150.68,121.09 R1154.1 ; v1(34.39,66.77) 34.5,66.66 C39.1 ; R683.1 v1(59.71,137.43) ; v1(129.06,14.83) 129.32,14.57 C540.1 R6.1 ; R841.1 v1(224.12,29.83) ; U17.2 57.15,35.01 v1(56.93,35.23) 56.84,35.33 C122.1 ; R682.1 v1(58.44,137.43)
  vias: v1(18.92,88.71) v1(19.93,88.71) v1(20.95,88.71) v1(39.19,89.66) v1(40.01,89.66) v1(43.48,75.99) v1(99.83,29.23) v1(148.39,124.56) v1(148.39,123.42) v1(148.39,122.4) v1(148.39,121.64) v1(148.39,120.37) v1(196.09,127.56) v1(197.36,127.56) v1(198.63,127.56) v1(199.9,127.56) v1(199.9,126.54) v1(201.17,127.56) v1(201.17,126.54) v1(202.44,127.56) v1(202.44,126.54)
VCC1V8_DH_R: length 16.1
  TOP w0.381: Q42.1 v1(160.66,127.36)
  03_SIG1 w0.381: v1(160.66,127.36) 160.66,125.29 160.18,124.8 159.37,124.8 154.49,119.92 154.49,118.62 v1(152.58,116.71)
  BOTTOM w0.508: R1112.2 v1(152.58,116.71)
VCC1V8_DL: length 7
  TOP w0.254: v1(159.56,122.53) 160.01,122.98 Q42.7
  07_SIG3 w0.381: v1(159.56,122.53) 159.56,120.72 v1(157.73,118.9)
  BOTTOM w0.254: v1(157.73,118.9) 157.73,118.67 158.13,118.27 U9.19
VCC1V8_FET_SWITCH: length 25.4
  TOP w0.152: L80.1 154,124.69 153.54,125.15 153.54,127.9 v1(153.9,128.25)
  TOP w0.381: v1(152.32,115.57) 152.32,115.57 R1136.1
  BOTTOM w0.152: R1127.2 153.54,127.9 v1(153.9,128.25)
  BOTTOM w0.254: U9.16 155.53,116.94 154.94,117.52 153.62,117.52 153.3,117.85
  BOTTOM w0.305: 153.3,117.85 C1523.2
  BOTTOM w0.381: R1159.2 v1(152.32,115.57) 151.71,116.18 151.71,117.76 152.31,118.36 C1523.2 153.3,118.88 153.94,119.52 155.08,120.66 155.08,123.26
  vias: v1(154.65,126.69) v1(155.1,127.33) v1(155.55,126.69) v1(156.04,127.3) v1(156.59,126.72) v1(157.2,127.19) v1(158.63,127.29) v1(159.48,127.25)
VCC1V8_FPGA: length 388.3
  TOP w0.14: R1171.2 146.32,127.28 146.21,127.17 145.05,127.17 v1(144.84,127.38)
  TOP w0.381: U1.AH28 122.74,70.34 v2(123.24,70.84) ; U1.AD32 v2(119.24,74.84) ; v2(141.24,59.84) U1.BF18 ; U1.AE31 v2(120.24,73.84) ; U1.AG35 v2(122.24,77.84) ; U1.AN17 v2(128.24,58.84) ; U1.AF30 v2(121.24,72.84) ; v1(157.09,19.1) 157.35,18.84 R1018.1 ; U133.2 v1(144.12,24.92) C1304.1 ; U1.BA23 v2(136.24,64.84) ; v2(121.24,70.84) 120.74,70.34 U1.AF28 ; U1.AE29 119.74,71.34 v2(120.24,71.84) ; R1015.1 v1(144.12,19.57) ; R1016.1 v1(142.37,27.09) ; v2(122.24,71.84) 121.74,71.34 U1.AG29 ; U1.U29 111.74,71.34 v2(111.24,71.84) ; C251.1 v1(149.87,99.12) C254.1 ; v1(146.25,108.51) 145.95,108.21 144.62,108.21 144.14,107.73 C161.1 144.14,107.58 144.54,107.18 146.16,107.18 146.2,107.14 v1(146.3,107.14) ; U1.Y28 v2(114.24,70.84) ; v2(116.24,76.84) U1.AB34 ; U1.AD28 118.74,70.34 v2(119.24,70.84) ; v2(117.24,71.84) 117.74,71.34 U1.AC29 ; U1.AC31 v2(117.24,73.84) ; v1(127.48,128.75) 127.33,128.91 125.84,128.91 C171.1 125.59,129.64 v1(127.53,129.64) ; U1.AF32 v2(121.24,74.84) ; 119.74,75.34 v2(120.24,75.84) ; U1.AA29 v2(115.24,71.84) ; U1.AH12 v2(123.24,53.84) ; J100.1 142.41,127.12 ; J100.1 140.54,126.31 ; J100.1 140.8,127.12 ; J100.1 142.41,125.51 ; J100.1 141.61,125.24 ; J100.1 140.8,125.51 ; J100.1 141.61,127.38 ; J100.1 142.58,126.31 143.52,127.25 v1(143.52,128.24) ; v2(129.24,66.84) U1.AP24 ; 117.74,75.34 v2(117.24,75.84) ; v2(115.24,73.84) U1.AA31 ; U1.AF34 v2(121.24,76.84) ; v1(128.34,119.98) 128.77,119.98 129.73,120.94 C247.1 129.73,122.06 129.29,122.5 v1(128.34,122.5) ; R1017.1 156.79,24.68 v1(156.72,24.75) ; v1(64.04,144.15) 65.16,143.03 77.77,143.03 84.87,150.13 166.1,150.13 v1(166.85,149.38) ; v2(116.24,53.84) U1.AB12 ; U1.AB28 v2(116.24,70.84) ; U1.W29 v2(113.24,71.84) ; v1(136.6,128.04) 136.6,126.3 C167.1 135.79,126.33 v1(135.79,127.79) ; v1(154.86,111.07) 154.61,110.82 153.54,110.82 153.23,111.13 C1406.1 153.23,112.02 153.5,112.3 154.44,112.3 v1(154.64,112.09) ; C1303.1 v1(144.12,22.14) ; U1.AD30 v2(119.24,72.84) ; C1466.1 145.8,98.22 v1(145.54,97.97) ; v2(114.24,72.84) U1.Y30 ; U1.AR21 v2(130.24,62.84) ; v2(139.24,66.84) U1.BD24 ; U1.BB20 v2(137.24,61.84) ; v2(116.24,74.84) U1.AB32 ; v2(126.24,64.84) U1.AL23 ; R236.1 v1(219.11,159.73) ; v2(115.24,75.84) 115.74,75.34 ; U1.AW19 v2(134.24,60.84) ; v2(116.24,72.84) U1.AB30 ; v2(127.24,61.84) U1.AM20 ; v2(140.24,62.84) U1.BE21 ; U1.AV22 v2(133.24,63.84) ; U1.AD34 v2(119.24,76.84) ; U1.AT18 v2(131.24,59.84) ; U1.BC17 v2(138.24,58.84)
  05_SIG2 w0.381: v1(145.04,128.24) 145.53,128.24 147.91,130.62 147.91,136.95 148.69,137.73 149.64,137.73 150.29,138.38 150.29,144.2 151.18,145.08 152.97,145.08 157.26,149.38 v1(166.85,149.38) 174.51,157.04 181.41,157.04 189.2,164.82 204.34,164.82 206.03,163.14 212.4,163.14 212.68,162.85 215.01,162.85 215.24,162.62 216.81,162.62 218.59,160.83 218.59,160.25 v1(219.11,159.73)
  07_SIG3 w0.381: J100.1 141.61,127.38 ; J100.1 140.8,127.12 ; J100.1 142.41,125.51 ; J100.1 141.61,125.24 ; J100.1 142.41,127.12 ; J100.1 140.54,126.31 ; J100.1 140.8,125.51 ; J100.1 142.67,126.31
  11_PWR2 w0.381: 140.8,127.12 J100.1 ; J100.1 142.41,125.51 ; J100.1 141.61,127.38 ; J100.1 142.67,126.31 ; J100.1 142.41,127.12 ; J100.1 140.8,125.51 ; J100.1 141.61,125.24 ; J100.1 140.54,126.31
  20_SIG7 w0.381: v1(116.85,30.26) 119.25,30.26 123.12,26.39 123.12,25.67 v1(124,24.79)
  BOTTOM w0.14: R99.2 v1(144.84,127.38)
  BOTTOM w0.191: v2(121.24,76.84) 121.5,76.84 122.02,77.37 127.43,77.37 127.74,77.67 127.74,85.07 128.03,85.36 128.47,85.36 128.72,85.61 128.72,86.05 129,86.33 129.39,86.33 129.74,86.67 129.74,87.07 129.99,87.32 130.53,87.32 130.78,87.57 130.78,88.11 130.98,88.31 131.42,88.31 131.67,88.57 131.67,88.96 137.07,94.36 141.07,94.36 142.81,96.09 142.81,96.9 143.23,97.32 143.23,97.76 143,97.99 Z101.2
  BOTTOM w0.381: C1464.1 151.15,84.4 v1(150.68,84.88) 151.34,85.55 C1570.1 ; v1(125.73,16.92) 123.72,16.92 121.79,18.85 121.79,22.58 v1(124,24.79) 124.1,24.79 v1(124.63,25.33) 124.84,25.54 L13.2 ; v1(157.26,27.26) 157.82,27.26 158.35,26.74 R191.1 ; C1465.1 151,70.92 150.75,71.17 v1(150.75,71.68) 151.13,72.06 C1571.1 ; C249.1 155.32,56.48 v1(154.94,56.87) 154.94,56.87 C250.1 ; R617.1 R618.1 63.25,143.46 63.94,144.15 v1(64.04,144.15) ; v1(150.5,51.51) 150.78,51.8 C252.1 C255.1 ; R1017.1 156.79,24.68 v1(156.72,24.75) 156.66,24.75 156.49,24.92 U43.2 ; C253.1 153.92,62.64 v1(153.42,62.13) R185.1 ; R1291.1 116.79,30.48 116.88,30.38 116.88,30.29 v1(116.85,30.26) ; R215.1 144.1,24.93 v1(144.12,24.92) ; R1019.1 143.51,18.96 v1(144.12,19.57) ; R1293.1 157.1,19.09 v1(157.09,19.1) ; R181.1 v1(153.49,58.08) ; C1303.1 v1(144.12,22.14) ; C1572.1 152.39,54.85 R182.1 v1(153.46,55.08) ; R186.1 v1(153.49,59.13)
  vias: v1(143.52,129) v1(143.86,125.87) v1(144.28,129) v1(144.28,128.24) v1(144.62,125.87) v1(145.04,129) v1(154.43,102.79) v1(155.19,102.79) v1(171.2,63.3) v1(171.2,62.53) v1(171.2,61.77) v3(143.49,130.64) v3(144.35,130.65)
VCC1V8_FPGA_SNS_N: length 42.4
  03_SIG1 w0.135: v1(164.86,115.83) 164.52,115.49 162.12,115.49 159.74,113.11 158.73,113.11 156.12,110.5 151.96,110.5 151.56,110.1 147.97,110.1 146.52,111.55 145.34,111.55 144.37,110.58 144.37,108.64 141.92,106.19 141.92,103.96 142.32,103.56 142.32,102.3 142.15,102.14 142.15,101.61 v1(141.86,101.32)
  BOTTOM w0.104: C1532.2 163.44,115.85 164.84,115.85 v1(164.86,115.83) ; C1532.2 C1446.1 ; C1532.2 163.08,115.62 162.79,115.62 161.97,116.44 U9.26 ; v1(141.86,101.32) 142.17,101.01 142.17,99.79 142.51,99.45 142.51,99.29 Z102.1
VCC1V8_FPGA_SNS_P: length 71.4
  03_SIG1 w0.135: v1(146.87,120.69) 148.72,118.85 148.72,115.93 153.07,111.58 155.11,111.58 155.48,111.95 156.7,111.95 159.62,114.87 160.77,114.87 162.27,116.36 165.12,116.36 165.53,115.95 165.53,115.44 164.87,114.78 v1(164.26,114.78) 164.26,115.13 164.18,115.21 163.67,115.21 163.59,115.12 163.59,114.62 163.42,114.46 163.26,114.46 163.17,114.55 163.17,115.12 163.08,115.21 162.24,115.21 159.85,112.83 158.85,112.83 156.24,110.22 152.07,110.22 151.68,109.82 147.85,109.82 146.4,111.27 145.46,111.27 144.65,110.46 144.65,108.53 142.2,106.08 142.2,104.08 142.6,103.68 142.6,102.19 142.43,102.02 142.43,101.68 v1(142.79,101.32)
  BOTTOM w0.104: Z101.1 142.74,99.29 142.74,99.55 142.4,99.88 142.4,100.94 v1(142.79,101.32) ; U23.8 146.02,121.06 146.39,120.69 v1(146.87,120.69) ; U9.27 162.08,115.94 162.61,115.4 162.61,115.22 162.91,114.92 C1532.1 163.49,115.04 164.01,115.04 v1(164.26,114.78)
VCC1V8_FPGA_VIN: length 9.3
  BOTTOM w0.152: U23.9 146.52,122.54 146.28,122.78 C91.1 146.58,123.61 146.58,123.97 146.35,124.2 144.09,124.2 142.72,125.57 142.72,126.94 143.04,127.26 143.05,127.26 143.47,127.26 R99.1
VCC1V8_PGOOD: length 119.2
  03_SIG1 w0.381: v1(162.05,112.77) 164.62,112.77 165.6,113.76 170.41,113.76 v1(174.45,117.81)
  05_SIG2 w0.381: v1(174.45,117.81) 175.85,117.81 183.1,125.05 189.27,125.05 196.96,132.74 200.41,132.74 201.52,133.86 201.52,137.03 199.67,138.88 199.67,143.37 203.23,146.92 203.85,146.92 v1(205.72,148.79)
  16_SIG5 w0.381: v1(205.72,148.79) 203.56,148.79 203.27,149.08 200.37,149.08 199.15,150.3 198.36,150.3 197.64,151.02 197.64,165.3 194.34,168.61 194.34,171.78 195.11,172.55 205.81,172.55 206.25,172.11 v1(206.25,170.37)
  BOTTOM w0.254: v1(162.05,112.77) 162.05,112.9 161.52,113.44 U9.32 ; U51.4 202.82,148.79 201.72,149.89 RP2.7
  BOTTOM w0.381: D5.1 v1(206.25,170.37) ; U51.4 v1(205.72,148.79)
VCC1V8_TEMPX: length 23.8
  BOTTOM w0.254: Q48.2 151.41,124.01 Q48.1 150.15,124.01 149.96,123.83 149.96,117.9 149.17,117.11 149.17,115.69 154.55,110.31 155.58,110.31 C1539.1 155.84,110.57 156.44,110.57 156.61,110.74 156.61,111.26 157.63,112.28 U9.7
  BOTTOM w0.381: C1539.1 155.83,111.34 v1(155.8,111.37)
VCC1V8_VIN: length 8.7
  BOTTOM w0.152: U23.10 147.02,122.48 147.28,122.75 C91.2 146.98,123.61 146.98,124.14 146.52,124.6 144.26,124.6 143.12,125.73 143.12,126.77 143.21,126.86 143.47,126.86 R100.1
VCC12_MGTAVCC:
  vias: v2(148.07,138.76) v2(148.7,138.76) v2(149.34,138.76) v2(151.76,140.2) v2(153.68,140.94) v2(153.68,140.31) v2(153.68,139.54) v2(153.68,138.91) v2(154.37,139.79) v2(154.39,137.02) v2(154.39,136.13) v2(154.45,142.65) v2(155.01,139.79) v2(155.03,137.02) v2(155.03,136.13) v2(155.21,142.65) v2(155.64,139.79) v2(155.66,137.02) v2(155.66,136.13) v2(155.85,143.35)
VCC12_MGTAVTT:
  vias: v2(181.8,54.46) v2(181.8,53.83) v2(181.8,53.19) v2(184.72,54.46) v2(184.72,53.83) v2(184.72,53.19) v2(185.25,56.83) v2(185.84,62.67) v2(185.84,62.04) v2(185.84,61.4) v2(185.89,56.83) v2(186.21,58.75) v2(186.65,56.83) v2(187.28,56.83) v2(187.52,54.46) v2(187.52,53.7) v2(187.52,53.06) v2(188.66,54.46) v2(188.66,53.7) v2(188.66,53.06)
VCC12_P: length 342.5
  TOP w0.381: 228.3,145.73 J15.1 ; J15.1 231.25,144.48 ; J15.1 231.25,146.98 ; J15.1 228.74,144.48 ; J15.1 230,144.03 ; J15.1 230,147.43 ; J15.1 231.7,145.73 ; J15.1 228.74,146.98 ; 224.5,144.03 J15.4 ; J15.4 225.75,144.48 ; J15.4 225.75,146.98 ; J15.4 226.2,145.73 ; J15.4 222.8,145.73 ; J15.4 223.24,144.48 ; J15.4 224.5,147.43 ; J15.4 223.24,146.98 ; J15.5 226.2,141.53 ; J15.5 222.8,141.53 ; J15.5 225.75,140.28 ; J15.5 223.24,142.78 ; J15.5 223.24,140.28 ; J15.5 225.75,142.78 ; J15.5 224.5,143.23 ; J15.5 224.5,139.83 ; v1(52.02,138.53) 53.86,138.53 55.92,136.48 64.84,136.48 66.31,137.95 66.31,140.17 68.06,141.91 77.98,141.91 85.31,149.25 125.94,149.25 v1(127.41,147.78) ; v1(220.85,155.23) 220.61,154.98 C549.1 ; DS20.2 v1(216.14,153.13)
  03_SIG1 w0.381: 224.5,140.08 J15.5 ; J15.5 223.42,142.6 ; J15.5 225.57,142.6 ; J15.5 223.42,140.45 ; J15.5 224.5,142.98 ; J15.5 225.95,141.53 ; J15.5 223.05,141.53 ; J15.5 225.57,140.45 ; 224.5,144.28 J15.4 ; J15.4 223.42,146.8 ; J15.4 224.5,147.18 ; J15.4 223.05,145.73 ; J15.4 225.95,145.73 ; J15.4 225.57,144.65 ; J15.4 225.57,146.8 ; J15.4 223.42,144.65 ; 230,144.28 J15.1 ; J15.1 231.07,146.8 ; J15.1 228.55,145.73 ; J15.1 231.07,144.65 ; J15.1 230,147.18 ; J15.1 228.92,144.65 ; J15.1 231.45,145.73 ; J15.1 228.92,146.8
  05_SIG2 w0.381: v1(33.54,108.95) 33.54,110.18 36.02,112.65 36.02,119.35 38.73,122.07 38.73,122.99 39.32,123.57 42.11,123.57 46.08,127.53 46.08,130.68 50.39,135 50.39,136.91 v1(52.02,138.53)
  16_SIG5 w0.381: v1(34.44,108.84) 34.33,108.95 v1(33.54,108.95)
  BOTTOM w0.203: U128.1 v1(33.54,108.95)
  BOTTOM w0.381: 223.24,140.28 J15.5 ; J15.5 224.5,139.83 ; J15.5 226.2,141.53 ; J15.5 224.5,143.23 ; J15.5 223.24,142.78 ; J15.5 222.8,141.53 ; J15.5 225.75,142.78 ; J15.5 225.75,140.28 ; J15.1 230,147.43 ; J15.1 228.3,145.73 ; J15.1 230,144.03 ; J15.1 228.74,144.48 ; J15.1 228.74,146.98 ; J15.1 231.7,145.73 ; J15.1 231.25,144.48 ; J15.1 231.25,146.98 ; C859.1 v1(34.44,108.84) ; v1(127.41,147.78) 128.22,148.59 145.41,148.59 148.16,151.34 196.82,151.34 197.84,150.32 197.84,146.66 200.84,143.66 208.71,143.66 212.52,147.47 214.88,147.47 ; J15.4 225.75,144.48 ; J15.4 226.2,145.73 ; J15.4 223.24,144.48 ; J15.4 222.8,145.73 ; J15.4 224.5,147.43 ; J15.4 223.24,146.98 ; J15.4 225.75,146.98 ; J15.4 224.5,144.03 ; U15.5 219.09,153.07 v1(218.77,153.39)
  vias: v1(215.24,149.48) v3(214.71,146.36) v3(214.71,145.22) v3(215.98,146.36) v3(215.98,145.22) v3(217.25,146.36) v3(217.25,145.22) v3(218.52,146.36) v3(218.52,145.22)
VCC12_PCIE: length 19.9
  TOP w0.381: U2.A3 v6(47.65,7.16) ; U2.B1 45.65,5.84 45.9,6.09 45.9,8.23 ; v6(46.65,7.38) U2.A2
  10_GND w0.711: v6(46.65,7.38) U2.A2 ; U2.A3 v6(47.65,7.16)
  vias: v6(47.07,9.94) v6(47.07,8.67) v6(48.22,9.94) v6(48.22,8.67) v6(49.36,9.94) v6(49.36,8.67) v6(50.5,9.94) v6(50.5,8.67) v7(48.64,11.35) v7(51.18,11.35)
VCC12_Q_OUT: length 23.5
  TOP w0.381: 208.38,130.84 U16.1 ; U16.1 209.59,130.84 ; U16.1 208.38,132.06 ; U16.1 210.81,132.06 ; U16.1 208.38,133.28 ; U16.1 210.81,133.28 ; U16.1 209.59,133.28 ; U16.1 210.81,130.84
  BOTTOM w0.381: U16.1 210.81,132.06 ; U16.1 208.38,132.06 ; U16.1 209.59,133.28 ; U16.1 208.38,130.84 ; U16.1 210.81,130.84 ; U16.1 210.81,133.28 ; U16.1 209.59,130.84 ; U16.1 208.38,133.28
  vias: v3(212.65,141.36) v3(212.65,140.09) v3(213.92,141.36) v3(213.92,140.09) v3(215.19,141.36) v3(215.19,140.09) v3(216.46,141.36) v3(216.46,140.09)
VCC12_SW: length 396.2
  TOP w0.254: R14.1 v1(206.34,67.9)
  TOP w0.381: R1216.1 v1(237.74,113.33) ; v1(44.86,129.36) 44.93,129.36 45.63,128.66 45.63,127.42 44.91,126.7 40.3,126.7 C1314.1 ; 136.59,145.96 136.59,145.93 136.06,145.41 v1(136.06,144.35) ; 136.59,145.96 C1633.1 ; 136.59,145.96 137.21,145.34 137.21,144.32 v1(136.78,143.89) ; v1(162.36,119.99) R1111.1 ; J22.L37 v1(61.21,170.94) ; R95.1 v1(186.6,134.14) ; v1(48.77,150.16) 48.77,149.28 48.32,148.83 C1632.1 47.05,148.83 46.74,149.15 v1(46.74,150.16) ; C257.1 176.31,134.2 176.25,134.26 176.25,138.76 175.77,139.24 v1(173.13,139.24) ; v1(205.74,161.34) 206.06,161.66 DS4.2 ; J22.L40 v1(57.4,170.94) ; v1(158.33,106.77) 158.15,106.95 158.15,109.77 158.71,110.34 C1412.1 ; DS27.2 v1(223.6,160.49) ; v1(51.64,123.06) 51.38,123.06 50.9,123.54 R1020.1 ; DS28.2 v1(221.49,160.61) ; v1(195.66,19.4) 195.79,19.53 R1116.1 ; R1113.1 v1(221.9,44.59) ; J22.C35 v1(63.75,160.78) ; J22.L36 v1(62.48,170.94) ; J2.C37 v1(131.22,160.78) ; DS26.2 v1(205.36,142.67) ; C146.1 216.63,67.83 216.69,67.77 216.69,64.29 217.2,63.78 219.53,63.78 v1(219.8,64.06) ; C1413.1 211.62,44.67 211.55,44.73 211.55,48.21 211.05,48.71 208.71,48.71 v1(208.44,48.44) ; DS46.2 v1(219.33,160.61) ; v1(41.71,116.86) R1021.1 ; J22.C37 v1(61.21,160.78) ; J2.C35 v1(133.76,160.78)
  03_SIG1 w0.381: 208.68,137.97 U16.8 ; U16.8 208.38,137.06 ; U16.8 209.59,138.28 ; U16.8 208.68,136.15 ; U16.8 209.59,135.84 ; U16.8 210.51,136.15 ; U16.8 210.51,137.97 ; U16.8 210.81,137.06 ; 199.18,135.86 C499.1 ; C499.1 201.06,135.05 ; C499.1 198.92,135.05 ; C499.1 199.99,136.12 ; C499.1 200.79,135.86 ; 200.61,141.11 J54.1 ; J54.1 202.74,141.11 ; J54.1 200.87,140.3 ; J54.1 200.87,141.91 ; J54.1 201.68,142.17 ; J54.1 202.48,140.3 ; J54.1 201.68,140.04 ; J54.1 202.48,141.91 ; v1(162.36,119.99) 157.67,119.99 156.95,119.28 156.95,118.1 153.27,114.42 152.66,114.42 v1(152.32,114.77)
  07_SIG3 w0.381: J54.1 202.48,140.3 ; J54.1 200.87,140.3 ; J54.1 200.61,141.11 ; J54.1 201.68,142.17 ; J54.1 202.48,141.91 ; J54.1 201.68,140.04 ; J54.1 200.87,141.91 ; J54.1 202.74,141.11 ; 199.18,135.86 C499.1 ; C499.1 200.79,135.86 ; C499.1 200.79,134.25 ; C499.1 201.06,135.05 ; C499.1 199.99,133.98 ; C499.1 199.18,134.25 ; C499.1 198.92,135.05 ; C499.1 199.99,136.12 ; v1(24.31,106.38) 26.52,106.38 29.01,103.89 29.01,95.25 28.11,94.35 28.11,92.42 29.36,91.16 29.36,77.88 26.16,74.68 J36.2
  11_PWR2 w0.381: 237.72,130.12 L92.1 ; L92.1 238.63,130.43 ; L92.1 237.72,128.3 ; L92.1 239.55,130.12 ; L92.1 239.55,128.3 ; L92.1 239.85,129.21 ; L92.1 237.41,129.21 ; L92.1 238.63,127.99 ; 198.92,135.05 C499.1 ; C499.1 200.79,134.25 ; C499.1 201.06,135.05 ; C499.1 200.79,135.86 ; C499.1 199.99,136.12 ; C499.1 199.18,135.86 ; C499.1 199.99,133.98 ; C499.1 199.18,134.25 ; J54.1 202.48,141.91 ; J54.1 200.87,140.3 ; J54.1 201.68,142.17 ; J54.1 202.48,140.3 ; J54.1 200.87,141.91 ; J54.1 201.68,140.04 ; J54.1 202.74,141.11 ; J54.1 200.61,141.11 ; 208.68,137.97 U16.8 ; U16.8 208.68,136.15 ; U16.8 208.38,137.06 ; U16.8 209.59,135.84 ; U16.8 210.51,136.15 ; U16.8 210.51,137.97 ; U16.8 210.81,137.06 ; U16.8 209.59,138.28 ; 173.46,32.34 J73.2 ; J73.2 173.72,33.15 ; J73.2 174.52,31.27 ; J73.2 175.33,33.15 ; J73.2 174.52,33.41 ; J73.2 175.33,31.54 ; J73.2 175.59,32.34 ; J73.2 173.72,31.54
  14_SIG4 w0.381: 199.99,133.98 C499.1 ; C499.1 199.18,134.25 ; C499.1 198.92,135.05 ; C499.1 200.79,135.86 ; C499.1 199.18,135.86 ; C499.1 199.99,136.12 ; C499.1 200.79,134.25 ; C499.1 201.06,135.05 ; 208.68,136.15 U16.8 ; U16.8 209.59,138.28 ; U16.8 208.68,137.97 ; U16.8 210.51,137.97 ; U16.8 210.81,137.06 ; U16.8 208.38,137.06 ; U16.8 209.59,135.84 ; U16.8 210.51,136.15 ; 200.87,141.91 J54.1 ; J54.1 201.68,142.17 ; J54.1 200.61,141.11 ; J54.1 202.74,141.11 ; J54.1 202.48,140.3 ; J54.1 201.68,140.04 ; J54.1 202.48,141.91 ; J54.1 200.87,140.3
  16_SIG5 w0.381: 208.38,137.06 U16.8 ; U16.8 209.59,135.84 ; U16.8 209.59,138.28 ; U16.8 210.81,137.06 ; U16.8 208.68,137.97 ; U16.8 210.51,137.97 ; U16.8 210.51,136.15 ; U16.8 208.68,136.15 ; 199.99,133.98 C499.1 ; C499.1 199.99,136.12 ; C499.1 200.79,135.86 ; C499.1 199.18,134.25 ; C499.1 200.79,134.25 ; C499.1 201.06,135.05 ; C499.1 198.92,135.05 ; C499.1 199.18,135.86 ; J54.1 202.48,140.3 ; J54.1 200.87,141.91 ; J54.1 200.87,140.3 ; J54.1 202.48,141.91 ; J54.1 201.68,140.04 ; J54.1 201.68,142.17 ; J54.1 200.61,141.11 ; J54.1 202.74,141.11
  18_SIG6 w0.381: U16.8 209.59,138.28 ; U16.8 208.68,136.15 ; U16.8 208.38,137.06 ; U16.8 210.51,137.97 ; U16.8 210.51,136.15 ; U16.8 208.68,137.97 ; U16.8 209.59,135.84 ; U16.8 210.81,137.06 ; 200.87,141.91 J54.1 ; J54.1 201.68,142.17 ; J54.1 202.74,141.11 ; J54.1 200.61,141.11 ; J54.1 202.48,140.3 ; J54.1 202.48,141.91 ; J54.1 200.87,140.3 ; J54.1 201.68,140.04 ; C499.1 200.79,135.86 ; C499.1 199.18,135.86 ; C499.1 199.99,133.98 ; C499.1 199.18,134.25 ; C499.1 200.79,134.25 ; C499.1 201.06,135.05 ; C499.1 199.99,136.12 ; C499.1 198.92,135.05 ; v1(41.71,116.86) 35.89,116.86 34.34,115.32 34.34,114.25 32.5,112.41 31.76,112.41 29.97,110.62 29.97,109.73 26.62,106.38 v1(24.31,106.38)
  20_SIG7 w0.381: 209.59,135.84 U16.8 ; U16.8 210.51,136.15 ; U16.8 210.81,137.06 ; U16.8 208.38,137.06 ; U16.8 210.51,137.97 ; U16.8 208.68,137.97 ; U16.8 209.59,138.28 ; U16.8 208.68,136.15 ; C499.1 200.79,135.86 ; C499.1 198.92,135.05 ; C499.1 199.99,136.12 ; C499.1 199.18,135.86 ; C499.1 199.18,134.25 ; C499.1 200.79,134.25 ; C499.1 201.06,135.05 ; C499.1 199.99,133.98 ; J54.1 201.68,142.17 ; J54.1 200.87,141.91 ; J54.1 202.48,141.91 ; J54.1 200.61,141.11 ; J54.1 202.48,140.3 ; J54.1 201.68,140.04 ; J54.1 202.74,141.11 ; J54.1 200.87,140.3
  BOTTOM w0.381: v1(180.59,61.29) 179.67,61.29 179.38,61 C1635.1 ; R1327.1 v1(177.81,34.33) ; R157.1 v1(213.37,58.81) ; R1158.1 152.66,114.42 v1(152.32,114.77) ; C1634.1 L92.1 ; C1648.1 C288.1 60.09,154.49 v1(59.98,154.6) ; C1636.1 146.62,133.01 v1(145.47,134.15) ; C1656.1 v1(133.51,157.11) ; R1075.1 v1(51.64,123.06) ; v1(160.71,108.26) 161,107.98 163.8,107.98 165.28,109.45 165.28,114.83 165.8,115.35 165.8,118.05 166.5,118.74 166.5,120.7 166.12,121.08 163.45,121.08 v1(162.36,119.99) ; C1011.1 v1(131.73,157.11) ; R1218.1 v1(164.86,142.89) ; R1217.1 v1(183.87,47.88) ; R333.1 v1(188.04,33.09) ; R1164.1 v1(189.31,33.09) ; R463.1 v1(179.58,143.22) ; R1160.1 v1(214.68,53.69)
  vias: v1(42.24,130.66) v1(42.82,131.14) v1(43.23,130.56) v1(43.84,131.14) v1(144.15,134.2) v1(144.2,131.87) v1(145.9,131.87) v1(157.77,106.4) v1(159.18,105.76) v1(159.99,108.23) v1(160.57,105.76) v1(171.36,138.48) v1(171.36,137.21) v1(172.12,139.24) v1(174.15,138.23) v1(174.15,137.21) v1(180.59,63.68) v1(180.59,62.92) v1(180.59,62.15) v1(206.66,47.68) v1(206.66,46.41) v1(207.42,48.44) v1(209.58,47.68) v1(209.58,46.66) v1(218.66,65.84) v1(218.66,64.82) v1(220.82,64.06) v1(221.58,66.09) v1(221.58,64.82) v2(220.81,81.05) v2(222.08,81.05) v3(194.06,14.53) v3(194.94,14.53) v3(195.83,14.53) v3(196.72,16.31) v3(196.72,15.42) v3(196.72,14.53)
VCC12_UTIL_3V3:
  vias: v3(181.06,15.57) v3(181.06,14.3) v3(182.07,15.6) v3(182.07,14.33) v3(183.23,15.54) v3(183.23,14.27)
VCC12_VCCINT: length 10
  TOP w0.381: L92.2 224.56,132.66 ; L92.2 222.43,131.75 ; L92.2 223.65,130.53 ; L92.2 222.73,130.84 ; L92.2 224.87,131.75 ; L92.2 222.73,132.66 ; L92.2 224.56,130.84 ; L92.2 223.65,132.97
  vias: v2(214.51,115.53) v2(214.51,105.12) v2(214.51,94.7) v2(214.51,84.3) v2(215.15,115.53) v2(215.15,105.12) v2(215.15,94.7) v2(215.15,84.3) v2(215.78,115.53) v2(215.78,105.12) v2(215.78,94.7) v2(215.78,84.3) v2(220.1,107.9) v2(220.05,106.55) v2(220.05,105.28) v2(220.05,104.01) v2(220.13,96.14) v2(220.13,93.6) v2(220.15,118.23) v2(220.15,116.96) v2(220.15,115.69) v2(220.15,114.45) v2(220.18,113.15) v2(220.18,102.74) v2(220.15,97.41) v2(220.15,94.87) v2(220.18,92.33) v2(220.15,86.99) v2(220.15,85.72) v2(220.15,84.45) v2(220.18,81.91) v2(220.81,118.87) v2(220.81,115.69) v2(220.81,112.52) v2(220.81,108.46) v2(220.81,105.28) v2(220.81,102.11) v2(220.81,98.04) v2(220.81,94.87) v2(220.81,91.69) v2(220.81,87.63) v2(220.81,84.45) v2(221.45,115.69) v2(221.47,94.87) v2(221.45,84.45) v2(221.88,105.33) v2(222.08,118.87) v2(222.08,112.52) v2(222.08,108.46) v2(222.08,102.11) v2(222.08,98.04) v2(222.08,91.69) v2(222.08,87.63)
VCCINT: length 11.6
  TOP w0.178: Z6.1 189.75,111.7 189.75,111.02 190.38,110.39 190.38,103.94 190.74,103.58 R168.1
  TOP w0.381: 199.02,112.81 L95.1 199.32,112.6
VCCINT_A3_IN: length 31.5
  TOP w0.152: v1(237.14,99.79) 236.81,100.11 236.81,100.31 R169.1
  03_SIG1 w0.173: v1(237.14,99.79) 228.94,99.79 v1(226.69,102.03)
  BOTTOM w0.152: 226.27,101.13 226.27,101.21 226.69,101.63 v1(226.69,102.03)
  BOTTOM w0.178: R1225.1 238.54,100.21 238.12,99.79 v1(237.14,99.79) 236.85,100.08 236.85,100.65 236.75,100.75 R1224.1 236.38,100.17 236.19,99.98 234.99,99.98 234.71,100.26 R1223.1 ; C1637.2 226.77,101.13 226.9,100.99 C1691.1 228.38,101.88 R1244.1 228.38,103.36 228.52,103.5 R1272.2 229.11,104.52 229.11,105.95 231.36,108.21 U164.30
VCCINT_FPGA: length 256.4
  TOP w0.178: R168.2 189.78,103.58 190,103.81 190,110.26 189.37,110.9 189.37,111.83 Z7.1
  TOP w0.381: v2(116.24,57.84) 116.74,58.34 U1.AB16 ; v2(116.24,55.84) 116.74,56.34 U1.AB14 ; U1.W25 v2(113.24,67.84) ; v1(85.38,57.24) 85.34,57.2 C919.1 ; U1.AC15 117.74,57.34 v2(117.24,56.84) ; v1(85.34,87.45) 85.32,87.43 C1559.1 ; v2(120.24,56.84) 119.74,57.34 U1.AE15 ; U1.AJ19 v2(124.24,60.84) ; C658.1 85.32,81.08 v1(85.34,81.06) ; U1.U19 v2(111.24,60.84) ; U1.AC21 v2(117.24,62.84) ; U1.AE19 v2(120.24,60.84) ; v2(122.24,67.84) 121.74,67.34 U1.AG25 ; v2(120.24,67.84) 119.74,67.34 U1.AE25 ; U1.AH24 v2(123.24,66.84) ; C1557.1 v1(85.34,79.81) ; v1(107.43,118.76) 108.56,118.76 C911.1 108.57,116.97 v1(107.43,116.97) ; v2(117.24,67.84) 117.74,67.34 U1.AC25 ; U1.AA25 v2(115.24,67.84) ; v1(80.32,86.91) 78.59,86.91 78.3,87.21 C1488.1 78.3,88.33 78.66,88.7 v1(80.32,88.7) ; v2(124.24,56.84) 123.74,57.34 U1.AJ15 ; U1.AG21 v2(122.24,62.84) ; v1(85.34,82.37) 85.32,82.35 C159.1 C1558.1 v1(85.34,83.62) ; v2(114.24,57.84) 114.74,58.34 U1.Y16 ; U1.AA15 115.74,57.34 v2(115.24,56.84) ; v2(125.24,66.84) U1.AK24 ; U1.U21 v2(111.24,62.84) ; v2(125.24,63.84) U1.AK22 ; v1(81.89,72.94) 81.77,72.82 80.19,72.82 79.95,73.06 C1487.1 v1(81.98,73.71) ; U1.AK16 v2(125.24,57.84) ; U1.AG17 121.74,59.34 v2(122.24,58.84) ; U1.AH18 v2(123.24,59.84) ; U1.AD24 v2(119.24,66.84) ; U1.AJ25 123.74,67.34 v2(124.24,67.84) ; v2(116.24,63.84) U1.AB22 ; U1.AJ23 v2(124.24,64.84) ; U1.U25 111.74,67.34 v2(111.24,67.84) ; v2(116.24,66.84) U1.AB24 ; v2(121.24,57.84) 120.74,58.34 U1.AF16 ; U1.AD20 v2(119.24,61.84) ; U1.AF26 120.74,68.34 v2(121.24,68.84) ; U1.AD22 v2(119.24,63.84) ; U1.AH26 122.74,68.34 v2(123.24,68.84) ; U1.AE21 v2(120.24,62.84) ; v2(114.24,63.84) U1.Y22 ; v2(116.24,61.84) U1.AB20 ; v2(125.24,59.84) U1.AK18 ; v2(123.24,57.84) 122.74,58.34 U1.AH16 ; v2(115.24,60.84) U1.AA19 ; U1.AK20 v2(125.24,61.84) ; U1.W17 113.74,59.34 v2(113.24,58.84) ; C657.1 v1(85.34,89.84) ; v2(112.24,66.84) U1.V24 ; U1.AH22 v2(123.24,63.84) ; v2(124.24,58.84) 123.74,59.34 U1.AJ17 ; v2(114.24,61.84) U1.Y20 ; v2(125.24,68.84) 124.74,68.34 U1.AK26 ; v1(85.34,55.93) C1756.1 ; v1(122.38,105.79) 122.38,104.98 C165.1 123.95,104.72 v1(123.95,105.74) ; U1.U23 v2(111.24,64.84) ; v1(83.86,140.68) 83.08,140.68 C460.1 82.57,138.89 v1(83.9,138.89) ; v2(114.24,66.84) U1.Y24 ; U1.AG23 v2(122.24,64.84) ; v2(112.24,61.84) U1.V20 ; U1.AA17 115.74,59.34 v2(115.24,58.84) ; v1(148.79,105.72) 148.95,105.87 148.95,106.89 C206.1 150.39,106.42 v1(150.39,105.77) ; U1.AC23 v2(117.24,64.84) ; v1(108.83,111.76) 108.83,110.87 C462.1 107.04,110.44 v1(107.04,111.76) ; U1.AF18 v2(121.24,59.84) ; U1.AG19 v2(122.24,60.84) ; v2(111.24,58.84) 111.74,59.34 U1.U17 ; C1755.1 116.46,99.27 v1(116.48,99.25) ; U1.AB26 v2(116.24,68.84) ; C659.1 v1(85.34,88.7) ; v2(113.24,62.84) U1.W21 ; U1.V26 v2(112.24,68.84) ; U1.AG15 121.74,57.34 v2(122.24,56.84) ; U1.AE23 v2(120.24,64.84) ; v2(115.24,64.84) U1.AA23 ; v2(112.24,63.84) U1.V22 ; v2(119.24,68.84) 118.74,68.34 U1.AD26 ; U1.AD16 118.74,58.34 v2(119.24,57.84) ; v2(112.24,59.84) U1.V18 ; v2(115.24,62.84) U1.AA21 ; U1.AC19 v2(117.24,60.84) ; v2(114.24,59.84) U1.Y18 ; U1.AF24 v2(121.24,66.84) ; U1.AF20 v2(121.24,61.84) ; U1.AJ21 v2(124.24,62.84) ; U1.AF22 v2(121.24,63.84) ; U1.Y26 v2(114.24,68.84) ; v1(131.22,103.71) 131.22,104.8 C461.1 132.72,105.1 v1(132.72,103.81) ; v2(113.24,64.84) U1.W23 ; U1.AH20 v2(123.24,61.84) ; v2(113.24,60.84) U1.W19
  09_PWR1 w0.381: J107.1 189.91,78.45 ; J107.1 190.17,77.65 ; J107.1 188.04,77.65 ; J107.1 189.1,78.71 ; J107.1 188.3,76.84 ; J107.1 189.91,76.84 ; J107.1 189.1,76.58 ; J107.1 188.3,78.45
  10_GND w0.381: 188.3,78.45 J107.1 ; J107.1 189.1,78.71 ; J107.1 188.3,76.84 ; J107.1 189.91,78.45 ; J107.1 189.91,76.84 ; J107.1 188.04,77.65 ; J107.1 190.17,77.65 ; J107.1 189.1,76.58
  14_SIG4 w0.14: v2(117.24,64.84) 118.03,65.64 118.03,71.49 118.89,72.35 123.03,72.35 123.44,72.35 123.73,72.64 123.73,73.05 124.03,73.35 124.44,73.35 124.73,73.64 124.73,74.02 125.03,74.33 125.42,74.33 125.75,74.66 125.75,75.05 126.03,75.33 129.42,75.33 129.73,75.64 129.73,78.06 129.45,78.34 129.05,78.34 128.73,78.66 128.73,78.97 128.73,78.97 128.73,79.05 128.43,79.35 128.04,79.35 127.75,79.64 127.75,80.18 127.59,80.33 127.05,80.33 126.76,80.62 126.76,80.62 126.75,80.64 126.75,81.18 126.59,81.33 126.06,81.33 126.04,81.35 126.03,81.35 125.75,81.64 125.75,81.64 125.73,81.66 125.73,86.02 125.75,86.04 125.75,86.05 126.03,86.33 126.56,86.33 126.73,86.5 126.73,86.96 127.11,87.34 127.49,87.34 127.7,87.55 127.7,88.11 127.93,88.33 128.58,88.33 128.76,88.51 128.76,89 129.08,89.32 129.49,89.32 130.02,89.84 v2(130.24,89.84)
  18_SIG6 w0.381: 197.44,19.82 J5.1 ; J5.1 197.44,21.43 ; J5.1 197.18,20.62 ; J5.1 198.25,19.56 ; J5.1 198.25,21.69 ; J5.1 199.05,21.43 ; J5.1 199.31,20.62 ; J5.1 199.05,19.82 ; 188.04,77.65 J107.1 ; J107.1 189.1,78.71 ; J107.1 190.17,77.65 ; J107.1 189.91,76.84 ; J107.1 188.3,78.45 ; J107.1 189.91,78.45 ; J107.1 188.3,76.84 ; J107.1 189.1,76.58
  BOTTOM w0.191: v2(130.24,89.84) 130.62,90.23 130.62,92.1 139.42,100.91 139.42,102.76 Z128.2
  BOTTOM w0.305: v1(155.34,82.75) 154.93,82.34 C331.1
  BOTTOM w0.381: v1(116.48,99.25) 116.46,99.27 C1755.1 ; v1(150.96,90.84) 151.8,90.84 C907.1 151.78,89.62 v1(150.96,89.62) ; C923.1 C920.1 151.77,97.47 v1(151.94,97.64) ; v1(157.84,72.42) 157.84,71.1 C916.1 158.9,70.72 158.9,72.19 v1(158.65,72.44) ; v1(159.36,55.71) 160,55.71 C1486.1 160.54,54.9 v1(159.36,54.9) ; v1(150.75,80.82) 151,81.08 C1455.1 ; v1(181.88,120.48) 181.23,120.48 180.58,121.13 C163.1 180.58,121.31 181.25,121.98 v1(181.82,121.98) ; C334.1 150.83,73.15 v1(150.75,73.08) ; v1(183.11,76.71) 183.11,75.7 C918.1 182.02,75.86 v1(182.02,76.76) ; v1(122.38,105.79) 122.38,104.98 C165.1 123.95,104.72 v1(123.95,105.74) ; v1(114.93,99.25) 114.93,99.25 C921.1 ; v1(174.4,122.55) 173.45,122.55 172.45,121.55 C153.1 172.45,121.23 173.59,120.09 v1(174.41,120.09) ; v1(155.34,82.75) C908.1 156.21,83.38 v1(156.21,82.73) ; 170.38,66.29 v1(170.38,65.18) 170.38,64.5 C914.1 168.99,64.47 v1(168.99,65.18) 168.99,66.31 C909.1 170.38,66.29 ; 169.04,76.87 v1(169.04,77.52) 169.04,78.17 C906.1 170.18,78.3 v1(170.18,77.52) 170.18,76.74 C917.1 169.04,76.87
  vias: v1(194.28,76.31) v1(194.28,75.3) v1(194.28,74.28) v3(178.83,118.03) v3(178.83,115.24) v3(179.21,109.65) v3(179.21,107.49) v3(179.21,105.21) v3(179.21,98.98) v3(179.21,96.95) v3(179.21,94.92) v3(179.84,116) v3(180.35,110.79) v3(180.35,108.51) v3(180.35,106.35) v3(180.35,104.19) v3(180.35,100) v3(180.35,97.97) v3(180.35,95.94) v3(180.35,93.9) v3(180.35,91.87) v3(180.35,89.84) v3(180.35,87.81) v3(180.35,85.78) v3(180.35,83.74) v3(180.86,117.02) v3(180.86,115.24) v3(181.49,109.65) v3(181.49,107.49) v3(181.49,105.21) v3(181.49,98.98) v3(181.49,96.95) v3(181.49,94.92) v3(181.49,92.89) v3(181.49,90.86) v3(181.49,88.82) v3(181.49,86.79) v3(181.49,84.76) v3(182.64,115.37) v3(182.64,110.79) v3(182.64,108.51) v3(182.64,106.35) v3(182.64,104.19) v3(182.64,100) v3(182.64,97.97) v3(182.64,95.94) v3(182.64,93.9) v3(182.64,91.87) v3(182.64,89.84) v3(182.64,87.81) v3(182.64,85.78) v3(182.64,83.74) v3(183.78,115.37) v3(183.78,109.65) v3(183.78,107.49) v3(183.78,105.21) v3(183.78,98.98) v3(183.78,96.95) v3(183.78,94.92) v3(183.78,92.89) v3(183.78,90.86) v3(183.78,88.82) v3(183.78,86.79) v3(183.78,84.76) v3(184.92,115.37) v3(184.92,110.79) v3(184.92,108.51) v3(184.92,106.35) v3(184.92,104.19) v3(184.92,102.03) v3(184.92,100) v3(184.92,97.97) v3(184.92,95.94) v3(184.92,93.9) v3(184.92,91.87) v3(184.92,89.84) v3(184.92,87.81) v3(184.92,85.78) v3(184.92,83.74) v3(186.07,115.37) v3(186.07,109.65) v3(186.07,107.49) v3(186.07,105.21) v3(186.07,103.05) v3(186.07,101.02) v3(186.07,98.98) v3(186.07,96.95) v3(186.07,94.92) v3(186.07,92.89) v3(186.07,90.86) v3(186.07,88.82) v3(186.07,86.79) v3(186.07,84.76) v3(187.21,110.79) v3(187.21,108.51) v3(187.21,93.9) v3(187.21,89.84) v3(187.21,87.81) v3(187.21,85.78) v3(188.35,110.79) v3(188.35,109.65) v3(188.35,107.49) v3(188.35,98.98) v3(188.35,94.92) v3(188.35,93.14) v3(188.35,88.82) v3(188.35,86.79) v3(189.5,93.9) v3(189.5,89.84) v3(189.5,87.81) v3(189.5,85.78)
