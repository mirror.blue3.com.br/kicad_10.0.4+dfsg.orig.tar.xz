# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFP1_RX2_N: length 76.4
  TOP w0.104: U145.21 52.91,19.43 arc(53,19.45) 53.09,19.51 53.24,19.66 arc(53.32,19.72) 53.42,19.74 53.56,19.74 arc(53.63,19.73) 53.69,19.71 arc(53.74,19.69) 53.78,19.65 54.05,19.38 arc(54.19,19.29) 54.35,19.26 54.84,19.26 arc(55.02,19.22) 55.17,19.12 55.35,18.94 arc(55.41,18.9) 55.48,18.89 56.35,18.89 arc(56.46,18.91) v9(56.55,18.97)
  TOP w0.114: U1.W3 113.74,45.34 v2(113.24,44.84)
  05_SIG2 w0.109: 112.96,42.35 112.96,42.37 arc(112.88,42.49) 112.85,42.63 112.85,44.97 arc(112.93,45.16) 113.12,45.24 113.13,45.24 arc(113.2,45.21) 113.24,45.13 v2(113.24,44.84)
  05_SIG2 w0.152: 112.96,42.35 112.96,41.67 112.96,41.64 112.97,41.63 arc(112.99,41.4) 112.99,41.17 arc(112.99,40.95) 112.97,40.74 arc(112.97,40.74) 112.97,40.74 112.89,40.12 arc(112.79,39.54) 112.62,38.97 112.6,38.9 arc(112.09,37.85) 111.36,36.94 108.73,34.31 arc(108.54,34.18) 108.31,34.13 arc(108.24,34.12) 108.18,34.08 106.56,32.46 arc(106.04,32.11) 105.43,31.99 101.36,31.99 arc(100.79,31.88) 100.31,31.56 arc(99.5,31.02) 98.54,30.83 97.75,30.83 arc(97.38,30.75) 97.07,30.54 94.09,27.56 arc(93.3,26.92) 92.4,26.44 arc(91.43,26.14) 90.41,26.04 84.72,26.04 arc(83.69,25.84) 82.82,25.25 79.62,22.05 arc(78.21,21.11) 76.56,20.78 74.21,20.78 arc(73.82,20.71) 73.49,20.49 72.74,19.74 arc(71.95,19.21) 71.02,19.03 58.15,19.03 arc(58.14,19.02) 58.12,19.02 58.1,19.02 arc(57.98,19) 57.88,18.93 arc(57.78,18.87) 57.67,18.85 56.85,18.85 arc(56.69,18.88) v9(56.55,18.97)
QSFP1_RX2_P: length 76.3
  TOP w0.104: U145.22 52.79,20.23 arc(52.93,20.2) 53.05,20.12 53.12,20.05 arc(53.22,19.99) 53.34,19.96 53.56,19.96 arc(53.67,19.95) 53.78,19.92 arc(53.86,19.88) 53.94,19.82 54.21,19.55 arc(54.27,19.5) 54.35,19.49 54.88,19.49 arc(54.99,19.51) 55.09,19.57 55.29,19.77 arc(55.39,19.84) 55.52,19.87 56.32,19.87 arc(56.44,19.84) v9(56.55,19.77)
  TOP w0.114: U1.W4 113.74,46.34 v2(113.24,45.84)
  05_SIG2 w0.109: v2(113.24,45.84) 113.24,45.55 arc(113.2,45.48) 113.13,45.44 113.12,45.44 arc(112.79,45.31) 112.65,44.97 112.65,42.52 arc(112.63,42.43) 112.58,42.35
  05_SIG2 w0.152: 112.58,42.35 112.58,41.66 112.59,41.48 112.6,41.46 arc(112.61,41.31) 112.61,41.17 arc(112.61,40.97) 112.59,40.78 112.51,40.16 arc(112.42,39.63) 112.26,39.1 112.24,39.03 arc(111.76,38.05) 111.09,37.2 108.46,34.58 arc(108.39,34.53) 108.31,34.51 arc(108.09,34.47) 107.91,34.35 106.29,32.73 arc(105.9,32.47) 105.43,32.37 101.36,32.37 arc(100.64,32.23) 100.04,31.83 arc(99.35,31.37) 98.54,31.21 97.75,31.21 arc(97.24,31.1) 96.8,30.81 93.82,27.83 arc(93.09,27.23) 92.26,26.79 arc(91.35,26.51) 90.41,26.42 84.72,26.42 arc(83.55,26.19) 82.55,25.52 79.35,22.32 arc(78.07,21.47) 76.56,21.17 74.21,21.17 arc(73.67,21.06) 73.22,20.76 72.47,20.01 arc(71.8,19.56) 71.02,19.41 58.14,19.41 arc(58.13,19.41) 58.11,19.41 arc(58.03,19.44) 57.97,19.51 arc(57.94,19.59) 57.94,19.68 arc(57.91,19.78) 57.82,19.85 57.71,19.87 arc(57.66,19.88) 57.62,19.88 56.81,19.88 arc(56.67,19.85) v9(56.55,19.77)
QSFP1_RX3_N: length 82.3
  TOP w0.104: U145.15 48.55,21.43 arc(48.49,21.44) 48.43,21.48 48.23,21.69 arc(48.21,21.7) 48.2,21.71 arc(48.2,21.71) 48.2,21.71 arc(48.17,21.72) 48.14,21.73 arc(48.13,21.73) 48.12,21.73 48.08,21.73 arc(48.07,21.73) 48.05,21.73 arc(48,21.71) 47.95,21.68 47.59,21.31 arc(47.5,21.25) 47.39,21.23 46.76,21.23 arc(46.6,21.26) 46.46,21.35 v9(46.38,21.43)
  TOP w0.114: U1.V1 112.74,43.34 v2(112.24,42.84)
  05_SIG2 w0.109: v2(112.24,42.84) 112.24,43.13 arc(112.2,43.21) 112.13,43.24 111.95,43.24 arc(111.88,43.21) 111.84,43.13 111.84,41.93 arc(111.87,41.82) 111.93,41.72 111.93,41.7
  05_SIG2 w0.152: 111.93,41.7 111.93,41.24 arc(111.85,40.83) 111.62,40.48 111.61,40.47 111.58,40.43 arc(111.45,40.24) 111.41,40.03 111.41,39.77 arc(111.2,38.74) 110.62,37.87 108.28,35.52 arc(107.82,35.22) 107.28,35.11 arc(107.01,35.06) 106.78,34.9 106.03,34.15 arc(105.25,33.63) 104.33,33.45 100.96,33.45 arc(100.5,33.36) 100.12,33.1 99.65,32.63 arc(98.95,32.17) 98.12,32 97.08,32 arc(96.48,31.88) 95.97,31.54 93.73,29.31 arc(92.95,28.78) 92.02,28.59 82.83,28.59 arc(82.52,28.53) 82.26,28.36 82.25,28.35 arc(81.76,28.02) 81.18,27.91 67.92,27.91 arc(67.45,27.81) 67.05,27.55 61.07,21.57 arc(59.92,20.8) 58.56,20.53 53.21,20.53 arc(52.9,20.59) 52.64,20.76 arc(52.57,20.81) 52.48,20.83 51.18,20.83 arc(51.16,20.82) 51.15,20.81 arc(50.83,20.6) 50.46,20.53 48.77,20.53 arc(48.26,20.73) 48.06,21.24 48.06,21.48 arc(48.01,21.59) 47.91,21.63 arc(47.82,21.61) 47.75,21.56 47.62,21.43 arc(47,21.18) v9(46.38,21.43)
QSFP1_RX3_P: length 82.4
  TOP w0.104: v9(46.38,22.23) 46.5,22.35 arc(46.6,22.41) 46.71,22.44 47.38,22.44 arc(47.49,22.41) 47.59,22.35 47.95,21.99 arc(47.98,21.97) 48.02,21.96 48.18,21.96 arc(48.22,21.96) 48.24,21.98 48.45,22.19 arc(48.5,22.22) 48.55,22.23 U145.14
  TOP w0.114: v2(112.24,43.84) 112.74,44.34 U1.V2
  05_SIG2 w0.109: v2(112.24,43.84) 112.24,43.55 arc(112.2,43.48) 112.13,43.44 111.95,43.44 arc(111.73,43.35) 111.64,43.13 111.64,41.94 arc(111.62,41.82) 111.55,41.72
  05_SIG2 w0.152: 111.55,41.72 111.55,41.24 arc(111.5,40.97) 111.35,40.74 111.34,40.73 111.31,40.7 arc(111.1,40.39) 111.03,40.03 111.03,39.77 arc(110.85,38.88) 110.35,38.14 108.01,35.79 arc(107.67,35.57) 107.28,35.49 arc(106.86,35.41) 106.51,35.17 105.76,34.42 arc(105.11,33.98) 104.33,33.83 100.96,33.83 arc(100.36,33.71) 99.85,33.37 99.38,32.9 arc(98.8,32.52) 98.12,32.38 97.08,32.38 arc(96.33,32.23) 95.7,31.81 93.46,29.58 arc(92.8,29.13) 92.02,28.98 82.83,28.98 arc(82.37,28.89) 81.99,28.63 81.98,28.62 arc(81.61,28.38) 81.18,28.29 67.92,28.29 arc(67.31,28.17) 66.78,27.82 60.8,21.84 arc(59.78,21.15) 58.56,20.91 54.92,20.91 arc(54.83,20.94) 54.8,21.02 arc(54.76,21.13) 54.66,21.17 54.34,21.17 arc(54.23,21.13) 54.19,21.02 arc(54.16,20.94) 54.07,20.91 53.21,20.91 arc(53.04,20.94) 52.91,21.03 arc(52.71,21.16) 52.48,21.21 51.18,21.21 arc(51.02,21.18) 50.88,21.08 arc(50.68,20.95) 50.46,20.91 48.77,20.91 arc(48.53,21) 48.44,21.24 48.44,21.57 arc(48.31,21.88) 48,22.01 arc(47.83,22.04) 47.69,22.14 47.59,22.23 arc(46.99,22.48) v9(46.38,22.23)
QSFP1_RX4_N: length 73.1
  TOP w0.104: U145.24 52.92,21.83 arc(52.97,21.84) 53.01,21.87 53.23,22.09 arc(53.32,22.15) 53.43,22.17 53.95,22.17 arc(54.13,22.14) 54.28,22.04 arc(54.42,21.94) 54.58,21.91 54.84,21.91 arc(55.02,21.88) 55.17,21.78 55.35,21.6 arc(55.41,21.56) 55.48,21.54 56.35,21.54 arc(56.46,21.56) v9(56.55,21.63)
  TOP w0.114: v2(111.24,44.84) 111.74,45.34 U1.U3
  05_SIG2 w0.109: v2(111.24,44.84) 111.24,45.13 arc(111.2,45.21) 111.13,45.24 110.99,45.24 arc(110.89,45.2) 110.85,45.1 110.85,42.47 arc(110.88,42.34) 110.96,42.22
  05_SIG2 w0.152: 110.96,42.22 110.96,42 arc(110.83,41.38) 110.48,40.85 110.45,40.82 arc(110.31,40.61) 110.24,40.37 arc(110.24,40.33) 110.24,40.3 arc(110.04,39.32) 109.48,38.48 109.07,38.07 arc(105.44,35.64) 101.15,34.79 98.24,34.79 arc(95.97,34.34) 94.05,33.05 92.84,31.84 arc(90.57,30.33) 87.89,29.79 82.34,29.79 arc(81.92,29.71) 81.56,29.47 81.45,29.36 arc(81.18,29.18) 80.86,29.11 67.14,29.11 arc(66.48,28.98) 65.92,28.61 64.63,27.32 arc(63.46,26.54) 62.08,26.26 arc(61.59,26.16) 61.18,25.89 60.01,24.72 arc(59.82,24.46) 59.71,24.15 59.71,22.82 arc(59.65,22.52) 59.49,22.28 59.25,22.04 arc(59.07,21.92) 58.85,21.87 58.04,21.87 arc(57.99,21.86) 57.95,21.83 arc(57.89,21.76) 57.83,21.69 57.83,21.69 arc(57.64,21.56) 57.41,21.52 56.81,21.52 arc(56.67,21.55) v9(56.55,21.63)
QSFP1_RX4_P: length 73.1
  TOP w0.104: U145.25 52.94,22.63 arc(53,22.62) 53.06,22.58 53.15,22.49 arc(53.25,22.43) 53.37,22.4 53.95,22.4 arc(54.22,22.35) 54.44,22.2 arc(54.51,22.16) 54.58,22.14 54.88,22.14 arc(55.03,22.17) 55.16,22.26 55.29,22.39 arc(55.42,22.48) 55.59,22.51 56.35,22.51 arc(56.46,22.49) v9(56.55,22.43)
  TOP w0.114: v2(111.24,45.84) 111.74,46.34 U1.U4
  05_SIG2 w0.109: v2(111.24,45.84) 111.24,45.55 arc(111.2,45.48) 111.13,45.44 110.99,45.44 arc(110.75,45.34) 110.65,45.1 110.65,42.44 arc(110.63,42.34) 110.58,42.26
  05_SIG2 w0.152: 110.58,42.26 110.58,42 arc(110.48,41.52) 110.21,41.12 110.18,41.09 arc(109.96,40.78) 109.86,40.4 arc(109.86,40.35) 109.85,40.3 arc(109.69,39.46) 109.21,38.75 108.8,38.34 arc(105.29,35.99) 101.15,35.17 98.24,35.17 arc(95.83,34.69) 93.78,33.32 92.57,32.11 arc(90.43,30.68) 87.89,30.17 82.34,30.17 arc(81.77,30.06) 81.29,29.74 81.18,29.63 arc(81.03,29.53) 80.86,29.49 67.14,29.49 arc(66.33,29.33) 65.65,28.88 64.36,27.59 arc(63.31,26.89) 62.08,26.64 arc(61.45,26.52) 60.92,26.16 59.74,24.99 arc(59.48,24.63) 59.34,24.22 arc(59.33,24.2) 59.33,24.19 arc(59.33,24.18) 59.33,24.17 59.33,23.95 arc(59.31,23.88) 59.26,23.82 arc(59.22,23.81) 59.18,23.8 59.16,23.8 arc(59.05,23.76) 59.01,23.65 59.01,23.35 arc(59.05,23.24) 59.16,23.19 arc(59.2,23.19) 59.25,23.17 arc(59.31,23.11) 59.33,23.02 59.33,22.82 arc(59.3,22.67) 59.22,22.55 58.98,22.31 arc(58.92,22.27) 58.85,22.25 58.32,22.25 arc(58.19,22.28) 58.09,22.35 arc(57.83,22.52) 57.53,22.58 56.92,22.58 arc(56.72,22.54) v9(56.55,22.43)
QSFP1_TX1_N: length 74.6
  TOP w0.104: U145.37 52.86,32.23 arc(52.93,32.22) 52.98,32.18 53.21,31.96 arc(53.27,31.92) 53.34,31.9 53.6,31.9 arc(53.68,31.92) 53.76,31.97 arc(53.88,32.05) 54.03,32.08 55.11,32.08 arc(55.37,32.03) 55.59,31.88 55.66,31.82 arc(55.77,31.74) 55.91,31.71 55.96,31.71 arc(56,31.72) 56.03,31.74 56.3,32.02 arc(56.36,32.05) 56.43,32.07 57.33,32.07 arc(57.44,32.05) v9(57.54,31.98)
  TOP w0.114: v2(112.24,47.84) U1.V6
  03_SIG1 w0.109: v2(112.24,47.84) 112.24,48.03 arc(112.3,48.18) 112.45,48.24 arc(112.58,48.19) 112.63,48.06 112.63,42.48 arc(112.61,42.34) 112.53,42.22
  03_SIG1 w0.152: v9(57.54,31.98) 57.61,32.06 arc(57.75,32.15) 57.93,32.19 58.48,32.19 arc(58.6,32.16) 58.71,32.09 58.9,31.9 arc(59,31.83) 59.1,31.81 59.68,31.81 arc(59.97,31.93) 60.09,32.22 arc(60.21,32.51) 60.5,32.63 60.6,32.63 arc(60.89,32.51) 61.01,32.22 arc(61.13,31.93) 61.41,31.81 63.07,31.81 arc(65.24,31.38) 67.08,30.15 arc(67.69,29.75) 68.4,29.61 81.31,29.61 arc(81.95,29.73) 82.5,30.1 82.7,30.3 arc(83.87,31.08) 85.25,31.36 87.13,31.36 arc(88.55,31.64) 89.76,32.45 90.97,33.65 arc(92.76,34.85) 94.87,35.27 104.32,35.27 arc(105.63,35.53) 106.73,36.27 112.42,41.96 arc(112.5,42.08) 112.53,42.22
QSFP1_TX1_P: length 74.6
  TOP w0.104: U145.36 52.9,31.43 arc(53.01,31.46) 53.11,31.52 53.21,31.62 arc(53.27,31.66) 53.34,31.67 53.6,31.67 arc(53.77,31.71) 53.92,31.8 arc(53.97,31.84) 54.03,31.85 55.11,31.85 arc(55.29,31.82) 55.43,31.72 55.51,31.64 arc(55.68,31.52) 55.88,31.48 55.9,31.48 arc(56,31.46) 56.08,31.41 56.34,31.15 arc(56.4,31.11) 56.47,31.1 57.33,31.1 arc(57.44,31.12) v9(57.54,31.18)
  TOP w0.114: v2(112.24,48.84) U1.V7
  03_SIG1 w0.109: v2(112.24,48.84) 112.24,48.55 arc(112.27,48.48) 112.35,48.44 112.45,48.44 arc(112.72,48.33) 112.84,48.06 112.84,42.39 arc(112.86,42.3) 112.91,42.22
  03_SIG1 w0.152: v9(57.54,31.18) 57.58,31.14 arc(57.76,31.02) 57.97,30.98 58.34,30.98 arc(58.55,31.02) 58.72,31.14 58.96,31.37 arc(58.96,31.37) 58.96,31.38 arc(59.03,31.42) 59.1,31.43 63.07,31.43 arc(65.1,31.03) 66.81,29.88 arc(67.54,29.4) 68.4,29.22 81.31,29.22 arc(82.1,29.38) 82.77,29.83 82.97,30.03 arc(84.02,30.73) 85.25,30.98 87.13,30.98 arc(88.7,31.29) 90.03,32.18 91.24,33.38 arc(92.91,34.5) 94.87,34.89 104.32,34.89 arc(105.77,35.18) 107,36 112.69,41.69 arc(112.85,41.93) 112.91,42.22
QSFP1_TX2_N: length 82.4
  TOP w0.104: U145.2 48.55,31.83 arc(48.5,31.82) 48.45,31.79 48.24,31.58 arc(48.22,31.56) 48.18,31.56 48.02,31.56 arc(47.98,31.57) 47.95,31.59 47.59,31.95 arc(47.49,32.01) 47.38,32.04 46.71,32.04 arc(46.6,32.01) 46.5,31.95 v9(46.38,31.83)
  TOP w0.114: v2(110.24,47.84) U1.T6
  03_SIG1 w0.109: 110.55,42.22 110.55,42.25 110.64,42.34 110.64,48.06 arc(110.58,48.19) 110.46,48.24 110.35,48.24 arc(110.27,48.21) 110.24,48.13 v2(110.24,47.84)
  03_SIG1 w0.152: 110.55,42.22 110.55,41.88 arc(110.53,41.78) 110.47,41.7 106.3,37.53 arc(105.23,36.81) 103.96,36.56 93.84,36.56 arc(92.29,36.25) 90.98,35.37 89.59,33.98 arc(89.06,33.63) 88.43,33.5 85.3,33.5 arc(84.61,33.37) 84.02,32.97 arc(82.33,31.84) 80.33,31.44 68.83,31.44 arc(67.81,31.65) 66.93,32.23 66.1,33.06 arc(64.84,33.91) 63.34,34.21 54.63,34.21 arc(54.43,34.29) 54.35,34.48 54.35,34.63 arc(54.27,34.83) 54.08,34.91 53.71,34.91 arc(53.52,34.83) 53.44,34.63 53.44,34.48 arc(53.36,34.29) 53.16,34.21 50.67,34.21 arc(50.01,34.07) 49.46,33.7 48.28,32.52 arc(48.12,32.29) 48.06,32.01 48.06,31.75 arc(48.02,31.63) 47.9,31.58 47.87,31.58 arc(47.83,31.59) 47.8,31.61 47.8,31.61 arc(47.73,31.67) 47.66,31.74 47.61,31.79 arc(47.4,31.93) 47.16,31.98 46.74,31.98 arc(46.55,31.94) v9(46.38,31.83)
QSFP1_TX2_P: length 82.3
  TOP w0.104: U145.3 48.55,31.03 arc(48.49,31.04) 48.43,31.08 48.23,31.29 arc(48.21,31.3) 48.2,31.31 arc(48.2,31.31) 48.2,31.31 arc(48.17,31.32) 48.14,31.33 arc(48.13,31.33) 48.12,31.33 48.08,31.33 arc(48.07,31.33) 48.05,31.33 arc(48,31.31) 47.95,31.28 47.59,30.91 arc(47.5,30.85) 47.39,30.83 46.76,30.83 arc(46.6,30.86) 46.46,30.95 v9(46.38,31.03)
  TOP w0.114: v2(110.24,48.84) U1.T7
  03_SIG1 w0.109: 110.93,42.22 110.93,42.25 110.84,42.34 110.84,48.06 arc(110.73,48.33) 110.46,48.44 110.35,48.44 arc(110.27,48.48) 110.24,48.55 v2(110.24,48.84)
  03_SIG1 w0.152: 110.93,42.22 110.93,41.88 arc(110.88,41.63) 110.74,41.43 106.57,37.26 arc(105.37,36.46) 103.96,36.18 93.84,36.18 arc(92.44,35.9) 91.25,35.1 89.86,33.71 arc(89.2,33.28) 88.43,33.12 85.3,33.12 arc(84.75,33.01) 84.29,32.7 arc(82.47,31.49) 80.33,31.06 68.83,31.06 arc(67.66,31.3) 66.66,31.96 65.84,32.79 arc(64.69,33.56) 63.34,33.82 50.67,33.82 arc(50.16,33.72) 49.73,33.43 48.55,32.26 arc(48.47,32.14) 48.45,32.01 48.45,31.78 arc(48.28,31.37) 47.87,31.2 47.85,31.2 arc(47.77,31.19) 47.7,31.14 47.54,30.98 arc(47.42,30.9) 47.28,30.87 46.77,30.87 arc(46.56,30.91) v9(46.38,31.03)
QSFP1_TX3_N: length 82.6
  TOP w0.104: U145.34 52.76,29.83 arc(52.91,29.8) 53.04,29.72 53.1,29.65 arc(53.18,29.59) 53.27,29.56 arc(53.33,29.56) 53.39,29.57 54.09,29.57 arc(54.16,29.55) 54.23,29.51 54.24,29.5 arc(54.28,29.47) 54.33,29.46 54.34,29.46 arc(54.34,29.46) 54.35,29.46 55.27,29.46 55.27,29.46 arc(55.39,29.48) 55.48,29.54 55.71,29.77 arc(55.77,29.81) 55.84,29.83 56.74,29.83 arc(56.85,29.81) v9(56.95,29.74)
  TOP w0.114: v2(108.24,47.84) U1.P6
  03_SIG1 w0.109: v2(108.24,47.84) 108.24,48.13 arc(108.27,48.21) 108.35,48.24 108.46,48.24 arc(108.73,48.35) 108.84,48.62 108.84,49.01 arc(108.91,49.17) 109.07,49.24 113.4,49.24 arc(113.57,49.17) 113.64,49 113.64,42.51 arc(113.61,42.39) 113.54,42.28
  03_SIG1 w0.152: 113.54,42.28 113.54,41.88 arc(113.46,41.46) 113.22,41.11 107.54,35.43 arc(106.05,34.43) 104.28,34.08 95.34,34.08 arc(94.57,33.93) 93.93,33.49 93.41,32.98 arc(90.28,30.89) 86.58,30.15 85.81,30.15 arc(84.35,29.86) 83.11,29.03 arc(82.41,28.57) 81.59,28.4 68.09,28.4 arc(66.97,28.62) 66.01,29.26 arc(65.37,29.69) 64.6,29.84 62.76,29.84 arc(62.45,29.78) 62.19,29.61 arc(62.12,29.56) 62.04,29.55 61.66,29.55 arc(61.49,29.61) 61.43,29.78 arc(61.36,29.94) 61.19,30.01 60.74,30.01 arc(60.58,29.94) 60.51,29.78 arc(60.44,29.61) 60.28,29.55 59.93,29.55 arc(59.88,29.57) 59.85,29.62 arc(59.83,29.68) 59.78,29.7 59.02,29.7 arc(58.96,29.68) 58.94,29.62 arc(58.92,29.57) 58.86,29.55 58.51,29.55 arc(58.45,29.56) 58.39,29.59 58.01,29.97 arc(57.92,30.04) 57.8,30.06 57.46,30.06 arc(57.28,30.02) 57.12,29.92 v9(56.95,29.74)
QSFP1_TX3_P: length 82.7
  TOP w0.104: U145.33 52.74,29.03 arc(52.87,29.06) 52.98,29.13 53.05,29.2 arc(53.17,29.28) 53.3,29.33 arc(53.34,29.34) 53.39,29.34 54,29.34 arc(54.07,29.32) 54.13,29.28 54.14,29.28 arc(54.19,29.24) 54.25,29.23 54.35,29.23 arc(54.35,29.23) 54.35,29.23 55.26,29.23 arc(55.43,29.19) 55.56,29.09 55.75,28.91 arc(55.81,28.87) 55.88,28.86 56.74,28.86 arc(56.85,28.88) v9(56.95,28.94)
  TOP w0.114: v2(108.24,48.84) U1.P7
  03_SIG1 w0.109: v2(108.24,48.84) 108.24,48.55 arc(108.27,48.48) 108.35,48.44 108.46,48.44 arc(108.58,48.5) 108.63,48.62 108.63,49.01 arc(108.76,49.32) 109.07,49.44 113.4,49.44 arc(113.71,49.31) 113.84,49 113.84,42.48 arc(113.86,42.37) 113.92,42.28
  03_SIG1 w0.152: 113.92,42.28 113.92,41.88 arc(113.81,41.32) 113.49,40.84 107.81,35.16 arc(106.19,34.08) 104.28,33.7 95.34,33.7 arc(94.72,33.57) 94.2,33.22 93.68,32.71 arc(90.42,30.53) 86.58,29.77 85.81,29.77 arc(84.49,29.51) 83.38,28.76 arc(82.56,28.21) 81.59,28.02 68.09,28.02 arc(66.82,28.27) 65.75,28.99 arc(65.22,29.34) 64.6,29.46 62.76,29.46 arc(62.6,29.43) 62.46,29.34 arc(62.26,29.21) 62.04,29.16 58.51,29.16 arc(58.49,29.16) 58.47,29.15 58.27,28.95 arc(58.11,28.84) 57.92,28.81 57.28,28.81 arc(57.1,28.84) v9(56.95,28.94)
QSFP1_TX4_N: length 95.9
  TOP w0.104: v9(46.38,29.43) 46.5,29.55 arc(46.6,29.61) 46.71,29.64 47.38,29.64 arc(47.49,29.61) 47.59,29.55 47.95,29.19 arc(47.98,29.17) 48.02,29.16 48.18,29.16 arc(48.22,29.16) 48.24,29.18 48.45,29.39 arc(48.5,29.42) 48.55,29.43 U145.5
  TOP w0.114: v2(106.24,47.84) U1.M6
  03_SIG1 w0.109: v2(106.24,47.84) 106.24,48.13 arc(106.21,48.21) 106.13,48.24 106.02,48.24 arc(105.75,48.35) 105.64,48.62 105.64,49.08 arc(105.74,49.34) 106,49.44 107.4,49.44 arc(107.71,49.31) 107.84,49 107.84,42.49 arc(107.84,42.48) 107.84,42.47 108.01,42.3 arc(108.11,42.15) 108.15,41.98 108.15,41.88 arc(108.17,41.76) 108.24,41.66 108.24,41.65
  03_SIG1 w0.152: 108.24,41.65 108.24,40.89 arc(108.19,40.62) 108.03,40.39 106.04,38.4 arc(104.98,37.69) 103.72,37.44 88.13,37.44 arc(87.17,37.25) 86.36,36.7 83.09,33.43 arc(81.77,32.55) 80.22,32.24 69.52,32.24 arc(68.21,32.5) 67.11,33.24 63.78,36.57 arc(63.03,37.07) 62.16,37.24 45.82,37.24 arc(44.4,36.65) 43.8,35.22 43.8,29.74 arc(43.81,29.7) 43.84,29.66 44.27,29.23 arc(44.32,29.2) 44.38,29.19 44.74,29.19 arc(44.78,29.19) 44.81,29.21 44.94,29.35 arc(45.17,29.5) 45.45,29.56 46.08,29.56 arc(46.24,29.53) v9(46.38,29.43)
QSFP1_TX4_P: length 95.9
  TOP w0.104: v9(46.38,28.63) 46.46,28.55 arc(46.6,28.46) 46.76,28.43 47.39,28.43 arc(47.5,28.45) 47.59,28.51 47.95,28.88 arc(48,28.91) 48.05,28.93 arc(48.07,28.93) 48.08,28.93 48.12,28.93 arc(48.13,28.93) 48.14,28.93 arc(48.17,28.92) 48.2,28.91 arc(48.2,28.91) 48.2,28.91 arc(48.21,28.9) 48.23,28.89 48.43,28.68 arc(48.49,28.64) 48.55,28.63 U145.6
  TOP w0.114: v2(106.24,48.84) U1.M7
  03_SIG1 w0.109: v2(106.24,48.84) 106.24,48.55 arc(106.21,48.48) 106.13,48.44 106.02,48.44 arc(105.89,48.5) 105.84,48.62 105.84,49.08 arc(105.89,49.19) 106,49.24 107.4,49.24 arc(107.57,49.17) 107.63,49 107.63,42.49 arc(107.65,42.4) 107.7,42.33 107.87,42.16 arc(107.93,42.08) 107.95,41.98 107.95,41.85 arc(107.92,41.75) 107.86,41.65
  03_SIG1 w0.152: 107.86,41.65 107.86,40.89 arc(107.84,40.77) 107.76,40.66 105.77,38.67 arc(104.83,38.04) 103.72,37.82 88.13,37.82 arc(87.03,37.6) 86.09,36.97 82.82,33.7 arc(81.63,32.9) 80.22,32.62 69.52,32.62 arc(68.36,32.86) 67.37,33.51 64.05,36.84 arc(63.18,37.42) 62.16,37.62 45.82,37.62 arc(44.13,36.92) 43.42,35.22 43.42,31.66 arc(43.37,31.53) 43.23,31.47 arc(43.1,31.42) 43.04,31.28 43.04,30.75 arc(43.1,30.61) 43.23,30.56 arc(43.37,30.5) 43.42,30.37 43.42,29.74 arc(43.46,29.55) 43.57,29.39 44,28.96 arc(44.17,28.85) 44.38,28.8 44.75,28.8 arc(44.82,28.79) 44.88,28.75 arc(45.14,28.58) 45.45,28.52 46.11,28.52 arc(46.26,28.55) v9(46.38,28.63)
QSFP1_VCC1_FILT: length 4.2
  TOP w0.305: U145.30 54.7,26.63 v1(55.14,27.07)
  BOTTOM w0.381: C1345.1 v1(55.14,27.07)
  vias: v1(44.32,32) v1(45.03,32.03) v1(63.6,28.66) v1(64.63,28.7)
QSFP1_VCCRX_FILT: length 2.6
  TOP w0.305: U145.10 v1(48.06,25.43)
  BOTTOM w0.381: v1(48.06,25.43) 48.41,25.43 C1347.1
  vias: v1(45.75,24.72) v1(45.75,23.35) v1(62.99,36.42) v1(63.04,35.66)
QSFP1_VCCTX_FILT: length 6.2
  TOP w0.305: v1(53.41,25.63) 53.21,25.83 U145.29
  TOP w0.381: v1(66.17,27.97) 65.8,27.59 L71.2 v1(63,27.59)
  BOTTOM w0.381: v1(53.41,25.63) 53.36,25.57 C1346.1
  vias: v1(45.44,26.68) v1(45.47,27.95)
QSFP2_IIC_SCL: length 124.1
  TOP w0.14: U123.11 v1(48.06,50.21)
  03_SIG1 w0.173: v1(52.1,147.45) 52.51,147.05 52.63,147.05 53.18,146.49 53.86,146.49 54.18,146.17 54.58,145.77 54.58,143.08 52.9,141.4 50.94,141.4 50.22,140.68 50.22,134.78 47.59,132.15 46.52,131.08 46.52,128.01 43.09,124.57 43.09,119.21 40.26,116.38 40.26,109.45 41.2,108.5 41.2,104.88 40.19,103.86 40.19,102.73 41.49,101.42 41.49,97.4 40.92,96.83 40.92,95.06 37.68,91.82 37.68,84.96 35.66,82.93 35.66,70.71 35.49,70.54 35.49,68.36 37.34,66.51 37.34,55.95 41.79,51.49 46.5,51.49 46.7,51.29 46.95,51.29 47.02,51.36 47.27,51.36 47.51,51.12 47.51,50.88 47.43,50.8 47.43,50.56 47.79,50.21 v1(48.06,50.21)
  BOTTOM w0.152: v1(52.1,147.45) 51.85,147.19 U28.11 49.69,147.19 48.67,148.21 R92.2
QSFP2_IIC_SDA: length 123.4
  TOP w0.14: U123.12 47.65,49.41 v1(47.5,49.56)
  03_SIG1 w0.173: v1(47.5,49.56) 47.5,49.71 46.27,50.94 41.57,50.94 36.79,55.72 36.79,66.28 34.94,68.13 34.94,70.77 35.1,70.94 35.1,83.16 37.13,85.19 37.13,92.05 40.37,95.29 40.37,97.06 40.94,97.63 40.94,101.19 39.63,102.5 39.63,104.09 40.65,105.11 40.65,108.27 39.7,109.22 39.7,116.61 42.53,119.44 42.53,124.8 45.97,128.24 45.97,131.31 49.67,135.01 49.67,140.91 50.72,141.96 52.68,141.96 54.03,143.31 54.03,145.54 53.63,145.94 52.95,145.94 52.4,146.49 52.29,146.49 v1(52.1,146.31)
  BOTTOM w0.152: R91.2 49.38,146.94 49.78,146.54 U28.10 51.87,146.54 v1(52.1,146.31)
QSFP2_INTL: length 16.7
  TOP w0.14: U123.28 53.64,50.61 54.25,51.22 v1(54.25,51.51)
  BOTTOM w0.152: U3.15 59.75,52.09 60.89,50.95 60.89,49.34 60.53,48.97 58.97,48.97 R2.2 57.89,48.39 56,50.28 56,51.65 55.59,52.06 54.8,52.06 v1(54.25,51.51)
QSFP2_INTL_LS: length 210.3
  TOP w0.152: v2(131.24,41.84) 128.29,38.9 95.8,38.9 89.72,32.82 84.66,32.82 83.21,31.38 76.99,31.38 74.13,28.52 68.63,28.52 66.52,30.62 66.52,36.4 65.51,37.41 38.75,37.41 v1(38.44,37.1) ; U1.AT21 v2(131.24,62.84)
  07_SIG3 w0.173: v1(61.91,66.62) 61.91,67.42 61.3,68.03 53.92,68.03 49.78,72.18 45.34,72.18 43.5,70.33 40.44,70.33 38.06,72.71 35.5,72.71 34.98,72.18 32.49,72.18 v1(32.25,71.93)
  14_SIG4 w0.089: v2(131.24,41.84) 131.81,42.42 131.81,45.04 131.54,45.31 131.04,45.31 130.84,45.5 130.84,47.31 130.8,47.36 130.8,49.3 130.84,49.34 130.84,62.45 v2(131.24,62.84) ; v1(32.25,71.93) 30.9,70.59 30.9,43.97 37.78,37.1 v1(38.44,37.1)
  BOTTOM w0.152: U3.6 59.75,60.96 61.66,62.87 61.66,65.77 61.91,66.02 v1(61.91,66.62)
QSFP2_LPMODE: length 12.1
  TOP w0.14: v1(55.47,53.75) 55.02,53.29 54.53,53.29 54.25,53.01 U123.31
  18_SIG6 w0.089: v1(55.47,53.75) 55.98,53.24 57.84,53.24 v1(60.12,55.52)
  BOTTOM w0.152: v1(60.12,55.52) 60.4,55.24 U3.14
QSFP2_LPMODE_LS: length 213.4
  TOP w0.152: U1.AT24 v2(131.24,66.84) ; v2(130.24,41.84) 127.74,39.35 95.65,39.35 89.66,33.36 84.39,33.36 82.91,31.88 76.67,31.88 73.67,28.88 68.78,28.88 66.88,30.77 66.88,36.68 65.55,38.01 v1(38.45,38.01)
  07_SIG3 w0.173: v1(62.86,66.17) 62.86,67.42 61,69.28 53.52,69.28 50.02,72.78 42.92,72.78 41.86,73.84 35.79,73.84 34.73,72.78 32.56,72.78 v1(32.13,73.2)
  14_SIG4 w0.089: v2(131.24,66.84) 130.74,66.34 130.74,63.23 130.67,63.15 130.67,49.41 130.62,49.37 130.62,47.28 130.67,47.24 130.67,42.27 v2(130.24,41.84) ; v1(32.13,73.2) 32.95,72.38 32.95,71.74 31.44,70.23 31.44,44.36 37.79,38.01 v1(38.45,38.01)
  BOTTOM w0.152: v1(62.86,66.17) 62.86,66.11 62.15,65.4 62.15,62.63 60.4,60.89 U3.7
QSFP2_MODPRSL: length 21.6
  TOP w0.14: v1(55.27,51.51) 54.76,51.01 54.58,51.01 53.67,50.09 53.37,50.09 53.08,49.81 U123.27
  18_SIG6 w0.089: v1(55.27,51.51) 54.58,52.2 54.58,53.92 55.02,54.36 55.75,54.36 56.35,53.76 57.52,53.76 58.37,54.61 58.37,55.73 v1(58.07,56.02)
  BOTTOM w0.152: v1(55.27,51.51) 55.27,50.46 57.91,47.83 57.91,47.72 R1.2 ; v1(58.07,56.02) 59.1,54.99 U3.16
QSFP2_MODPRSL_LS: length 120.8
  TOP w0.152: v2(128.24,66.84) U1.AN24
  14_SIG4 w0.089: v2(128.24,66.84) 128.24,65.86 127.74,65.36 127.74,64.59 127.48,64.33 126.96,64.33 126.73,64.11 126.73,63.65 126.52,63.44 125.97,63.44 125.63,63.1 125.63,62.67 125.3,62.34 125.04,62.34 124.75,62.05 124.75,61.64 124.64,61.52 124.64,52.52 124.45,52.33 124.02,52.33 123.74,52.05 123.74,51.51 123.58,51.35 123.03,51.35 122.74,51.07 122.74,50.58 122.5,50.33 121.98,50.33 121.74,50.09 121.74,46.65 121.73,46.64 121.73,46.64 121.44,46.35 121.44,46.35 121.42,46.33 121.03,46.33 120.75,46.05 120.75,44.5 120.59,44.34 120.04,44.34 119.74,44.05 119.74,43.33 v2(120.24,42.84)
  18_SIG6 w0.089: v1(62.59,46.28) 62.59,47.23 62.3,47.51 62.3,64.14 60.76,65.68 v1(60.76,67.01)
  BOTTOM w0.152: v1(60.76,67.01) 61.26,66.51 61.26,63.15 59.1,60.99 U3.5 ; v2(120.24,42.84) 119.68,42.29 96.35,42.29 92.36,46.28 v1(62.59,46.28)
QSFP2_MODSELL: length 14.2
  TOP w0.14: U123.8 v1(48.06,52.61)
  05_SIG2 w0.173: v1(57.38,51.49) 57.38,52.61 56.8,53.19 54.38,53.19 53.8,52.61 v1(48.06,52.61)
  BOTTOM w0.14: v1(57.38,51.49) 57.8,51.91 U3.18
QSFP2_MODSELL_LS: length 141.4
  TOP w0.152: v2(122.24,41.84) 121.76,42.32 120.55,42.32 120.29,42.06 86.4,42.06 83.48,39.14 67.09,39.14 62.76,43.47 54.9,43.47 54.72,43.64 53.94,43.64 53.43,43.14 v1(52.95,43.14) ; v2(128.24,64.84) U1.AN23
  14_SIG4 w0.089: v2(122.24,41.84) 121.74,42.34 120.97,42.34 120.73,42.57 120.73,44.11 121,44.38 121.51,44.38 121.74,44.6 121.74,46.05 122.04,46.34 122.44,46.34 122.73,46.64 122.73,46.7 122.74,46.7 122.74,50.02 122.74,50.02 122.74,50.05 123.03,50.34 123.53,50.34 123.74,50.55 123.74,50.63 123.74,50.64 123.74,51.05 123.74,51.05 123.74,51.11 123.97,51.34 124.63,51.34 124.73,51.44 124.73,52.18 124.84,52.29 124.84,61.19 124.99,61.34 125.5,61.34 125.64,61.48 125.64,62.39 125.83,62.59 125.83,63.02 126.05,63.24 126.67,63.24 126.88,63.44 127.6,63.44 127.74,63.58 127.74,64.04 128.24,64.54 v2(128.24,64.84)
  BOTTOM w0.152: U3.3 57.8,61 60.01,63.21 R43.1 60.01,64.62 60.29,64.9 60.29,65.74 59.59,66.45 57.78,66.45 50.69,59.36 50.69,44.47 52.01,43.14 v1(52.95,43.14)
QSFP2_RECCLK_C_N: length 2.6
  TOP w0.104: C1581.2 80.84,24.77 81.01,24.77 81.13,24.64 81.13,24.46 81.35,24.24 81.59,24.24 81.73,24.1 U57.13
QSFP2_RECCLK_C_P: length 2.6
  TOP w0.104: U57.12 81.73,24.6 81.59,24.47 81.45,24.47 81.36,24.56 81.36,24.74 81.1,24.99 80.84,24.99 C1580.2
QSFP2_RECCLK_N: length 101.9
  TOP w0.104: U1.AP22 v2(129.24,63.84) ; C1581.1 79.31,24.38 R1198.2 77.49,24.38 v1(77.21,24.66)
  16_SIG5 w0.076: v2(129.24,63.84) 129.24,64.16 129.14,64.25 128.9,64.25 128.64,64.51 128.64,65.24 128.39,65.49 118.9,65.49 117.85,64.45 117.85,56.59 117.51,56.24 116.92,56.24 116.84,56.16 116.84,49.38 116.86,49.36 116.86,47.6 116.83,47.57 116.83,46.22 116.82,46.21 116.82,44.48 116.86,44.44 116.86,42.46 116.64,42.24 116.64,41.56 116.68,41.52 116.68,41.5
  16_SIG5 w0.089: 116.68,41.5 116.68,38.96 114.95,37.23 114.95,28.45 113.47,26.97 113.47,23.33 110.55,20.41 105.24,20.41 103.5,18.67 92.83,18.67 92.27,19.23 88.28,19.23 87.69,19.82 81.26,19.82 79.39,21.69 79.39,24.24 78.68,24.95 77.5,24.95 v1(77.21,24.66)
QSFP2_RECCLK_P: length 101.8
  TOP w0.104: C1580.1 79.31,25.38 R1198.1 77.49,25.38 v1(77.21,25.66) ; v2(129.24,64.84) U1.AP23
  16_SIG5 w0.076: 116.4,41.5 116.4,41.52 116.44,41.56 116.44,42.32 116.66,42.54 116.66,44.36 116.62,44.4 116.62,46.29 116.63,46.3 116.63,47.65 116.66,47.68 116.66,49.28 116.64,49.3 116.64,56.24 116.84,56.44 117.43,56.44 117.65,56.67 117.65,64.53 118.81,65.69 128.48,65.69 128.84,65.32 128.84,64.59 128.99,64.45 129.16,64.45 129.24,64.53 v2(129.24,64.84)
  16_SIG5 w0.089: 116.4,41.5 116.4,39.08 114.67,37.35 114.67,28.56 113.19,27.08 113.19,23.45 110.44,20.69 105.13,20.69 103.39,18.95 92.94,18.95 92.39,19.5 88.39,19.5 87.8,20.1 81.38,20.1 79.66,21.81 79.66,24.36 78.79,25.23 77.64,25.23 v1(77.21,25.66)
QSFP2_RESETL: length 18.7
  TOP w0.14: U123.9 v1(48.06,51.81)
  05_SIG2 w0.173: v1(56.62,56.13) 55.11,54.62 53.48,54.62 52.49,53.63 48.73,53.63 48.24,54.13 47.75,54.13 47.28,53.65 47.28,52.19 47.66,51.81 v1(48.06,51.81)
  BOTTOM w0.152: v1(56.62,56.13) 56.64,56.11 57.07,56.11 57.66,55.52 57.94,55.52 58.45,55.01 U3.17
QSFP2_RESETL_LS: length 266.6
  TOP w0.152: U1.AY22 v2(135.24,63.84) ; v1(171.4,29.46) 170.89,29.97 154.24,29.97 151.55,32.67 146.17,32.67 144.76,31.26 144.76,29.68 143.99,28.91 142.9,28.91 140.08,26.09 137.11,26.09 136.67,26.53 135.11,26.53 133.34,28.3 133.34,32.7 130.86,35.18 129.23,35.18 127.39,37.02 126.61,37.02 125.86,36.27 123.08,36.27 120.13,33.32 118.14,33.32 117.47,32.66 117.47,29.9 117.14,29.57 115.49,29.57 114.99,30.07 113.54,30.07 112.66,29.19 v1(110.88,29.19)
  14_SIG4 w0.089: v1(57.69,67.39) 56.71,68.36 52.56,68.36 51.97,67.77 51.97,59.16 52.94,58.19 52.94,48.64 54.08,47.5 54.08,45.34 52.15,43.41 52.15,39.13 53.85,37.43 54.14,37.14 58.23,37.14 59.47,35.9 59.47,34.35 60.94,32.88 61.78,32.88 65.1,29.56 65.1,25.39 66.15,24.35 66.15,23.11 67.03,22.22 67.03,21.13 67.49,20.68 70.71,20.68 71.72,21.68 76.31,21.68 77.09,22.45 79.42,22.45 80.76,21.12 87.78,21.12 89.67,23.01 93.74,23.01 94.45,22.3 97.87,22.3 102.49,26.92 106.2,26.92 107.06,27.79 109.48,27.79 v1(110.88,29.19)
  16_SIG5 w0.089: v2(135.24,63.84) 135.25,63.84 135.63,63.46 135.63,53.6 135.45,53.42 134.93,53.42 134.64,53.13 134.64,50.63 135.01,50.26 137.4,50.26 137.64,50.03 137.64,49.62 138,49.25 142.16,49.25 144.46,46.95 144.46,43.61 154.4,33.67 167.83,33.67 168.5,33 168.5,30.32 169.36,29.46 v1(171.4,29.46)
  BOTTOM w0.152: v1(57.69,67.39) 58.02,67.05 59.69,67.05 60.82,65.93 60.82,63.33 58.45,60.96 U3.4
QSFP2_RX1_N: length 79.3
  TOP w0.104: U123.18 48.55,44.61 arc(48.49,44.62) 48.43,44.65 48.23,44.86 arc(48.21,44.87) 48.2,44.88 arc(48.2,44.88) 48.2,44.88 arc(48.17,44.9) 48.14,44.9 arc(48.13,44.9) 48.12,44.9 48.08,44.9 arc(48.07,44.9) 48.05,44.9 arc(48,44.89) 47.95,44.85 47.59,44.48 arc(47.5,44.42) 47.39,44.4 46.76,44.4 arc(46.6,44.44) 46.46,44.53 v9(46.38,44.61)
  TOP w0.114: v2(110.24,42.84) 110.74,43.34 U1.T1
  05_SIG2 w0.109: v2(110.24,42.84) 110.24,43.11 arc(110.2,43.2) 110.1,43.24 109.99,43.24 arc(109.88,43.2) 109.84,43.09 109.84,41.95 arc(109.79,41.68) 109.64,41.46 109.63,41.46 109.54,41.37 109.44,41.27 arc(109.38,41.19) 109.36,41.08
  05_SIG2 w0.152: 109.36,41.08 109.29,41.01 arc(109.09,40.71) 109.02,40.36 arc(109.01,40.24) 109,40.13 arc(108.85,39.68) 108.58,39.31 108.26,38.98 arc(104.91,36.75) 100.96,35.96 97.02,35.96 arc(94.05,35.37) 91.53,33.69 89.92,32.07 arc(88.82,31.34) 87.52,31.08 85.87,31.08 arc(84.97,31.26) 84.21,31.77 arc(83.7,32.11) 83.11,32.23 70.07,32.23 arc(68.15,32.61) 66.52,33.69 63.1,37.12 arc(61.33,38.3) 59.25,38.72 56.95,38.72 arc(55.9,38.93) 55.01,39.52 51.38,43.15 arc(51.04,43.38) 50.64,43.46 49.01,43.46 arc(48.64,43.53) 48.34,43.74 arc(48.13,44.05) 48.06,44.41 48.06,44.66 arc(48.01,44.76) 47.91,44.8 arc(47.82,44.79) 47.75,44.74 47.62,44.61 arc(47,44.35) v9(46.38,44.61)
QSFP2_RX1_P: length 79.3
  TOP w0.104: v9(46.38,45.41) 46.5,45.52 arc(46.6,45.59) 46.71,45.61 47.38,45.61 arc(47.49,45.59) 47.59,45.52 47.95,45.16 arc(47.98,45.14) 48.02,45.13 48.18,45.13 arc(48.22,45.14) 48.24,45.16 48.45,45.37 arc(48.5,45.4) 48.55,45.41 U123.17
  TOP w0.114: v2(110.24,43.84) 110.74,44.34 U1.T2
  05_SIG2 w0.109: 109.11,41.37 109.12,41.39 109.15,41.39 arc(109.2,41.39) 109.25,41.4 arc(109.28,41.42) 109.32,41.45 109.49,41.6 arc(109.6,41.76) 109.64,41.95 109.64,43.09 arc(109.74,43.34) 109.99,43.45 110.13,43.45 arc(110.21,43.48) 110.24,43.56 v2(110.24,43.84)
  05_SIG2 w0.152: 109.11,41.37 109.02,41.28 arc(108.74,40.86) 108.64,40.36 arc(108.63,40.27) 108.62,40.19 arc(108.52,39.86) 108.31,39.58 107.99,39.25 arc(104.77,37.1) 100.96,36.34 97.02,36.34 arc(93.91,35.72) 91.26,33.96 89.65,32.34 arc(88.67,31.69) 87.52,31.46 85.87,31.46 arc(85.12,31.61) 84.48,32.04 arc(83.85,32.46) 83.11,32.61 70.07,32.61 arc(68.29,32.96) 66.79,33.96 63.37,37.39 arc(61.48,38.65) 59.25,39.1 56.95,39.1 arc(56.05,39.28) 55.28,39.79 51.65,43.42 arc(51.18,43.73) 50.64,43.84 50.36,43.84 arc(50.3,43.86) 50.28,43.92 arc(50.26,43.95) 50.23,43.97 49.87,43.97 arc(49.84,43.95) 49.82,43.92 arc(49.8,43.86) 49.75,43.84 49.01,43.84 arc(48.79,43.88) 48.61,44.01 arc(48.48,44.19) 48.44,44.41 48.44,44.74 arc(48.31,45.05) 48,45.18 arc(47.83,45.22) 47.69,45.31 47.59,45.41 arc(46.99,45.66) v9(46.38,45.41)
QSFP2_RX2_N: length 70.7
  TOP w0.104: U123.21 52.91,45.01 arc(53,45.03) 53.09,45.08 53.24,45.24 arc(53.32,45.29) 53.42,45.31 53.55,45.31 arc(53.65,45.29) 53.73,45.24 arc(53.9,45.13) 54.09,45.09 54.84,45.09 arc(55.02,45.05) 55.17,44.95 55.35,44.77 arc(55.41,44.73) 55.48,44.72 56.35,44.72 arc(56.46,44.74) v9(56.55,44.8)
  TOP w0.114: v2(109.24,44.84) 109.74,45.34 U1.R3
  05_SIG2 w0.109: v2(109.24,44.84) 109.24,45.13 arc(109.21,45.21) 109.13,45.24 109.01,45.24 arc(108.89,45.19) 108.84,45.08 108.84,42.56 arc(108.86,42.46) 108.92,42.37
  05_SIG2 w0.152: 108.92,42.37 108.92,42.28 arc(108.88,42.05) 108.75,41.85 108.09,41.2 108.08,41.2 108.05,41.15 arc(108.04,41.15) 108.04,41.14 107.91,41.04 arc(107.67,40.75) 107.47,40.44 arc(107.2,40) 106.87,39.61 arc(106.63,39.38) 106.38,39.16 arc(103.81,37.66) 100.88,37.13 96.85,37.13 arc(93.56,36.48) 90.78,34.62 89.96,33.8 arc(89.03,33.18) 87.93,32.96 86.55,32.96 arc(85.57,33.16) 84.74,33.71 arc(84.27,34.02) 83.72,34.13 68.55,34.13 arc(67.88,34.27) 67.3,34.65 60.18,41.78 60.14,41.82 58.98,42.98 58.65,43.3 arc(58.44,43.62) 58.36,44.01 58.36,44.9 arc(58.32,44.99) 58.23,45.03 57.98,45.03 arc(57.94,45.02) 57.91,45 57.88,44.97 arc(57.87,44.93) 57.86,44.9 arc(57.78,44.69) 57.57,44.6 57.03,44.6 arc(56.77,44.65) v9(56.55,44.8)
QSFP2_RX2_P: length 70.6
  TOP w0.104: U123.22 52.79,45.81 arc(52.93,45.78) 53.05,45.7 53.12,45.63 arc(53.22,45.56) 53.34,45.54 53.55,45.54 arc(53.74,45.5) 53.9,45.4 arc(53.99,45.34) 54.09,45.32 54.88,45.32 arc(54.99,45.34) 55.09,45.4 55.32,45.63 arc(55.38,45.67) 55.45,45.69 56.35,45.69 arc(56.46,45.66) v9(56.55,45.6)
  TOP w0.114: v2(109.24,45.84) 109.74,46.34 U1.R4
  05_SIG2 w0.109: v2(109.24,45.84) 109.24,45.55 arc(109.21,45.48) 109.13,45.44 109.01,45.44 arc(108.75,45.34) 108.64,45.08 108.64,42.52 arc(108.62,42.39) 108.54,42.28
  05_SIG2 w0.152: 108.54,42.28 arc(108.53,42.19) 108.48,42.12 107.96,41.6 107.96,41.6 107.79,41.43 107.67,41.33 arc(107.65,41.32) 107.64,41.3 arc(107.36,40.98) 107.14,40.61 arc(106.9,40.23) 106.6,39.88 arc(106.37,39.66) 106.13,39.45 arc(103.68,38.01) 100.88,37.52 96.85,37.52 arc(93.42,36.83) 90.51,34.89 89.69,34.07 arc(88.88,33.53) 87.93,33.34 86.55,33.34 arc(85.72,33.51) 85.01,33.98 arc(84.42,34.38) 83.72,34.51 68.55,34.51 arc(68.02,34.62) 67.57,34.92 59.79,42.7 arc(59.77,42.76) 59.79,42.81 arc(59.85,42.94) 59.79,43.07 59.62,43.24 arc(59.49,43.3) 59.36,43.24 arc(59.31,43.22) 59.25,43.24 58.92,43.57 arc(58.79,43.77) 58.74,44.01 58.74,44.9 arc(58.59,45.26) 58.23,45.41 57.98,45.41 arc(57.95,45.42) 57.93,45.43 arc(57.92,45.45) 57.91,45.48 arc(57.83,45.68) 57.62,45.77 56.96,45.77 arc(56.74,45.73) v9(56.55,45.6)
QSFP2_RX3_N: length 77.8
  TOP w0.104: v9(46.38,47.01) 46.46,46.93 arc(46.6,46.84) 46.76,46.8 47.39,46.8 arc(47.5,46.82) 47.59,46.88 47.95,47.25 arc(48,47.29) 48.05,47.3 arc(48.07,47.3) 48.08,47.3 48.12,47.3 arc(48.13,47.3) 48.14,47.3 arc(48.17,47.3) 48.2,47.28 arc(48.2,47.28) 48.2,47.28 arc(48.21,47.27) 48.23,47.26 48.43,47.05 arc(48.49,47.02) 48.55,47.01 U123.15
  TOP w0.114: v2(108.24,42.84) 108.74,43.34 U1.P1
  05_SIG2 w0.109: v2(108.24,42.84) 108.24,43.13 arc(108.21,43.21) 108.13,43.24 106.94,43.24 arc(106.73,43.33) 106.64,43.54 106.64,44.08 arc(106.59,44.19) 106.47,44.24 105,44.24 arc(104.89,44.2) 104.85,44.09 104.85,42.45 arc(104.83,42.33) 104.76,42.24 104.48,41.96 arc(104.42,41.86) 104.39,41.74 104.37,41.72
  05_SIG2 w0.152: 104.37,41.72 103.52,40.87 arc(102.02,39.86) 100.24,39.51 82.68,39.51 arc(82.31,39.44) 82,39.23 81.99,39.21 arc(81.78,39.07) 81.53,39.02 68.24,39.02 arc(66.85,39.3) 65.68,40.08 62.31,43.45 arc(61.64,44.45) 61.41,45.62 61.41,46.26 arc(61.23,47.18) 60.71,47.96 59.23,49.43 arc(58.32,50.05) 57.23,50.26 51.03,50.26 arc(50.5,50.16) 50.06,49.86 48.61,48.41 arc(48.48,48.22) 48.44,48 48.44,47.67 arc(48.31,47.36) 48,47.23 arc(47.83,47.2) 47.69,47.1 47.59,47.01 arc(46.99,46.76) v9(46.38,47.01)
QSFP2_RX3_P: length 77.8
  TOP w0.104: U123.14 48.55,47.81 arc(48.5,47.8) 48.45,47.77 48.24,47.56 arc(48.22,47.54) 48.18,47.53 48.02,47.53 arc(47.98,47.54) 47.95,47.56 47.59,47.92 arc(47.49,47.99) 47.38,48.01 46.71,48.01 arc(46.6,47.99) 46.5,47.92 v9(46.38,47.81)
  TOP w0.114: U1.P2 108.74,44.34 v2(108.24,43.84)
  05_SIG2 w0.109: v2(108.24,43.84) 108.24,43.55 arc(108.21,43.48) 108.13,43.44 106.94,43.44 arc(106.87,43.47) 106.84,43.54 106.84,44.08 arc(106.74,44.34) 106.47,44.45 105,44.45 arc(104.75,44.34) 104.65,44.09 104.65,42.45 arc(104.64,42.41) 104.62,42.38 104.32,42.08 arc(104.22,42.01) 104.1,41.99
  05_SIG2 w0.152: 104.1,41.99 103.25,41.14 arc(101.87,40.21) 100.24,39.89 82.68,39.89 arc(82.17,39.79) 81.73,39.5 81.72,39.48 arc(81.63,39.42) 81.53,39.4 68.24,39.4 arc(67,39.65) 65.95,40.35 62.58,43.72 arc(62,44.59) 61.79,45.62 61.79,46.26 arc(61.58,47.33) 60.98,48.23 59.5,49.7 arc(58.46,50.4) 57.23,50.65 51.03,50.65 arc(50.36,50.51) 49.79,50.13 49.59,49.94 arc(49.52,49.9) 49.45,49.94 arc(49.37,49.97) 49.3,49.94 48.8,49.43 arc(48.77,49.36) 48.8,49.29 arc(48.83,49.22) 48.8,49.14 48.34,48.68 arc(48.13,48.37) 48.06,48 48.06,47.76 arc(48.01,47.65) 47.91,47.61 arc(47.82,47.63) 47.75,47.68 47.62,47.81 arc(47,48.06) v9(46.38,47.81)
QSFP2_RX4_N: length 64
  TOP w0.104: U123.24 52.92,47.41 arc(52.97,47.42) 53.01,47.44 53.23,47.67 arc(53.32,47.73) 53.43,47.75 53.66,47.75 arc(53.75,47.73) 53.83,47.68 53.9,47.61 arc(54.03,47.52) 54.19,47.49 54.89,47.49 arc(55.07,47.45) 55.23,47.35 55.37,47.21 arc(55.47,47.14) 55.58,47.12 56.35,47.12 arc(56.46,47.14) v9(56.55,47.2)
  TOP w0.114: v2(106.24,42.84) 106.74,43.34 U1.M1
  05_SIG2 w0.109: 105.93,42.1 105.93,42.13 105.93,42.13 arc(105.87,42.23) 105.85,42.34 105.85,43.07 arc(105.9,43.19) 106.02,43.24 106.13,43.24 arc(106.21,43.21) 106.24,43.13 v2(106.24,42.84)
  05_SIG2 w0.152: 105.93,42.1 105.93,41.37 arc(105.87,41.05) 105.69,40.78 104.77,39.87 arc(103.05,38.72) 101.02,38.31 83.45,38.31 arc(83.14,38.25) 82.88,38.07 arc(82.7,37.95) 82.48,37.91 67.64,37.91 arc(66.26,38.18) 65.1,38.96 60.67,43.39 arc(60.11,44.07) 59.69,44.86 arc(59.43,45.7) 59.35,46.58 59.35,46.75 arc(59.17,47.2) 58.74,47.43 arc(58.7,47.43) 58.66,47.43 58.06,47.43 arc(57.98,47.41) 57.91,47.37 arc(57.89,47.34) 57.88,47.3 arc(57.8,47.1) 57.6,47.02 57,47.02 arc(56.76,47.06) v9(56.55,47.2)
QSFP2_RX4_P: length 64
  TOP w0.104: U123.25 52.94,48.21 arc(53,48.19) 53.06,48.16 53.15,48.07 arc(53.25,48) 53.37,47.98 53.66,47.98 arc(53.84,47.94) 53.99,47.84 54.06,47.77 arc(54.12,47.73) 54.19,47.72 54.88,47.72 arc(55.09,47.76) 55.26,47.88 55.31,47.92 arc(55.49,48.04) 55.7,48.09 56.35,48.09 arc(56.46,48.06) v9(56.55,48)
  TOP w0.114: v2(106.24,43.84) 106.74,44.34 U1.M2
  05_SIG2 w0.109: v2(106.24,43.84) 106.24,43.55 arc(106.21,43.48) 106.13,43.44 106.02,43.44 arc(105.75,43.33) 105.64,43.07 105.64,42.32 arc(105.62,42.2) 105.55,42.1
  05_SIG2 w0.152: 105.55,42.1 105.55,41.37 arc(105.52,41.2) 105.42,41.05 105.14,40.77 arc(105.04,40.73) 104.94,40.77 arc(104.83,40.82) 104.73,40.77 104.5,40.55 arc(104.46,40.44) 104.5,40.34 arc(104.55,40.24) 104.5,40.14 arc(102.9,39.07) 101.02,38.69 83.45,38.69 arc(83,38.6) 82.61,38.34 arc(82.55,38.3) 82.48,38.29 67.64,38.29 arc(66.41,38.54) 65.37,39.23 60.94,43.66 arc(60.43,44.29) 60.04,45 arc(59.81,45.78) 59.73,46.58 59.73,46.75 arc(59.45,47.46) 58.78,47.81 arc(58.77,47.81) 58.76,47.81 57.97,47.81 arc(57.91,47.84) 57.88,47.91 arc(57.8,48.1) 57.6,48.19 56.99,48.19 arc(56.75,48.14) v9(56.55,48)
QSFP2_TX1_N: length 75.6
  TOP w0.104: U123.37 52.86,57.81 arc(52.93,57.79) 52.98,57.76 53.21,57.53 arc(53.27,57.49) 53.34,57.48 53.6,57.48 arc(53.68,57.49) 53.76,57.54 arc(53.88,57.63) 54.03,57.66 55.11,57.66 arc(55.37,57.6) 55.59,57.46 55.66,57.39 arc(55.77,57.31) 55.91,57.29 55.96,57.29 arc(56,57.3) 56.03,57.32 56.3,57.59 arc(56.36,57.63) 56.43,57.64 57.33,57.64 arc(57.44,57.62) v9(57.54,57.56)
  TOP w0.114: v2(105.24,45.84) 105.74,46.34 U1.L4
  03_SIG1 w0.109: v2(105.24,45.84) 105.24,46.13 arc(105.27,46.21) 105.35,46.24 105.46,46.24 arc(105.58,46.19) 105.64,46.06 105.64,42.54 arc(105.62,42.45) 105.57,42.38 105.54,42.35
  03_SIG1 w0.152: v9(57.54,57.56) arc(57.73,57.69) 57.96,57.73 58.27,57.73 arc(58.57,57.67) 58.83,57.5 59.32,57.01 arc(59.51,56.73) 59.57,56.41 59.57,47.55 arc(59.86,46.11) 60.67,44.88 66.08,39.48 arc(66.82,38.98) 67.71,38.81 82.34,38.81 arc(82.78,38.89) 83.14,39.14 83.75,39.75 arc(84.23,40.07) 84.8,40.18 103.54,40.18 arc(103.81,40.23) 104.04,40.39 104.17,40.52 arc(104.26,40.73) 104.17,40.95 104.11,41.01 arc(104.11,41.44) 104.54,41.44 104.62,41.36 arc(104.81,41.28) 105.01,41.36 105.21,41.56 arc(105.45,41.92) 105.54,42.35
QSFP2_TX1_P: length 75.5
  TOP w0.104: U123.36 52.9,57.01 arc(53.01,57.03) 53.11,57.1 53.21,57.2 arc(53.27,57.24) 53.34,57.25 53.6,57.25 arc(53.77,57.28) 53.92,57.38 arc(53.97,57.41) 54.03,57.43 55.11,57.43 arc(55.29,57.39) 55.43,57.3 55.51,57.21 arc(55.68,57.1) 55.88,57.06 55.9,57.06 arc(56,57.04) 56.08,56.99 56.34,56.73 arc(56.4,56.69) 56.47,56.68 57.33,56.68 arc(57.44,56.7) v9(57.54,56.76)
  TOP w0.114: v2(105.24,46.84) U1.L5
  03_SIG1 w0.109: v2(105.24,46.84) 105.24,46.55 arc(105.27,46.48) 105.35,46.44 105.46,46.44 arc(105.73,46.33) 105.84,46.06 105.84,42.53 arc(105.86,42.43) 105.92,42.35
  03_SIG1 w0.152: 105.92,42.35 arc(105.8,41.77) 105.48,41.29 105.28,41.09 104.31,40.12 arc(103.96,39.88) 103.54,39.8 84.8,39.8 arc(84.38,39.72) 84.02,39.48 83.41,38.87 arc(82.92,38.54) 82.34,38.43 67.71,38.43 arc(66.68,38.63) 65.81,39.21 61.77,43.25 arc(61.65,43.3) 61.54,43.25 arc(61.42,43.2) 61.3,43.25 61.1,43.44 arc(61.06,43.56) 61.1,43.68 arc(61.15,43.8) 61.1,43.92 60.4,44.62 arc(59.51,45.96) 59.19,47.55 59.19,56.16 arc(59.15,56.36) 59.03,56.54 arc(58.94,56.6) 58.84,56.62 57.88,56.62 arc(57.7,56.65) v9(57.54,56.76)
QSFP2_TX2_N: length 85.1
  TOP w0.104: U123.2 48.55,57.41 arc(48.5,57.4) 48.45,57.37 48.24,57.16 arc(48.22,57.14) 48.18,57.13 48.02,57.13 arc(47.98,57.14) 47.95,57.16 47.59,57.52 arc(47.49,57.59) 47.38,57.61 46.71,57.61 arc(46.6,57.59) 46.5,57.52 v9(46.38,57.41)
  TOP w0.114: v2(104.24,47.84) U1.K6
  03_SIG1 w0.109: 102.55,42.42 102.56,42.44 arc(102.62,42.52) 102.64,42.61 102.64,49.09 arc(102.74,49.34) 102.99,49.44 104.44,49.44 arc(104.72,49.33) 104.84,49.05 104.84,48.62 arc(104.73,48.35) 104.46,48.24 104.35,48.24 arc(104.27,48.21) 104.24,48.13 v2(104.24,47.84)
  03_SIG1 w0.152: 102.55,42.42 102.55,41.67 arc(102.45,41.45) 102.22,41.35 85.29,41.35 arc(84.21,41.57) 83.29,42.18 82.7,42.76 arc(82.35,43) 81.94,43.08 67.38,43.08 arc(67.15,43.13) 66.96,43.26 61.61,48.61 arc(61.17,49.27) 61.01,50.05 61.01,56.06 arc(60.85,56.9) 60.37,57.62 59.32,58.67 arc(58.5,59.22) 57.54,59.41 50.4,59.41 arc(49.65,59.26) 49.01,58.83 48.28,58.1 arc(48.12,57.86) 48.06,57.59 48.06,57.32 arc(48.02,57.21) 47.9,57.16 47.87,57.16 arc(47.83,57.16) 47.8,57.18 47.8,57.19 arc(47.73,57.25) 47.66,57.31 47.61,57.37 arc(47.4,57.51) 47.16,57.55 46.74,57.55 arc(46.55,57.52) v9(46.38,57.41)
QSFP2_TX2_P: length 85
  TOP w0.104: v9(46.38,56.61) 46.46,56.53 arc(46.6,56.44) 46.76,56.4 47.39,56.4 arc(47.5,56.42) 47.59,56.48 47.95,56.85 arc(48,56.89) 48.05,56.9 arc(48.07,56.9) 48.08,56.9 48.12,56.9 arc(48.13,56.9) 48.14,56.9 arc(48.17,56.9) 48.2,56.88 arc(48.2,56.88) 48.2,56.88 arc(48.21,56.87) 48.23,56.86 48.43,56.65 arc(48.49,56.62) 48.55,56.61 U123.3
  TOP w0.114: v2(104.24,48.84) U1.K7
  03_SIG1 w0.109: 102.93,42.42 102.91,42.44 arc(102.86,42.52) 102.84,42.61 102.84,49.09 arc(102.88,49.2) 102.99,49.24 104.44,49.24 arc(104.58,49.18) 104.64,49.05 104.64,48.62 arc(104.58,48.5) 104.46,48.44 104.35,48.44 arc(104.27,48.48) 104.24,48.55 v2(104.24,48.84)
  03_SIG1 w0.152: 102.93,42.42 102.93,41.67 arc(102.72,41.18) 102.22,40.97 85.29,40.97 arc(84.06,41.21) 83.02,41.91 82.43,42.49 arc(82.21,42.65) 81.94,42.7 67.38,42.7 arc(67.01,42.77) 66.69,42.99 61.34,48.34 arc(60.82,49.12) 60.63,50.05 60.63,56.06 arc(60.5,56.76) 60.1,57.35 59.05,58.4 arc(58.36,58.87) 57.54,59.03 51.96,59.03 arc(51.87,58.99) 51.83,58.9 arc(51.78,58.77) 51.65,58.72 51.1,58.72 arc(50.97,58.77) 50.92,58.9 arc(50.88,58.99) 50.79,59.03 50.4,59.03 arc(49.79,58.91) 49.28,58.56 48.55,57.83 arc(48.47,57.72) 48.45,57.59 48.45,57.35 arc(48.28,56.95) 47.87,56.78 47.85,56.78 arc(47.77,56.76) 47.7,56.72 47.54,56.55 arc(47.42,56.47) 47.28,56.45 46.77,56.45 arc(46.56,56.49) v9(46.38,56.61)
QSFP2_TX3_N: length 83.6
  TOP w0.104: U123.34 52.76,55.41 arc(52.91,55.38) 53.04,55.29 53.14,55.19 arc(53.19,55.15) 53.25,55.14 54.09,55.14 arc(54.16,55.13) 54.23,55.08 54.24,55.07 arc(54.28,55.05) 54.33,55.03 54.34,55.03 arc(54.34,55.03) 54.35,55.03 55.27,55.03 55.27,55.03 arc(55.39,55.06) 55.48,55.12 55.71,55.35 arc(55.77,55.39) 55.84,55.4 56.74,55.4 arc(56.85,55.38) v9(56.95,55.32)
  TOP w0.114: v2(103.24,45.84) 103.74,46.34 U1.J4
  03_SIG1 w0.109: 106.54,41.45 106.58,41.5 arc(106.62,41.55) 106.64,41.62 106.64,46.98 arc(106.56,47.17) 106.38,47.24 104.14,47.24 arc(103.93,47.15) 103.84,46.94 103.84,46.62 arc(103.73,46.35) 103.46,46.24 103.35,46.24 arc(103.27,46.21) 103.24,46.13 v2(103.24,45.84)
  03_SIG1 w0.152: v9(56.95,55.32) 57.08,55.45 57.93,55.45 arc(58.12,55.41) 58.29,55.3 arc(58.37,55.18) 58.39,55.05 58.39,44.54 arc(58.46,44.21) 58.64,43.94 67.77,34.81 arc(68.3,34.46) 68.92,34.33 80.99,34.33 arc(81.4,34.42) 81.75,34.65 85.2,38.1 arc(86.19,38.76) 87.36,38.99 103.41,38.99 arc(104.31,39.17) 105.07,39.68 106.32,40.93 arc(106.48,41.17) 106.54,41.45
QSFP2_TX3_P: length 83.7
  TOP w0.104: U123.33 52.74,54.61 arc(52.87,54.63) 52.98,54.71 53.11,54.83 arc(53.2,54.89) 53.3,54.91 54,54.91 arc(54.07,54.9) 54.13,54.86 54.14,54.85 arc(54.19,54.82) 54.25,54.8 54.35,54.8 arc(54.35,54.8) 54.35,54.8 55.26,54.8 arc(55.43,54.77) 55.56,54.67 55.75,54.49 arc(55.81,54.45) 55.88,54.43 56.74,54.43 arc(56.85,54.46) v9(56.95,54.52)
  TOP w0.114: v2(103.24,46.84) U1.J5
  03_SIG1 w0.109: v2(103.24,46.84) 103.24,46.55 arc(103.27,46.48) 103.35,46.44 103.46,46.44 arc(103.58,46.5) 103.63,46.62 103.63,46.94 arc(103.78,47.3) 104.14,47.45 106.38,47.45 arc(106.7,47.31) 106.84,46.98 106.84,41.62 arc(106.85,41.54) 106.9,41.47 106.92,41.45
  03_SIG1 w0.152: v9(56.95,54.52) 57.14,54.33 57.58,54.33 arc(57.73,54.3) 57.85,54.22 arc(57.94,54.11) 57.99,53.99 arc(58.01,53.93) 58.01,53.86 58.01,44.54 arc(58.11,44.07) 58.37,43.67 67.5,34.54 arc(68.15,34.11) 68.92,33.95 80.99,33.95 arc(81.55,34.06) 82.02,34.38 85.47,37.83 arc(86.34,38.41) 87.36,38.61 103.41,38.61 arc(104.45,38.82) 105.34,39.41 106.59,40.67 arc(106.83,41.03) 106.92,41.45
QSFP2_TX4_N: length 87.2
  TOP w0.104: U123.5 48.55,55.01 arc(48.5,55) 48.45,54.97 48.24,54.76 arc(48.22,54.74) 48.18,54.73 48.02,54.73 arc(47.98,54.74) 47.95,54.76 47.59,55.12 arc(47.49,55.19) 47.38,55.21 46.71,55.21 arc(46.6,55.19) 46.5,55.12 v9(46.38,55.01)
  TOP w0.114: v2(102.24,47.84) U1.H6
  03_SIG1 w0.109: v2(102.24,47.84) 102.24,48.13 arc(102.2,48.21) 102.13,48.24 102.02,48.24 arc(101.89,48.19) 101.84,48.06 101.84,42.7 arc(101.7,42.36) 101.36,42.22 101.14,42.22 arc(101.05,42.18) 101.01,42.09 arc(100.97,42) 100.88,41.96 100.7,41.96 arc(100.61,42) 100.57,42.09 arc(100.53,42.18) 100.44,42.22 100.26,42.22 arc(100.17,42.18) 100.13,42.09 arc(100.1,42) 100,41.96 99.83,41.96 arc(99.74,42) 99.7,42.09 arc(99.66,42.18) 99.57,42.22 99.39,42.22 arc(99.3,42.18) 99.26,42.09 arc(99.22,42) 99.13,41.96 98.95,41.96 arc(98.86,42) 98.82,42.09 arc(98.79,42.18) 98.69,42.22 98.52,42.22 arc(98.42,42.18) 98.39,42.09 arc(98.35,42) 98.26,41.96 98.08,41.96 arc(97.99,42) 97.95,42.09 arc(97.91,42.18) 97.82,42.22 96.89,42.22 arc(96.8,42.2) 96.72,42.15
  03_SIG1 w0.152: 96.72,42.15 85.4,42.15 arc(84.67,42.29) 84.06,42.7 82.83,43.93 arc(82.53,44.13) 82.18,44.2 80.92,44.2 arc(80.52,44.12) 80.18,43.9 arc(79.86,43.68) 79.48,43.61 68.56,43.61 arc(67.79,43.76) 67.14,44.2 62.51,48.83 arc(61.99,49.61) 61.81,50.52 61.81,56.6 arc(61.67,57.29) 61.28,57.87 59.54,59.61 arc(58.88,60.05) 58.09,60.21 49.1,60.21 arc(47.91,59.97) 46.91,59.3 44.38,56.77 arc(43.96,56.15) 43.82,55.41 arc(44.01,54.95) 44.47,54.76 44.74,54.76 arc(44.78,54.77) 44.81,54.79 44.94,54.92 arc(45.17,55.08) 45.45,55.13 46.08,55.13 arc(46.24,55.1) v9(46.38,55.01)
QSFP2_TX4_P: length 87.2
  TOP w0.104: v9(46.38,54.21) 46.46,54.13 arc(46.6,54.04) 46.76,54 47.39,54 arc(47.5,54.02) 47.59,54.08 47.95,54.45 arc(48,54.49) 48.05,54.5 arc(48.07,54.5) 48.08,54.5 48.12,54.5 arc(48.13,54.5) 48.14,54.5 arc(48.17,54.5) 48.2,54.48 arc(48.2,54.48) 48.2,54.48 arc(48.21,54.47) 48.23,54.46 48.43,54.25 arc(48.49,54.22) 48.55,54.21 U123.6
  TOP w0.114: v2(102.24,48.84) U1.H7
  03_SIG1 w0.109: 96.72,42.53 96.72,42.52 arc(96.83,42.45) 96.96,42.42 101.36,42.42 arc(101.55,42.5) 101.64,42.7 101.64,48.06 arc(101.75,48.33) 102.02,48.44 102.13,48.44 arc(102.2,48.48) 102.24,48.55 v2(102.24,48.84)
  03_SIG1 w0.152: 96.72,42.53 85.4,42.53 arc(84.82,42.64) 84.33,42.97 83.1,44.2 arc(82.68,44.48) 82.18,44.58 80.92,44.58 arc(80.37,44.47) 79.91,44.16 arc(79.71,44.04) 79.48,43.99 68.56,43.99 arc(67.94,44.11) 67.41,44.47 62.78,49.1 arc(62.34,49.75) 62.19,50.52 62.19,56.6 arc(62.02,57.43) 61.55,58.14 59.81,59.88 arc(59.02,60.4) 58.09,60.59 49.1,60.59 arc(47.77,60.33) 46.64,59.57 44.11,57.04 arc(43.61,56.3) 43.43,55.41 arc(43.74,54.68) 44.47,54.38 44.75,54.38 arc(44.82,54.37) 44.88,54.33 arc(45.14,54.15) 45.45,54.09 46.11,54.09 arc(46.26,54.12) v9(46.38,54.21)
QSFP2_VCC1_FILT: length 4.2
  TOP w0.305: U123.30 54.7,52.21 v1(55.14,52.65)
  BOTTOM w0.381: C1.1 v1(55.14,52.65)
  vias: v1(44.35,58.85) v1(44.35,58.12) v1(66.75,57.33) v1(66.75,56.49)
QSFP2_VCCRX_FILT: length 2.6
  TOP w0.305: U123.10 v1(48.06,51.01)
  BOTTOM w0.381: C1553.1 48.41,51.01 v1(48.06,51.01)
  vias: v1(45.75,50.29) v1(45.75,48.92) v1(64.52,64.67) v1(65.66,64.64)
QSFP2_VCCTX_FILT: length 2.9
  TOP w0.305: U123.29 53.21,51.41 v1(53.41,51.2)
  BOTTOM w0.381: v1(53.41,51.2) 53.36,51.15 C1552.1
  vias: v1(45.72,53.57) v1(45.69,52.3) v1(63.89,55.33) v1(65.31,55.31)
QSFP_SI570_CLOCK_C_N: length 31.6
  TOP w0.104: C95.1 126.49,32.77 126.49,34.34 v1(126.26,34.57) ; v2(113.24,49.84) U1.W8
  18_SIG6 w0.076: v2(113.24,49.84) 113.24,50.16 113.33,50.25 114.48,50.25 114.66,50.07 114.66,47.17 114.62,47.13 114.62,44.34 114.66,44.3 114.66,41.82 114.62,41.79 114.62,41.78
  18_SIG6 w0.089: v1(126.26,34.57) 126.51,34.83 126.51,34.85 125.88,35.48 125.88,36.12 125.75,36.25 125.55,36.25 125.41,36.11 125.41,35.9 125.28,35.77 125.02,35.77 124.87,35.91 124.87,36.11 124.74,36.25 124.47,36.25 124.34,36.11 124.34,35.95 124.2,35.82 123.93,35.82 123.8,35.95 123.8,36.11 123.66,36.25 123.39,36.25 123.26,36.11 123.26,35.95 123.12,35.82 122.85,35.82 122.72,35.95 122.72,36.11 122.59,36.25 120.86,36.25 118.93,38.18 116.79,38.18 114.62,40.35 114.62,41.78
