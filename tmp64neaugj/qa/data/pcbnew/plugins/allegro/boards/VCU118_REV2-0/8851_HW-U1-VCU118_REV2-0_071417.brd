# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RLD3_C3_72B_DQ70: length 113.7
  TOP w0.152: U1.D26 98.74,68.34 v2(98.24,68.84) ; U142.M3 v2(70.32,121.17)
  16_SIG5 w0.089: 94.39,76.66 94.7,76.34 95.44,76.34 95.74,76.05 95.74,75.64 96.03,75.34 96.44,75.34 96.74,75.05 96.74,74.64 97.03,74.34 97.44,74.34 97.74,74.05 97.74,73.64 98.03,73.34 98.44,73.34 98.74,73.05 98.74,72.64 99.03,72.34 99.44,72.34 99.74,72.05 99.74,69.64 99.44,69.34 98.83,69.34 98.33,68.84 v2(98.24,68.84) ; v2(70.32,121.17) 70.62,121.17 71.12,120.67 71.53,120.67 71.82,120.96 71.82,121.37 72.12,121.67 72.54,121.67 72.82,121.95 72.82,122.4 72.56,122.67 72.12,122.67 71.82,122.96 71.82,123.45 ; 73.89,124.82 74.09,124.61 74.09,123.72 73.84,123.47 73.84,122.97 74.12,122.68 74.49,122.68 74.81,122.37 74.81,121 76.12,119.68 76.63,119.68 76.84,119.47 76.84,118.97 77.12,118.68 77.52,118.68 77.82,118.38 77.82,111.96 77.82,111.96 77.82,109.45 78.46,108.81
  16_SIG5 w0.14: 78.46,108.81 78.59,108.69 82.04,108.69 87.34,103.39 87.34,102.48 89.04,100.78 89.04,99.96 88.58,99.51 88.58,98.74 88.9,98.42 89.23,98.42 91.24,96.41 91.24,94.45 90.35,93.57 90.35,80.7 94.39,76.66 ; 73.89,124.82 71.75,126.95 69.01,126.95 67.28,128.68 65.51,128.68 65.05,129.13 62.64,129.13 62.1,129.67 60.3,129.67 59.74,129.11 59.74,126.53 60.56,125.7 63.6,125.7 64.79,124.52 67.86,124.52 68.41,125.07 70.94,125.07 71.82,124.19 71.82,123.45
RLD3_C3_72B_DQ71: length 113.1
  TOP w0.152: U1.C25 97.74,67.34 v2(97.24,67.84) ; U142.N6 v2(69.32,118.17)
  16_SIG5 w0.089: 68.91,120.65 69.52,120.65 69.81,120.37 69.81,118.97 69.32,118.48 v2(69.32,118.17) ; v2(97.24,67.84) 96.94,67.84 96.44,68.34 96.03,68.34 95.74,68.64 95.74,69.05 95.44,69.34 94.69,69.34 94.6,69.25 94.39,69.25
  16_SIG5 w0.14: 94.39,69.25 92.69,69.25 86.57,75.37 85.05,75.37 83.81,76.61 83.81,85.11 83.46,85.46 82.77,85.46 81.64,86.6 81.64,94.23 81.37,94.5 77.12,94.5 76.89,94.73 76.89,95.26 77.17,95.54 81.37,95.54 81.64,95.8 81.64,98.86 81.39,99.11 74.8,99.11 74.06,99.85 74.06,100.69 73.78,100.97 72.42,100.97 71.72,101.67 71.06,101.67 71.05,101.67 65.29,101.67 64.22,102.74 64.22,106.37 62.79,107.8 60.96,107.8 59.63,109.13 59.63,116.07 58.17,117.53 58.17,117.98 56.67,119.48 56.67,120.3 56.98,120.6 56.98,122.25 57.23,122.5 57.84,122.5 57.99,122.35 57.99,121.57 58.22,121.34 58.86,121.34 59.38,121.86 59.38,122.48 59.64,122.74 61.62,122.74 61.67,122.8 62,123.13 62.5,123.13 64.16,121.46 67.97,121.46 68.78,120.65 68.91,120.65
RLD3_C3_72B_QK0_N: length 142.7
  TOP w0.145: U141.E8 v2(95.23,119.32) ; U1.J40 v2(103.24,82.84)
  20_SIG7 w0.107: v2(95.23,119.32) 95.6,119.32 95.78,119.49 95.78,119.67 95.95,119.84 96.39,119.84 96.63,119.6 96.63,118.95 96.85,118.72 102.03,118.72 102.08,118.67 102.11,118.67
  20_SIG7 w0.13: v2(103.24,82.84) 103.24,82.39 103.31,82.32 103.57,82.32 103.71,82.46 103.71,82.95 104.11,83.34 104.49,83.34 104.77,83.63 104.77,84.05 105.04,84.32 105.37,84.32 105.72,84.66 105.72,85.06 105.99,85.34 106.56,85.34 106.79,85.56 106.79,86.09 107.05,86.36 107.48,86.36 107.8,86.67 107.8,87.17 107.99,87.36 108.4,87.36 108.64,87.6 108.64,89.09
  20_SIG7 w0.14: 102.11,118.67 102.93,118.67 103.19,118.94 103.19,119.29 103.38,119.48 104.77,119.48 105.73,120.44 105.73,120.95 105.41,121.26 104.6,121.26 104.46,121.4 104.46,121.68 104.6,121.82 105.41,121.82 105.73,122.14 105.73,122.67 105.41,122.99 104.6,122.99 104.46,123.13 104.46,123.41 104.6,123.55 105.41,123.55 105.73,123.87 105.73,125.99 106.29,126.55 106.29,132.31 106.77,132.78 107.64,132.78 107.78,132.65 107.78,132.32 108.09,132 108.63,132 108.94,132.32 108.94,132.65 109.08,132.78 109.79,132.78 115.02,127.55 115.02,127.35 114.61,126.94 114.61,126.49 114.98,126.11 115.43,126.11 115.85,126.53 116.04,126.53 116.56,126.01 116.56,125.62 117.45,124.73 117.45,124.23 117.24,124.02 116.72,124.02 116.58,124.16 116.58,124.74 116.26,125.05 115.73,125.05 115.41,124.74 115.41,124.16 115.27,124.02 114.73,124.02 114.54,124.22 114.54,124.98 114.22,125.3 113.61,125.3 113.28,124.97 113.28,121.26 113.67,120.88 115.44,120.88 115.65,120.68 115.65,120.36 115.97,120.03 116.63,120.03 116.95,120.35 116.95,121.74 116.53,122.15 115.75,122.15 115.52,122.38 115.52,122.63 115.67,122.78 116.97,122.78 117.7,122.05 117.7,120.13 117.04,119.46 117.04,119.03 116.86,118.85 115.85,118.85 115.47,118.47 115.47,117.96 115.81,117.61 116.86,117.61 117.04,117.43 117.04,117.17 116.86,116.99 115.77,116.99 115.36,116.59 115.36,116.08 115.69,115.75 116.86,115.75 117.04,115.57 117.04,114.87 116.63,114.46 116.63,111.23 117.73,110.13 117.73,102.77 118.22,102.29 118.39,102.29 118.64,102.03 118.64,101.32 117.92,100.6 117.92,100.12 118.73,99.31 118.73,98.85 118.38,98.49 116.24,98.49 115.19,97.44 115.19,94.64 115.07,94.52 114.87,94.52 113.7,95.69 113.25,95.69 112.88,95.32 112.88,94.87 114.05,93.7 114.05,93.5 113.05,92.5 112.85,92.5 112.45,92.9 112,92.9 111.63,92.52 111.63,92.07 112.03,91.67 112.03,91.48 111.83,91.29 110.57,91.29 110.41,91.44 110.41,93.28 110.64,93.5 112.09,93.5 112.4,93.81 112.4,94.45 111.99,94.87 109.55,94.87 109.07,94.39 109.07,89.52 108.64,89.09
RLD3_C3_72B_QK0_P: length 142.5
  TOP w0.145: U1.J39 v2(103.24,81.84) ; U141.D9 v2(96.23,120.32)
  20_SIG7 w0.107: 102.11,118.98 102.08,118.98 102.03,118.93 96.94,118.93 96.83,119.03 96.83,119.69 96.23,120.29 v2(96.23,120.32)
  20_SIG7 w0.13: v2(103.24,81.84) 103.51,81.84 104.04,82.37 104.41,82.37 104.76,82.73 104.76,83.1 105.05,83.38 105.5,83.38 105.78,83.66 105.78,84.05 106.07,84.34 106.45,84.34 106.78,84.68 106.78,85.03 107.1,85.35 107.43,85.35 107.75,85.67 107.75,86.11 108.04,86.39 108.5,86.39 108.78,86.67 108.78,86.98 109.06,87.26 109.38,87.26 109.8,87.68 109.8,89.09
  20_SIG7 w0.14: 102.11,118.98 102.8,118.98 102.89,119.06 102.89,119.42 103.26,119.79 104.65,119.79 105.42,120.56 105.42,120.82 105.28,120.96 104.48,120.96 104.16,121.28 104.16,121.81 104.48,122.13 105.28,122.13 105.42,122.27 105.42,122.55 105.28,122.69 104.48,122.69 104.16,123 104.16,123.54 104.48,123.85 105.28,123.85 105.42,123.99 105.42,126.12 105.98,126.68 105.98,132.43 106.64,133.09 107.76,133.09 108.08,132.77 108.08,132.45 108.22,132.31 108.5,132.31 108.64,132.45 108.64,132.77 108.96,133.09 109.91,133.09 115.32,127.68 115.32,127.23 114.91,126.81 114.91,126.61 115.11,126.42 115.31,126.42 115.72,126.83 116.17,126.83 116.87,126.14 116.87,125.75 117.75,124.86 117.75,124.1 117.37,123.72 116.6,123.72 116.28,124.04 116.28,124.61 116.14,124.75 115.86,124.75 115.72,124.61 115.72,124.04 115.4,123.72 114.61,123.72 114.23,124.09 114.23,124.86 114.1,124.99 113.74,124.99 113.59,124.84 113.59,121.39 113.79,121.18 115.57,121.18 115.95,120.8 115.95,120.48 116.1,120.34 116.5,120.34 116.64,120.48 116.64,121.61 116.41,121.84 115.62,121.84 115.21,122.25 115.21,122.76 115.54,123.09 117.09,123.09 118.01,122.17 118.01,120 117.35,119.34 117.35,118.91 116.98,118.54 115.98,118.54 115.78,118.34 115.78,118.08 115.94,117.92 116.98,117.92 117.35,117.56 117.35,117.05 116.98,116.68 115.89,116.68 115.67,116.46 115.67,116.2 115.81,116.06 116.98,116.06 117.35,115.7 117.35,114.74 116.94,114.33 116.94,111.36 118.04,110.26 118.04,102.9 118.35,102.59 118.52,102.59 118.95,102.16 118.95,101.19 118.23,100.47 118.23,100.24 119.04,99.43 119.04,98.72 118.51,98.19 116.37,98.19 115.5,97.32 115.5,94.52 115.2,94.22 114.75,94.22 113.58,95.39 113.38,95.39 113.18,95.19 113.18,94.99 114.35,93.82 114.35,93.37 113.18,92.2 112.73,92.2 112.33,92.59 112.13,92.59 111.93,92.4 111.93,92.2 112.33,91.8 112.33,91.35 111.96,90.98 110.44,90.98 110.11,91.32 110.11,93.4 110.51,93.8 111.97,93.8 112.1,93.94 112.1,94.33 111.86,94.56 109.68,94.56 109.37,94.26 109.37,89.52 109.8,89.09
RLD3_C3_72B_QK1_N: length 144.3
  TOP w0.145: U141.J8 v2(95.23,114.32) ; v2(99.24,76.84) U1.E34
  18_SIG6 w0.107: 101.74,84.55 101.74,84.34 101.62,84.22 101.62,83.68 101.4,83.46 100.96,83.46 100.63,83.13 100.63,82.63 100.45,82.44 99.95,82.44 99.64,82.13 99.64,81.65 99.43,81.44 98.92,81.44 98.64,81.16 98.64,80.63 98.45,80.44 97.95,80.44 97.64,80.13 97.64,78.52 97.92,78.24 98.45,78.24 98.64,78.05 98.64,77.55 98.94,77.24 99.49,77.24 99.64,77.1 99.64,76.95 99.53,76.84 v2(99.24,76.84) ; 94.43,113.06 94.43,113.08 94.45,113.11 94.45,113.48 94.89,113.92 95.65,113.92 95.78,114.05 95.78,114.34 95.69,114.43 95.33,114.43 v2(95.23,114.32)
  18_SIG6 w0.108: 94.43,113.06 94.43,109.08 94.99,108.52 94.99,108.48 95.01,108.46
  18_SIG6 w0.13: 103.74,89.08 103.74,88.64 103.44,88.34 102.85,88.34 102.7,88.19 102.7,87.59 102.43,87.32 101.96,87.32 101.74,87.1 101.74,84.55
  18_SIG6 w0.14: 103.74,89.08 104.09,89.43 104.09,89.72 104.52,90.14 105.72,90.14 105.9,90.32 105.9,90.65 105.64,90.91 104.71,90.91 104.44,91.17 104.44,91.71 104.8,92.07 106.17,92.07 106.33,92.23 106.33,92.81 106.1,93.04 104.8,93.04 104.55,93.29 104.55,93.95 104.83,94.23 105.64,94.23 105.9,94.49 105.9,94.82 105.41,95.3 103.15,95.3 102.97,95.12 102.97,94.39 103.05,94.31 103.43,94.31 103.81,93.93 103.81,93.22 103.4,92.81 103.11,92.81 102.97,92.68 102.97,92.15 103.07,92.05 103.4,92.05 103.81,91.64 103.81,90.4 102.77,89.36 101.19,89.36 100.36,90.2 100.36,91.12 101.63,92.4 101.63,94.58 101.42,94.79 100.02,94.79 99.63,95.18 99.63,95.84 100.02,96.23 101.94,96.23 102.12,96.41 102.12,96.83 101.88,97.06 100.47,97.06 100.11,97.43 100.11,99.72 99.94,99.88 99.88,99.88 99.49,100.27 99.49,100.94 99.88,101.33 99.94,101.33 100.15,101.53 100.15,104.49 100.6,104.94 102.09,104.94 102.77,104.26 103.6,104.26 103.89,104.56 103.89,104.79 102.94,105.75 102.94,106.25 103.38,106.69 103.86,106.69 105.12,105.43 105.37,105.43 105.78,105.84 105.78,106.12 105.08,106.82 105.08,107.79 106.7,109.41 106.7,110.61 107.95,111.86 107.95,112.86 108.5,113.42 108.5,113.91 107.99,114.43 107.99,115.17 108.5,115.69 108.5,116.19 107.99,116.7 107.99,121.03 107.59,121.43 107.07,121.43 106.4,122.1 106.4,122.78 104.88,124.3 104.6,124.3 104.42,124.11 104.42,123.19 104.64,122.96 105.33,122.96 105.69,122.61 105.69,121.95 105.12,121.38 105.12,120.57 105.98,119.71 106.45,119.71 106.83,119.33 106.83,118.66 106.45,118.27 105.7,118.27 105.51,118.08 105.51,117.04 105.74,116.81 106.69,116.81 107.08,116.42 107.08,115.75 106.69,115.37 105.74,115.37 105.59,115.22 105.59,114.8 106.34,114.05 106.77,114.05 107.2,113.62 107.2,112.72 106.81,112.33 105.98,112.33 105.78,112.12 105.78,110.31 101.27,105.8 100.72,105.8 100.41,106.12 100.41,106.5 100.28,106.63 99.75,106.63 99.64,106.53 99.64,106.15 99.3,105.8 98.72,105.8 98.17,106.35 97.46,106.35 96.97,106.84 96.97,107.36 96.51,107.82 95.65,107.82 95.01,108.46
RLD3_C3_72B_QK1_P: length 144.1
  TOP w0.145: v2(100.24,76.84) U1.F34 ; U141.K9 v2(96.23,113.32)
  18_SIG6 w0.107: 101.96,84.28 101.82,84.14 101.82,83.6 101.48,83.26 101.05,83.26 100.84,83.05 100.84,82.55 100.53,82.24 100.04,82.24 99.84,82.04 99.84,81.57 99.51,81.24 99,81.24 98.84,81.08 98.84,80.55 98.53,80.24 98.04,80.24 97.84,80.04 97.84,78.6 98,78.44 98.53,78.44 98.84,78.13 98.84,77.63 99.03,77.45 99.58,77.45 99.84,77.18 99.84,76.95 99.95,76.84 v2(100.24,76.84) ; 94.68,113.06 94.68,113.08 94.65,113.11 94.65,113.39 94.98,113.72 95.83,113.72 v2(96.23,113.32)
  18_SIG6 w0.108: 95.23,108.67 95.21,108.69 95.17,108.69 94.68,109.18 94.68,113.06
  18_SIG6 w0.13: 104.74,89.05 104.74,88.64 104.44,88.34 104.03,88.34 103.74,88.05 103.74,87.64 103.44,87.34 103.03,87.34 102.74,87.05 102.74,84.5 102.58,84.34 102.03,84.34 101.96,84.28
  18_SIG6 w0.14: 95.23,108.67 95.78,108.12 96.64,108.12 97.28,107.49 97.28,106.97 97.58,106.66 98.3,106.66 98.84,106.11 99.18,106.11 99.34,106.27 99.34,106.65 99.62,106.93 100.41,106.93 100.71,106.63 100.71,106.25 100.85,106.11 101.15,106.11 105.47,110.43 105.47,112.25 105.86,112.64 106.68,112.64 106.89,112.84 106.89,113.5 106.64,113.75 106.21,113.75 105.29,114.67 105.29,115.35 105.61,115.67 106.57,115.67 106.77,115.88 106.77,116.3 106.56,116.51 105.61,116.51 105.21,116.91 105.21,118.21 105.57,118.58 106.32,118.58 106.53,118.78 106.53,119.2 106.32,119.41 105.86,119.41 104.82,120.45 104.82,121.51 105.38,122.07 105.38,122.48 105.21,122.66 104.52,122.66 104.11,123.06 104.11,124.24 104.48,124.6 105,124.6 106.7,122.9 106.7,122.23 107.2,121.73 107.71,121.73 108.29,121.15 108.29,116.83 108.81,116.31 108.81,115.56 108.29,115.05 108.29,114.55 108.81,114.04 108.81,113.29 108.26,112.74 108.26,111.74 107,110.48 107,109.28 105.38,107.66 105.38,106.95 106.08,106.25 106.08,105.72 105.5,105.13 104.99,105.13 103.73,106.39 103.5,106.39 103.24,106.13 103.24,105.87 104.2,104.92 104.2,104.43 103.72,103.96 102.64,103.96 101.97,104.63 100.73,104.63 100.45,104.36 100.45,101.41 100.07,101.02 100,101.02 99.8,100.81 99.8,100.4 100,100.19 100.07,100.19 100.41,99.84 100.41,97.56 100.6,97.37 102.01,97.37 102.43,96.95 102.43,96.28 102.07,95.93 100.15,95.93 99.94,95.72 99.94,95.3 100.15,95.09 101.55,95.09 101.93,94.71 101.93,92.27 100.66,91 100.66,90.32 101.32,89.66 102.64,89.66 103.5,90.53 103.5,91.52 103.28,91.74 102.95,91.74 102.67,92.02 102.67,92.8 102.98,93.12 103.28,93.12 103.5,93.34 103.5,93.8 103.3,94.01 102.92,94.01 102.67,94.26 102.67,95.25 103.02,95.61 105.54,95.61 106.2,94.94 106.2,94.36 105.77,93.93 104.95,93.93 104.85,93.83 104.85,93.42 104.93,93.34 106.22,93.34 106.63,92.94 106.63,92.1 106.3,91.77 104.93,91.77 104.75,91.59 104.75,91.29 104.83,91.21 105.76,91.21 106.2,90.78 106.2,90.2 105.84,89.84 104.65,89.84 104.4,89.59 104.4,89.39 104.74,89.05
RLD3_C3_72B_QK2_N: length 141.3
  TOP w0.145: v2(98.24,81.84) 98.74,81.34 U1.D39 ; U141.E6 v2(92.23,119.32)
  16_SIG5 w0.107: 96.84,109.32 96.2,109.32 96.18,109.34 95.98,109.34 95.6,109.72 94.55,109.72 93.55,110.72 91.97,110.72 91.63,111.06 91.63,115.96 92.62,116.96 92.62,119.56 92.45,119.73 91.78,119.73 91.71,119.66 91.71,119.42 91.82,119.32 v2(92.23,119.32)
  16_SIG5 w0.108: 98.16,108.46 98.14,108.48 98.14,108.52 97.34,109.32 96.84,109.32
  16_SIG5 w0.13: v2(98.24,81.84) 98.63,81.84 98.73,81.94 98.73,89.16 98.85,89.28
  16_SIG5 w0.14: 98.85,89.28 99.04,89.46 99.04,90.45 100.27,91.68 101.63,93.04 101.63,94.56 101.42,94.77 101.28,94.77 100.89,95.15 100.89,95.82 101.28,96.21 101.87,96.21 102.03,96.37 102.03,96.78 101.77,97.04 101.28,97.04 100.89,97.43 100.89,98.1 101.28,98.49 101.42,98.49 101.63,98.69 101.63,99.68 102.01,100.07 102.09,100.07 102.34,100.31 102.34,100.7 102.13,100.9 102.01,100.9 101.63,101.29 101.63,102.11 101.37,102.36 100.75,102.36 100.15,102.96 100.15,103.69 100.47,104.01 103.19,104.01 106.17,106.99 106.17,109.68 106.02,109.84 105.26,109.84 104.96,110.14 104.96,111.35 106.28,112.67 108.41,112.67 108.58,112.84 108.58,113.16 108.43,113.31 106.62,113.31 106.22,113.7 106.22,114.65 106.58,115.01 108.32,115.01 108.56,115.24 108.56,115.88 108.37,116.07 105.98,116.07 105.46,116.59 105.46,118.21 105.97,118.72 106.54,118.72 106.86,118.4 106.86,118.16 107.19,117.83 108.34,117.83 108.58,118.07 108.58,119.8 108.45,119.94 107.73,119.94 107.42,120.26 107.42,120.93 107.73,121.25 108.45,121.25 108.58,121.39 108.58,121.86 108.41,122.04 108.35,122.04 107.96,122.43 107.96,123.1 108.58,123.72 108.58,126.64 106.92,128.31 106.72,128.31 106.4,127.99 105.95,127.99 105.57,128.36 105.57,128.81 105.9,129.13 105.9,129.33 105.73,129.5 105.01,129.5 104.84,129.33 104.84,128.24 104.07,127.47 103.37,127.47 103.23,127.33 103.23,126.25 102.91,125.93 102.38,125.93 102.06,126.25 102.06,127.33 101.92,127.47 101.23,127.47 100.73,126.97 100.73,125.53 100.87,125.39 104.25,125.39 104.55,125.09 104.55,124.26 104.04,123.75 103.4,123.75 102.97,123.32 101.27,123.32 101.09,123.14 101.09,122.48 101.27,122.3 102.23,122.3 102.69,121.84 102.69,120.87 102.11,120.28 102.11,119.9 102.69,119.32 102.69,118.64 102.11,118.05 102.11,117.62 102.69,117.04 102.69,116.36 102.11,115.78 102.11,115.35 102.69,114.76 102.69,114 102.08,113.39 102.08,112.99 102.69,112.38 102.69,111.72 102.08,111.12 102.08,110.71 102.66,110.13 102.66,107.59 101.7,106.63 99.21,106.63 98.48,107.37 98.48,108.14 98.16,108.46
RLD3_C3_72B_QK2_P: length 141.5
  TOP w0.145: U141.D5 v2(91.23,120.32) ; U1.E39 v2(99.24,81.84)
  16_SIG5 w0.107: 96.84,109.56 96.2,109.56 96.18,109.54 96.07,109.54 95.69,109.92 94.64,109.92 93.63,110.93 92.05,110.93 91.83,111.15 91.83,115.88 92.83,116.87 92.83,119.64 92.54,119.93 91.62,119.93 v2(91.23,120.32)
  16_SIG5 w0.108: 98.37,108.67 98.35,108.69 98.31,108.69 97.44,109.56 96.84,109.56
  16_SIG5 w0.13: v2(99.24,81.84) 99.24,82.14 99.73,82.64 99.73,89.17 99.56,89.35
  16_SIG5 w0.14: 98.37,108.67 98.78,108.26 98.78,107.49 99.34,106.93 101.57,106.93 102.36,107.72 102.36,109.96 101.75,110.57 101.75,111.21 102.39,111.85 102.39,112.21 101.75,112.85 101.75,113.49 102.39,114.13 102.39,114.64 101.77,115.25 101.77,115.87 102.39,116.49 102.39,116.91 101.77,117.53 101.77,118.15 102.39,118.76 102.39,119.19 101.77,119.8 101.77,120.42 102.39,121.04 102.39,121.72 102.11,122 101.14,122 100.79,122.35 100.79,123.31 101.1,123.63 102.85,123.63 103.27,124.05 103.91,124.05 104.25,124.39 104.25,124.96 104.12,125.09 100.74,125.09 100.42,125.41 100.42,127.09 101.1,127.77 102.05,127.77 102.37,127.46 102.37,126.38 102.51,126.24 102.79,126.24 102.92,126.38 102.92,127.46 103.24,127.77 103.95,127.77 104.54,128.36 104.54,129.45 104.88,129.8 105.86,129.8 106.2,129.46 106.2,129.01 105.88,128.69 105.88,128.49 106.08,128.29 106.27,128.29 106.6,128.61 107.05,128.61 108.89,126.77 108.89,123.59 108.26,122.97 108.26,122.55 108.47,122.34 108.53,122.34 108.89,121.99 108.89,121.26 108.57,120.94 107.86,120.94 107.72,120.8 107.72,120.39 107.86,120.25 108.57,120.25 108.89,119.93 108.89,117.95 108.47,117.53 107.06,117.53 106.55,118.03 106.55,118.28 106.41,118.41 106.09,118.41 105.76,118.08 105.76,116.72 106.1,116.37 108.49,116.37 108.86,116 108.86,115.11 108.45,114.7 106.71,114.7 106.53,114.52 106.53,113.83 106.74,113.61 108.56,113.61 108.89,113.28 108.89,112.72 108.54,112.37 106.41,112.37 105.26,111.22 105.26,110.27 105.39,110.14 106.14,110.14 106.47,109.81 106.47,106.86 103.32,103.71 100.6,103.71 100.46,103.57 100.46,103.09 100.88,102.67 101.5,102.67 101.93,102.23 101.93,101.42 102.14,101.21 102.25,101.21 102.64,100.82 102.64,100.19 102.22,99.77 102.14,99.77 101.93,99.56 101.93,98.57 101.54,98.18 101.4,98.18 101.19,97.97 101.19,97.56 101.4,97.35 101.9,97.35 102.34,96.91 102.34,96.24 102,95.91 101.4,95.91 101.19,95.7 101.19,95.28 101.4,95.07 101.54,95.07 101.93,94.69 101.93,92.91 99.34,90.32 99.34,89.57 99.56,89.35
RLD3_C3_72B_QK3_N: length 142.8
  TOP w0.145: U141.J6 v2(92.23,114.32) ; U1.C37 v2(97.24,79.84)
  14_SIG4 w0.107: v2(97.24,79.84) 97.84,79.24 99.49,79.24 99.84,79.59 99.84,82.1 99.98,82.24 100.5,82.24 100.84,82.58 100.84,83.1 101,83.26 101.48,83.26 101.85,83.62 101.85,84.08 101.92,84.16 ; 101.73,112.6 101.73,112.57 101.78,112.52 101.78,112.12 101.59,111.92 94.56,111.92 93.93,112.56 93.93,113.66 93.67,113.92 92.63,113.92 v2(92.23,114.32)
  14_SIG4 w0.13: 104.38,89.44 104.67,89.16 104.67,86.64 104.4,86.38 104.05,86.38 103.67,86 103.67,85.65 103.36,85.34 103.06,85.34 102.79,85.07 102.79,84.68 102.43,84.33 102.09,84.33 101.92,84.16
  14_SIG4 w0.14: 104.38,89.44 104.38,89.78 105.61,91 105.61,92.68 107.16,94.24 107.16,95.81 105.71,97.26 105.71,98.35 104.95,99.11 104.95,99.59 106.63,101.27 106.63,101.96 108.03,103.35 108.03,104.14 108.63,104.74 109.61,104.74 110.19,105.32 110.19,107.19 109.91,107.47 109.91,107.98 111.92,109.99 111.92,112.45 112.78,113.31 112.78,123.26 104.66,131.38 102.52,131.38 102.28,131.61 102.28,132.25 101.91,132.63 101.24,132.63 100.92,132.31 100.92,131.51 100.77,131.37 100.49,131.37 100.36,131.5 100.36,132.31 100.04,132.63 99.51,132.63 99.19,132.31 99.19,131.83 99.05,131.69 98.77,131.69 98.63,131.83 98.63,132.31 98.31,132.63 96.88,132.63 96.57,132.31 96.57,131.87 96.43,131.73 96.15,131.73 96.01,131.87 96.01,132.31 95.69,132.63 95.16,132.63 94.84,132.31 94.84,131.87 94.7,131.73 94.42,131.73 94.28,131.87 94.28,132.31 93.96,132.63 91.69,132.63 90.18,131.11 89.33,131.11 88.47,130.25 88.47,127.99 88.3,127.82 83.94,127.82 83.59,127.47 83.59,126.87 84.02,126.44 88.92,126.44 89.77,125.59 92.57,125.59 92.84,125.32 92.84,124.71 93.73,123.83 100.46,123.83 100.93,123.36 100.93,122.49 101.73,121.69 101.73,112.6
RLD3_C3_72B_QK3_P: length 142.9
  TOP w0.145: U141.K5 v2(91.23,113.32) ; U1.D37 v2(98.24,79.84)
  14_SIG4 w0.107: v2(98.24,79.84) 98.12,79.96 97.8,79.96 97.68,79.84 97.68,79.68 97.92,79.44 99.41,79.44 99.64,79.67 99.64,82.18 99.9,82.44 100.41,82.44 100.64,82.67 100.64,83.18 100.92,83.46 101.4,83.46 101.64,83.71 101.64,84.34 ; v2(91.23,113.32) 91.38,113.32 91.98,113.92 92.35,113.92 92.54,113.72 93.58,113.72 93.73,113.58 93.73,112.47 94.48,111.72 101.67,111.72 101.99,112.03 101.99,112.52 102.04,112.57 102.04,112.6 ; 93.38,124.6 93.85,124.13
  14_SIG4 w0.13: 104.08,89.44 103.76,89.12 103.76,86.64 103.43,86.32 102.98,86.32 102.79,86.13 102.79,85.61 102.53,85.34 101.98,85.34 101.64,85.01 101.64,84.34
  14_SIG4 w0.14: 104.08,89.44 104.08,89.91 105.3,91.13 105.3,92.81 106.86,94.36 106.86,95.69 105.41,97.14 105.41,98.22 104.65,98.98 104.65,99.72 106.32,101.4 106.32,102.08 107.72,103.48 107.72,104.27 108.5,105.05 109.49,105.05 109.89,105.45 109.89,107.06 109.61,107.34 109.61,108.11 111.61,110.11 111.61,112.57 112.47,113.43 112.47,123.14 104.54,131.07 102.4,131.07 101.98,131.49 101.98,132.12 101.78,132.32 101.36,132.32 101.22,132.18 101.22,131.38 100.9,131.06 100.37,131.06 100.05,131.38 100.05,132.18 99.91,132.32 99.63,132.32 99.49,132.18 99.49,131.71 99.18,131.39 98.64,131.39 98.33,131.71 98.33,132.18 98.19,132.32 97.01,132.32 96.87,132.18 96.87,131.75 96.55,131.43 96.02,131.43 95.7,131.75 95.7,132.18 95.56,132.32 95.28,132.32 95.14,132.18 95.14,131.75 94.82,131.43 94.29,131.43 93.97,131.75 93.97,132.18 93.83,132.32 91.81,132.32 90.3,130.81 89.46,130.81 88.77,130.12 88.77,127.86 88.42,127.52 84.07,127.52 83.89,127.34 83.89,127 84.14,126.75 89.05,126.75 89.89,125.9 92.7,125.9 93.15,125.45 93.15,124.84 93.38,124.6 ; 102.04,112.6 102.04,121.81 101.23,122.62 101.23,123.48 100.58,124.13 93.85,124.13
RLD3_C3_72B_QK4_N: length 122.2
  TOP w0.145: U1.R26 109.74,68.34 v2(109.24,68.84) ; U142.E8 v2(78.32,115.17)
  14_SIG4 w0.107: v2(109.24,68.84) 109.29,68.84 109.9,69.45 110.51,69.45 110.84,69.12 110.84,66.28 109.84,65.28 109.84,64.54 109.54,64.24 109.02,64.24 108.84,64.06 108.84,62.55 108.53,62.24 94.97,62.24 94.65,62.56 94.43,62.56 94.39,62.52 ; v2(78.32,115.17) 78.72,114.77 78.72,113.99 78.5,113.77 75.96,113.77 75.62,113.42 75.62,109.62 75.05,109.05 74.98,109.05
  14_SIG4 w0.14: 94.39,62.52 92.71,62.52 91.83,61.65 86.74,61.65 85.89,62.5 82.38,62.5 81.65,63.23 81.65,65.84 80.89,66.6 72.7,66.6 71.3,68 71.3,70.51 70.89,70.92 68.17,70.92 67.41,71.68 67.41,89.56 66.01,90.96 66.01,97.13 65.46,97.69 65.46,101.85 64.85,102.46 64.85,106.34 65.36,106.85 68.86,106.85 70.72,108.71 71.7,108.71 72.06,108.35 72.06,105.73 72.18,105.6 72.52,105.6 72.7,105.78 72.7,108.23 73.08,108.61 74.54,108.61 74.98,109.05
RLD3_C3_72B_QK4_P: length 122.1
  TOP w0.145: v2(110.24,68.84) 110.74,68.34 U1.T26 ; U142.D9 v2(79.32,114.17)
  14_SIG4 w0.107: 75.17,108.81 75.19,108.83 75.19,108.9 75.25,108.96 75.41,108.96 75.63,108.74 75.78,108.74 75.93,108.89 75.93,109.04 75.71,109.26 75.71,109.42 75.82,109.53 75.82,113.34 76.04,113.57 78.59,113.57 78.92,113.9 78.92,114.65 79.03,114.76 79.18,114.76 ; v2(110.24,68.84) 109.8,68.84 109.74,68.9 109.74,69.01 109.98,69.24 110.43,69.24 110.64,69.04 110.64,66.36 110.36,66.08 110.16,66.08 109.92,65.85 109.92,65.65 109.64,65.36 109.64,64.62 109.46,64.44 108.93,64.44 108.64,64.15 108.64,62.64 108.44,62.44 95.05,62.44 94.73,62.76 94.46,62.76 94.4,62.83 94.39,62.83
  14_SIG4 w0.108: 79.18,114.76 79.32,114.62 v2(79.32,114.17)
  14_SIG4 w0.14: 94.39,62.83 92.58,62.83 91.71,61.95 86.87,61.95 86.02,62.8 82.51,62.8 81.96,63.36 81.96,65.96 81.01,66.9 72.82,66.9 71.6,68.12 71.6,70.64 71.02,71.22 68.3,71.22 67.72,71.81 67.72,89.69 66.32,91.08 66.32,97.26 65.76,97.82 65.76,101.98 65.15,102.59 65.15,106.21 65.49,106.55 68.99,106.55 70.85,108.41 71.57,108.41 71.75,108.23 71.75,105.6 72.05,105.3 72.65,105.3 73,105.65 73,108.11 73.2,108.31 74.67,108.31 75.17,108.81
RLD3_C3_72B_QK5_N: length 117.3
  TOP w0.145: v2(106.24,70.84) 106.74,70.34 U1.M28 ; v2(73.32,115.17) U142.J8
  20_SIG7 w0.107: 94.39,77.19 94.4,77.19 94.45,77.24 95.42,77.24 95.64,77.02 95.64,75.58 95.98,75.24 96.44,75.24 96.63,75.04 96.63,74.56 96.95,74.24 97.44,74.24 97.64,74.04 97.64,73.58 97.98,73.24 98.46,73.24 98.64,73.07 98.64,72.61 99.01,72.24 106.53,72.24 106.64,72.13 106.64,70.53 106.46,70.36 106.3,70.36 106.24,70.42 v2(106.24,70.84) ; 77.97,124.82 77.97,123.71 77.92,123.66 77.92,121.83 77.66,121.56 75.7,121.56 75.54,121.4 75.54,117.36 75.28,117.11 75.28,116.95 75.44,116.8 75.44,116.65 75.28,116.5 75.13,116.5 74.98,116.65 74.83,116.65 74.55,116.37 74.15,116.37 74.05,116.27 74.05,115.92 73.94,115.81 73.73,115.81 73.62,115.92 73.62,116.27 73.51,116.37 73.16,116.37 72.93,116.15 72.93,115.18 73.04,115.07 73.23,115.07 v2(73.32,115.17)
  20_SIG7 w0.14: 77.97,124.82 77.97,125.81 76.73,127.05 76.73,128.17 77.48,128.92 78.88,128.92 79.02,128.78 79.02,127.46 79.34,127.14 80.01,127.14 80.4,127.53 83.38,127.53 83.52,127.39 83.52,125.32 84.36,124.48 84.36,108.28 87.26,105.38 90.47,105.38 92.17,103.68 92.17,98.97 92.05,98.85 92.05,98.06 92.37,97.74 93.75,97.74 93.88,97.6 93.88,97.18 93.75,97.04 92.37,97.04 92.05,96.72 92.05,94.45 92.37,94.13 93.71,94.13 93.85,93.99 93.85,93.58 93.71,93.44 92.37,93.44 92.05,93.12 92.05,92.5 92.37,92.18 93.77,92.18 93.89,92.06 93.89,91.64 93.73,91.48 91.73,91.48 91.4,91.15 91.4,90.52 91.72,90.21 92.31,90.21 92.45,90.07 92.45,89.65 92.31,89.51 91.72,89.51 91.4,89.19 91.4,79.28 93.49,77.19 94.39,77.19
RLD3_C3_72B_QK5_P: length 117.4
  TOP w0.145: v2(106.24,69.84) 106.74,69.34 U1.M27 ; U142.K9 v2(72.32,114.17)
  20_SIG7 w0.107: 77.67,124.82 77.69,124.79 77.69,123.73 77.67,123.71 77.67,123.7 77.72,123.65 77.72,121.91 77.57,121.77 75.62,121.77 75.34,121.48 75.34,117.45 74.47,116.58 73.07,116.58 72.73,116.23 72.73,114.57 v2(72.32,114.17) ; 94.39,77.49 94.44,77.44 95.5,77.44 95.84,77.1 95.84,75.67 96.06,75.44 96.52,75.44 96.84,75.13 96.84,74.65 97.04,74.44 97.52,74.44 97.84,74.13 97.84,73.67 98.06,73.44 98.55,73.44 98.84,73.15 98.84,72.7 99.09,72.44 106.61,72.44 106.84,72.22 106.84,70.44 v2(106.24,69.84)
  20_SIG7 w0.14: 94.39,77.49 93.61,77.49 91.71,79.4 91.71,89.06 91.85,89.2 92.44,89.2 92.75,89.52 92.75,90.19 92.44,90.51 91.85,90.51 91.71,90.65 91.71,91.02 91.86,91.18 93.85,91.18 94.19,91.52 94.19,92.19 93.89,92.49 92.49,92.49 92.35,92.63 92.35,92.99 92.49,93.13 93.84,93.13 94.16,93.45 94.16,94.12 93.84,94.44 92.49,94.44 92.35,94.58 92.35,96.59 92.49,96.73 93.87,96.73 94.19,97.05 94.19,97.72 93.87,98.04 92.49,98.04 92.35,98.18 92.35,98.72 92.48,98.85 92.48,103.8 90.6,105.69 87.39,105.69 84.66,108.41 84.66,124.61 83.82,125.45 83.82,127.52 83.5,127.84 80.28,127.84 79.89,127.45 79.47,127.45 79.33,127.59 79.33,128.91 79.01,129.22 77.36,129.22 76.43,128.29 76.43,126.92 77.67,125.69 77.67,124.82
RLD3_C3_72B_QK6_N: length 113.1
  TOP w0.145: U142.E6 v2(78.32,118.17) ; U1.F26 v2(100.24,68.84)
  18_SIG6 w0.107: 94.39,68.23 94.41,68.23 94.46,68.18 94.64,68.18 94.9,68.44 100.51,68.44 100.7,68.64 100.7,69.29 100.59,69.4 100.09,69.4 99.98,69.28 99.98,69.1 v2(100.24,68.84) ; 76.97,108.81 76.97,108.84 76.92,108.89 76.92,117.43 77.06,117.57 77.69,117.57 77.92,117.79 77.92,118.34 78.15,118.57 78.45,118.57 78.55,118.47 78.55,118.28 78.45,118.17 v2(78.32,118.17)
  18_SIG6 w0.14: 76.97,108.81 76.97,108.38 76.43,107.83 73.69,107.83 73.31,108.22 73.31,108.74 73.1,108.95 72.68,108.95 72.47,108.74 72.47,108.22 72.09,107.83 71.4,107.83 71.03,108.2 71.03,108.74 70.82,108.95 70.41,108.95 70.2,108.74 70.2,108.22 69.78,107.81 69,107.81 68.86,107.66 68.86,107.47 69.04,107.29 70.78,107.29 71.15,106.92 71.15,106.29 70.82,105.96 69.83,105.96 69.58,105.71 69.58,105.51 70.34,104.75 72.08,104.75 72.58,104.26 72.58,101.41 72.74,101.25 73.24,101.25 73.45,101.46 73.45,101.58 73.84,101.97 74.51,101.97 75.19,101.29 81.69,101.29 85.37,97.61 85.37,94.44 86.22,93.58 86.22,91.7 86.43,91.5 87.32,91.5 87.7,91.11 87.7,90.23 87.32,89.84 86.43,89.84 86.22,89.64 86.22,89.01 86.43,88.8 87.32,88.8 87.7,88.42 87.7,87.54 87.32,87.15 86.43,87.15 86.22,86.94 86.22,86.32 86.43,86.11 87.32,86.11 87.7,85.72 87.7,84.85 87.32,84.46 86.43,84.46 86.22,84.25 86.22,83.63 86.43,83.42 87.32,83.42 87.7,83.03 87.7,82.15 87.32,81.77 86.43,81.77 86.22,81.56 86.22,80.93 86.43,80.73 87.32,80.73 87.7,80.34 87.7,79.46 87.32,79.08 86.13,79.08 85.92,78.87 85.92,78.17 86.13,77.97 87.32,77.97 87.71,77.58 87.71,76.91 87.32,76.52 86.43,76.52 86.22,76.31 86.22,74.77 86.55,74.43 86.93,74.43 87.69,75.19 88.23,75.19 88.71,74.72 88.71,74.17 88.52,73.99 88.52,73.69 88.82,73.4 89.11,73.4 89.3,73.58 89.84,73.58 90.32,73.11 90.32,72.56 90.13,72.38 90.13,72.08 90.43,71.79 90.72,71.79 90.91,71.97 91.45,71.97 91.93,71.5 91.93,70.95 91.74,70.77 91.74,70.47 92.04,70.18 92.33,70.18 92.51,70.36 93.06,70.36 93.53,69.89 93.53,69.34 93.35,69.16 93.35,68.7 93.83,68.23 94.39,68.23
RLD3_C3_72B_QK6_P: length 113.3
  TOP w0.145: U142.D5 v2(79.32,119.17) ; U1.G26 v2(101.24,68.84)
  18_SIG6 w0.107: 76.67,108.81 76.67,108.84 76.72,108.89 76.72,117.51 76.98,117.77 77.61,117.77 77.72,117.88 77.72,118.42 78.07,118.77 78.63,118.77 79.03,119.17 v2(79.32,119.17) ; 94.39,67.92 94.41,67.92 94.46,67.97 94.72,67.97 94.99,68.24 100.59,68.24 100.9,68.55 100.9,68.68 101.06,68.84 v2(101.24,68.84) ; 69.89,108.91 69.89,108.87
  18_SIG6 w0.14: 69.89,108.91 70.27,109.29 70.96,109.29 71.34,108.91 71.34,108.33 71.53,108.14 71.96,108.14 72.17,108.35 72.17,108.91 72.54,109.29 73.24,109.29 73.61,108.91 73.61,108.35 73.82,108.14 76.3,108.14 76.67,108.5 76.67,108.81 ; 69.89,108.87 69.89,108.35 69.66,108.11 68.88,108.11 68.55,107.78 68.55,107.35 68.91,106.99 70.65,106.99 70.85,106.8 70.85,106.42 70.69,106.26 69.7,106.26 69.28,105.84 69.28,105.39 70.21,104.45 71.95,104.45 72.27,104.13 72.27,101.29 72.61,100.95 73.37,100.95 73.75,101.34 73.75,101.46 73.96,101.67 74.38,101.67 75.06,100.98 81.57,100.98 85.06,97.49 85.06,94.31 85.92,93.46 85.92,91.58 86.31,91.19 87.19,91.19 87.4,90.98 87.4,90.36 87.19,90.15 86.31,90.15 85.92,89.76 85.92,88.89 86.31,88.5 87.19,88.5 87.4,88.29 87.4,87.67 87.19,87.46 86.31,87.46 85.92,87.07 85.92,86.19 86.31,85.81 87.19,85.81 87.4,85.6 87.4,84.97 87.19,84.76 86.31,84.76 85.92,84.38 85.92,83.5 86.31,83.11 87.19,83.11 87.4,82.91 87.4,82.28 87.19,82.07 86.31,82.07 85.92,81.69 85.92,80.81 86.31,80.42 87.19,80.42 87.4,80.21 87.4,79.59 87.19,79.38 86,79.38 85.61,78.99 85.61,78.05 86,77.66 87.19,77.66 87.4,77.45 87.4,77.04 87.19,76.83 86.31,76.83 85.92,76.44 85.92,74.64 86.43,74.13 87.06,74.13 87.81,74.89 88.11,74.89 88.4,74.59 88.4,74.3 88.22,74.11 88.22,73.57 88.69,73.09 89.24,73.09 89.42,73.28 89.72,73.28 90.01,72.98 90.01,72.69 89.83,72.5 89.83,71.96 90.3,71.48 90.85,71.48 91.03,71.67 91.33,71.67 91.62,71.37 91.62,71.08 91.44,70.89 91.44,70.35 91.91,69.87 92.46,69.87 92.64,70.06 92.94,70.06 93.23,69.76 93.23,69.47 93.05,69.29 93.05,68.58 93.7,67.92 94.39,67.92
RLD3_C3_72B_QK7_N: length 111.8
  TOP w0.145: U1.C28 97.74,70.34 v2(97.24,70.84) ; v2(73.32,118.17) U142.J6
  16_SIG5 w0.107: v2(73.32,118.17) 72.84,118.17 72.71,118.29 72.71,118.48 72.8,118.57 74.77,118.57 74.79,118.54 75.07,118.54 75.5,118.11 75.5,117.82 ; 68.91,109.9 68.92,109.88 ; v2(97.24,70.84) 97.64,71.24 97.64,72.01 97.41,72.24 95.98,72.24 95.62,72.6 95.62,73.08 95.45,73.24 94.98,73.24 94.48,73.74 94.41,73.74 94.39,73.76 ; 75.39,117.28 74.96,117.28 74.85,117.39 74.85,117.6 74.96,117.71 75.39,117.71
  16_SIG5 w0.108: 74.88,109.03 74.9,109.05 74.94,109.05 75.5,109.61 75.5,117.17 75.39,117.28 ; 75.39,117.71 75.5,117.82
  16_SIG5 w0.14: 94.39,73.76 94.08,74.07 93.61,74.07 88.42,79.26 88.42,92.03 85.93,94.52 85.93,99.56 86.46,100.09 86.46,100.79 83.67,103.58 83.67,104.27 83.34,104.6 82.72,104.6 82.34,104.98 82.34,106.13 82.1,106.36 81.48,106.36 81.29,106.18 81.29,104.98 80.91,104.6 79.86,104.6 79.4,105.06 79.4,106.87 79.26,107.01 78.97,107.01 78.28,106.32 77.03,106.32 76.71,106.64 76.71,107.68 76.57,107.82 76.02,107.82 75.88,107.68 75.88,106.64 75.56,106.32 74.96,106.32 74.64,106.64 74.64,107.3 74.5,107.44 73.94,107.44 73.8,107.3 73.8,106.64 73.48,106.32 72.62,106.32 71.49,107.46 70.32,107.46 70.03,107.17 67.38,107.17 65.07,109.47 65.07,111.86 64.59,112.34 64.59,114.3 65.13,114.83 66.14,114.83 66.73,114.24 66.73,112.66 66.87,112.52 67.35,112.52 67.67,112.2 67.67,111.39 67.35,111.07 66.87,111.07 66.52,110.72 66.52,109.88 66.9,109.5 67.39,109.5 68.05,110.16 68.65,110.16 68.91,109.9 ; 74.88,109.03 74.49,108.64 73,108.64 72.88,108.76 72.88,109.38 72.56,109.7 71.75,109.7 71.43,109.38 71.43,108.76 71.31,108.64 69.06,108.64 68.92,108.78 68.92,109.88
RLD3_C3_72B_QK7_P: length 111.7
  TOP w0.145: U1.D27 98.74,69.34 v2(98.24,69.84) ; U142.K5 v2(72.32,119.17)
  16_SIG5 w0.107: 75.75,109.51 75.75,118.21 75.17,118.79 74.79,118.79 74.77,118.77 72.72,118.77 v2(72.32,119.17) ; v2(98.24,69.84) 97.84,70.24 97.84,72.1 97.49,72.44 96.06,72.44 95.82,72.68 95.82,73.16 95.54,73.44 95.06,73.44 94.62,73.89 94.62,73.96
  16_SIG5 w0.108: 75.1,108.81 75.11,108.83 75.11,108.87 75.75,109.51
  16_SIG5 w0.14: 94.62,73.96 94.21,74.37 93.74,74.37 88.72,79.39 88.72,92.16 86.23,94.65 86.23,99.43 86.77,99.97 86.77,100.91 83.97,103.71 83.97,104.39 83.46,104.9 82.85,104.9 82.64,105.11 82.64,106.25 82.23,106.66 81.35,106.66 80.99,106.3 80.99,105.11 80.78,104.9 79.98,104.9 79.71,105.18 79.71,107 79.39,107.31 78.84,107.31 78.15,106.63 77.16,106.63 77.02,106.77 77.02,107.81 76.7,108.13 75.89,108.13 75.57,107.81 75.57,106.77 75.43,106.63 75.08,106.63 74.94,106.77 74.94,107.43 74.63,107.75 73.81,107.75 73.5,107.43 73.5,106.77 73.36,106.63 72.75,106.63 71.61,107.76 70.19,107.76 69.9,107.47 67.51,107.47 65.38,109.6 65.38,111.99 64.9,112.47 64.9,114.17 65.25,114.53 66.01,114.53 66.43,114.11 66.43,112.53 66.75,112.21 67.22,112.21 67.36,112.07 67.36,111.52 67.22,111.38 66.75,111.38 66.22,110.85 66.22,109.75 66.78,109.19 67.51,109.19 68.17,109.85 68.52,109.85 68.62,109.76 68.62,108.65 68.93,108.33 71.43,108.33 71.74,108.64 71.74,109.26 71.88,109.4 72.43,109.4 72.57,109.26 72.57,108.64 72.88,108.33 74.61,108.33 75.1,108.81
RLD3_C3_72B_QVLD0: length 143.2
  TOP w0.152: U141.J12 v2(99.23,114.32) ; v2(101.24,79.84) U1.G37
  20_SIG7 w0.089: v2(101.24,79.84) 101.24,80.14 101.74,80.64 101.74,80.72 101.74,82.06 101.46,82.34 100.93,82.34 100.74,82.54 100.74,83.64 100.74,84.05 101.03,84.34 101.44,84.34 101.74,84.64 101.74,85.05 102.03,85.34 102.44,85.34 102.74,85.64 102.74,89.05 ; 102.11,114.77 101.45,114.77 101.4,114.82 99.73,114.82 v2(99.23,114.32)
  20_SIG7 w0.14: 102.74,89.05 102.86,89.17 102.86,89.53 102.68,89.7 101.74,89.7 101.56,89.87 101.56,90.22 101.74,90.39 102.68,90.39 102.86,90.56 102.86,95.59 103.28,96.02 103.28,97.09 103.85,97.66 104.85,97.66 105.73,96.77 111.65,96.77 112.04,97.16 112.04,98.16 111.27,98.93 111.27,99.66 111.82,100.22 111.82,100.98 110.97,101.83 110.97,102.8 111.2,103.02 112.15,103.02 112.57,102.6 112.57,101.31 112.75,101.14 113.35,101.14 113.54,101.32 113.54,102.23 114.27,102.96 114.27,103.41 113.9,103.78 111.36,103.78 111.21,103.93 111.21,104.3 111.41,104.51 114.76,104.51 114.97,104.72 114.97,105.06 114.74,105.29 109.97,105.29 109.79,105.47 109.79,105.86 110.05,106.12 114.6,106.12 114.84,106.36 114.84,106.7 114.65,106.89 108.84,106.89 108.64,107.1 108.64,107.91 108.81,108.08 114.68,108.08 114.94,108.35 114.94,108.66 114.73,108.87 111.19,108.87 110.96,109.11 110.96,109.39 111.22,109.65 114.54,109.65 114.72,109.83 114.72,110.2 114.45,110.47 112.86,110.47 112.62,110.72 112.62,112.98 112.45,113.14 109.52,113.14 109.19,112.82 108.87,112.82 108.71,112.98 108.71,113.53 108.61,113.63 108.21,113.63 107.99,113.41 107.99,112.93 107.9,112.84 107.66,112.84 107.18,113.32 106.55,113.32 106.4,113.47 106.4,113.91 106.79,114.3 108.45,114.3 108.64,114.49 108.64,117.31 110.46,119.13 110.46,129.11 109.82,129.76 108.54,129.76 107.98,129.2 107.98,120.1 106.07,118.19 106.07,116.42 104.69,115.04 103.79,115.04 103.53,114.77 102.11,114.77
RLD3_C3_72B_QVLD1: length 141
  TOP w0.152: v2(95.24,80.84) 95.74,80.34 U1.A38 ; U141.J2 v2(88.23,114.32)
  16_SIG5 w0.089: 78.82,123.67 78.82,121.99 79.12,121.68 79.49,121.68 79.81,121.37 79.81,121 80.12,120.68 80.49,120.68 80.81,120.37 80.81,120 81.12,119.68 81.49,119.68 81.84,119.34 81.84,118.97 82.12,118.68 82.51,118.68 82.81,118.39 82.81,113.93 83.09,113.65 83.59,113.65 ; 95.74,90.96 95.74,90.2 94.69,89.15 94.69,83.66 95.01,83.34 95.52,83.34 95.74,83.13 95.74,81.34 v2(95.24,80.84) ; 86.82,114.99 86.99,114.81 87.47,114.81 87.95,114.32 v2(88.23,114.32)
  16_SIG5 w0.14: 95.74,90.96 95.74,91.88 97.44,93.58 97.44,97.17 96.27,98.35 96.27,99.9 96.04,100.13 95.87,100.13 95.64,100.36 95.64,100.68 95.87,100.91 96.04,100.91 96.27,101.14 96.27,101.97 96.08,102.16 96.08,102.42 96.77,103.11 96.77,103.44 96.54,103.67 96.21,103.67 95.52,102.97 95.2,102.97 94.97,103.2 94.97,103.53 96.43,105 96.43,105.32 96.2,105.55 95.88,105.55 94.41,104.08 94.09,104.08 93.86,104.31 93.86,104.64 94.41,105.19 94.41,105.52 94.18,105.75 93.85,105.75 93.3,105.19 92.98,105.19 92.75,105.42 92.75,105.75 93.11,106.11 93.11,106.33 92.88,106.56 92.45,106.56 92.19,106.3 91.63,106.3 90.84,107.1 90.84,107.64 89.89,108.58 88.75,108.58 88.33,109 87.18,109 86.26,109.92 86.26,111.1 85.52,111.84 84.96,111.84 83.97,112.83 83.97,113.36 83.69,113.65 83.59,113.65 ; 78.82,123.67 78.82,126.32 78.68,126.46 78.4,126.46 78.26,126.6 78.26,126.88 78.4,127.02 78.68,127.02 78.82,127.16 78.82,128.37 78.68,128.51 78.23,128.51 78.1,128.65 78.1,128.93 78.23,129.07 78.68,129.07 78.82,129.21 78.82,129.59 78.38,130.02 76.3,130.02 74.84,131.49 73.66,131.49 71.97,133.17 71.5,133.17 71.12,133.55 71.12,135.05 71.25,135.18 71.75,135.18 71.86,135.28 71.86,135.99 71.75,136.09 69.98,136.09 69.82,136.25 69.82,136.7 70.02,136.9 77.78,136.9 77.92,136.76 77.92,135.28 78.06,135.14 78.48,135.14 78.62,135.28 78.62,136.76 78.76,136.9 79.23,136.9 79.38,136.75 79.38,133.85 80.41,132.82 81.22,132.82 81.82,132.22 83.15,132.22 83.29,132.08 83.29,128.44 84.51,127.21 85.47,127.21 85.7,126.99 85.7,126.66 85.47,126.43 83.33,126.43 83.05,126.16 83.05,125.83 83.24,125.65 85.47,125.65 85.7,125.42 85.7,125.09 85.47,124.86 83.47,124.86 83.23,124.63 83.23,123.98 83.44,123.77 84.4,123.77 85.06,123.11 85.06,122.68 84.7,122.31 84.7,120.23 85.08,119.85 85.45,119.85 85.76,119.54 85.76,119.52 85.8,119.47 85.8,117.66 85.69,117.55 85.69,117.1 86.69,116.09 86.69,115.11 86.82,114.99
RLD3_C3_72B_QVLD2: length 118.4
  TOP w0.152: U1.J27 v2(103.24,69.84) ; v2(73.32,111.17) U142.J12
  14_SIG4 w0.089: 83.59,116 80.47,116 80.13,115.66 75.8,115.66 75.18,115.03 75.18,114.74 75.3,114.62 75.39,114.62 75.51,114.49 75.51,114.24 75.39,114.12 75.3,114.12 75.18,113.99 75.18,112.55 75.05,112.42 74.96,112.42 74.83,112.3 74.83,112.05 74.96,111.92 75.05,111.92 75.18,111.8 75.18,111.55 75.05,111.43 74.96,111.43 74.83,111.3 74.83,111.05 74.96,110.93 75.05,110.93 75.18,110.8 75.18,109.98 74.86,109.67 72.06,109.67 71.83,109.89 71.83,111.36 72.12,111.65 73.43,111.65 73.61,111.47 73.61,111.24 73.53,111.17 v2(73.32,111.17) ; v2(103.24,69.84) 103.56,69.84 104.05,70.34 104.51,70.34 104.73,70.55 104.73,71.08 105,71.35 105.47,71.35 105.74,71.62 105.74,72.08 105.99,72.33 108.5,72.33 108.76,72.59 108.76,73.14 108.95,73.33 109.58,73.33 109.72,73.47 109.72,74.04 109.46,74.3 109.46,74.3 109.44,74.32 109,74.32 108.74,74.58 108.74,75.02 108.43,75.33 108.04,75.33 107.75,75.62 107.75,77.06 107.44,77.37 106.99,77.37 106.74,77.12 106.74,74.64 106.46,74.35 105.89,74.35 105.72,74.18 105.72,72.64 105.44,72.36 105.04,72.36 104.72,72.69 104.72,74.23 104.59,74.36 103.97,74.36 103.71,74.1 103.71,74.04 103.72,74.04 103.72,72.64 103.71,72.64 103.71,72.04 103.72,72.04 103.72,71.64 103.71,71.64 103.71,71.04 103.72,71.04 103.72,70.64 103.71,70.64 103.71,70.62 103.45,70.36 103.44,70.36 102.98,70.36 102.76,70.58 102.76,72.04 102.46,72.34 94.7,72.34 94.39,72.03
  14_SIG4 w0.14: 83.59,116 84.28,116 84.69,115.59 84.69,109.34 85.22,108.81 85.22,108.53 91.01,102.74 91.01,101.37 91.41,100.97 91.41,99.79 91.06,99.44 91.06,98.76 93.38,96.44 93.73,96.44 94.46,95.71 94.46,94.95 90.32,90.81 90.32,72.44 91.39,71.37 93.73,71.37 94.39,72.03
RLD3_C3_72B_QVLD3: length 114.9
  TOP w0.152: v2(73.32,122.17) U142.J2 ; U1.F25 v2(100.24,67.84)
  18_SIG6 w0.089: 94.39,66.74 94.63,66.74 95.03,66.34 99.44,66.34 99.74,66.64 99.74,67.07 100.24,67.57 v2(100.24,67.84) ; 68.91,109.78 69.03,109.78 69.12,109.68 69.52,109.68 69.82,109.98 69.82,112.38 70.11,112.67 70.54,112.67 70.82,112.39 70.82,111.35 70.82,111.35 70.82,109.79 70.95,109.66 71.53,109.66 71.82,109.96 71.82,110.46 71.84,110.48 71.84,111.96 71.82,111.98 71.82,112.41 72.08,112.67 72.54,112.67 72.82,112.38 72.82,109.91 73.07,109.66 73.56,109.66 73.82,109.93 73.82,111.42 74.07,111.67 74.56,111.67 74.86,111.37 74.86,110.39 75.03,110.22 75.55,110.22 75.8,110.48 75.8,118.33 76.14,118.67 77.57,118.67 77.82,118.92 77.82,119.4 78.08,119.67 78.6,119.67 78.82,119.88 78.82,120.41 78.56,120.67 74.1,120.67 73.81,120.96 73.81,121.68 v2(73.32,122.17)
  18_SIG6 w0.14: 94.39,66.74 94.14,66.74 87.85,73.04 84.97,73.04 84.78,73.22 84.78,93.5 84.28,94 84.28,97.25 81.89,99.64 72.11,99.64 71.88,99.88 71.88,100.64 71.51,101.01 71.51,102.34 71.34,102.51 70.75,102.51 70.58,102.34 70.58,101.42 70.38,101.22 69.78,101.22 69.18,101.82 69.18,102.16 69.81,102.79 69.81,103.98 67.51,106.28 67.51,109.4 67.88,109.78 68.91,109.78
RLD3_C3_72B_REF_B: length 171.1
  TOP w0.152: U1.L30 v2(105.24,72.84) ; U142.F8 v2(77.32,115.17) ; U141.F8 v2(95.23,118.32)
  TOP w0.279: R953.2 95.4,125.12 v1(95.5,125.02)
  03_SIG1 w0.173: v2(95.23,118.32) 94.93,118.32 93.43,119.82 93.03,119.82 92.72,120.14 92.72,120.52 92.43,120.81 91.99,120.81 91.73,121.07 91.73,121.58 91.5,121.81 91.02,121.81 90.73,122.11 90.73,122.56 90.47,122.81 90.02,122.81 89.73,123.1 89.73,123.53 89.08,124.18 87.45,124.18 87.4,124.13 86.92,124.13 86.59,124.46 83.57,124.46 83.29,124.74 73.15,124.74 71.82,123.41 71.82,114 72.16,113.67 75.08,113.67 76.07,114.66 76.58,114.66 77.09,115.17 v2(77.32,115.17)
  05_SIG2 w0.173: v2(105.24,72.84) U1.L30 109.54,72.34 109.75,72.13 109.75,70.56 109.95,70.36 111.58,70.36 111.74,70.51 111.74,79.15 111.5,79.39 110.91,79.39 110.74,79.56 110.74,82.15 110.55,82.34 109.96,82.34 109.74,82.57 109.74,84.09 109.48,84.34 99.92,84.34 99.74,84.53 99.74,89.48 ; v2(77.32,115.17) 76.94,115.17 76.82,115.28 76.82,120.39 77.1,120.67 78.71,120.67 78.82,120.77 78.82,121.42 79.07,121.67 79.66,121.67 79.82,121.83 79.82,122.38 80.11,122.67 82.42,122.67 82.6,122.84 82.6,123.12 82.48,123.24 82.08,123.24 81.99,123.32 81.99,123.64 82.16,123.81 83,123.81 83.09,123.73 83.09,123.45 83.18,123.36 83.58,123.36 83.68,123.45 83.68,123.73 83.77,123.81 84.72,123.81 84.86,123.68 84.86,123.29 84.76,123.19 84.35,123.19 84.18,123.02 84.18,122.65 84.3,122.53 85.28,122.53 85.38,122.63 85.38,123.24 85.47,123.33 85.81,123.33 85.93,123.21 85.93,121.97 86.08,121.82 86.32,121.82 86.5,122 86.5,123.25 86.67,123.43 87.08,123.43 87.21,123.3 87.21,122.97 87.36,122.82 94.37,122.82 94.49,122.7 94.49,122.38 94.32,122.2 93.9,122.2 93.72,122.03 93.72,121.69 93.9,121.51 94.32,121.51 94.49,121.34 94.49,117.32 95.14,116.67 97.12,116.67 97.3,116.5 97.3,116.09 97.11,115.9 96.91,115.9 96.73,115.72 96.73,115.06 96.97,114.82 100.49,114.82 100.73,114.59 100.73,114.04 100.51,113.82 99.92,113.82 99.73,113.63 99.73,113 99.9,112.82 100.56,112.82 100.74,112.65 100.74,112.07 100.5,111.82 99.88,111.82 99.73,111.67 99.73,110.99 99.89,110.82 100.58,110.82 100.73,110.67 100.73,108.46
  05_SIG2 w0.292: 100.73,108.46 100.73,107.55 101.83,106.45 101.83,92.24 99.74,90.15 99.74,89.48
  07_SIG3 w0.262: v2(95.23,118.32) 95.73,118.83 95.73,124.79 v1(95.5,125.02)
RLD3_C3_72B_RESET_B: length 158.6
  TOP w0.152: U1.L29 105.74,71.34 v2(105.24,71.84) ; U141.A13 v2(100.23,123.32) 99.65,123.9 87.35,123.9 87.12,123.67 87.12,123.01 86.89,122.78 86.54,122.78 86.28,123.04 86.28,124.18 86.03,124.43 84.65,124.43 84.43,124.21 84.43,123.83 84.25,123.65 83.67,123.65 83.49,123.82 83.49,124.51 83.34,124.66 80.52,124.66 80.31,124.46 80.31,124.1 80.57,123.85 82.3,123.85 82.83,123.32 82.83,116.79 82.98,116.64 83.57,116.64 83.72,116.49 83.72,115.88 83.57,115.73 82.98,115.73 82.83,115.57 82.83,110.67 v2(82.32,110.17) U142.A13
  16_SIG5 w0.089: v2(105.24,71.84) 104.74,71.34 104.74,67.83 104.74,67.64 105.03,67.34 105.22,67.34 105.22,67.34 110.44,67.34 110.74,67.05 110.74,65.84 110.99,65.58 111.51,65.58 111.74,65.35 111.74,64.52 111.56,64.34 105.03,64.34 104.74,64.05 104.74,63.62 105.01,63.34 111.44,63.34 111.74,63.05 111.74,62.61 111.47,62.34 101.97,62.34 101.74,62.58 101.74,65.35 101.91,65.52 110.16,65.52 110.26,65.62 110.26,66.14 110.15,66.25 102.04,66.25 101.74,66.55 101.74,68.05 101.44,68.34 101.03,68.34 101.02,68.34 100.74,68.62 100.74,72.05 100.44,72.34 100.44,72.34 100.03,72.34 99.74,72.64 99.74,73.14 99.53,73.34 99.03,73.34 98.74,73.64 98.74,74.08 98.48,74.34 98.03,74.34 97.74,74.64 97.74,75.08 97.48,75.34 97.03,75.34 96.74,75.64 96.74,76.08 96.48,76.34 96.03,76.34 95.74,76.64 95.74,77.11 95.5,77.34 95,77.34 94.39,77.95
  16_SIG5 w0.14: v2(82.32,110.17) 82.32,109.52 83.03,108.81
  16_SIG5 w0.157: 83.03,108.81 87.53,104.32 88.14,104.32 89.7,102.75 89.7,99.64 89.85,99.5 89.85,98.91 92.05,96.71 92.05,94.13 91.16,93.24 91.16,81.18 94.39,77.95
RLD3_C3_72B_TCK: length 86.6
  TOP w0.152: U142.N2 v2(69.32,122.17) 68.84,122.65 68.84,123.55 71.2,125.91 92.51,125.91 94.09,127.49 96.07,127.49 96.75,128.17 96.75,129.87 97.38,130.51 98.98,130.51 J105.5 101.59,127.95 101.59,127.05 105.66,122.98 105.66,113.6 105.1,113.04 105.1,106.92 103.06,104.88 92.74,104.88 v1(90.19,107.43) ; U141.N2 v2(88.23,110.32)
  20_SIG7 w0.089: v1(90.19,107.43) 88.23,109.39 v2(88.23,110.32)
  BOTTOM w0.152: R1195.2 100.64,128.87 J105.5
RLD3_C3_72B_TDI: length 23.8
  TOP w0.152: U141.N10 v2(97.23,110.32)
  07_SIG3 w0.173: v2(97.23,110.32) 97.23,110.61 97.73,111.11 97.73,116.02 98.73,117.02 98.73,125.73 J105.3
  BOTTOM w0.152: J105.3 95.56,128.87 R1194.2
RLD3_C3_72B_TMS: length 72.1
  TOP w0.152: U141.N12 v2(99.23,110.32) ; v2(99.23,110.32) 98.9,110 98.9,109.12 100.11,107.91 100.11,106.83 99.82,106.54 95.64,106.54 95.26,106.92 95.26,107.48 92.9,109.84 88.68,109.84 88.11,109.27 82.25,109.27 81.86,109.66 74.61,109.66 74.6,109.65 68.99,109.65 68.84,109.8 68.84,110.4 69.32,110.88 v2(69.32,111.17) U142.N12 ; v2(99.23,110.32) 99.71,109.84 100.43,109.84 100.71,110.12 100.71,112.5 101.02,112.81 104.4,112.81 104.75,113.15 104.75,113.19 104.83,113.27 104.83,122.91 104.01,123.73 101.11,123.73 100.43,124.41 100.43,126.57 J105.4
  BOTTOM w0.152: R1193.2 98.1,128.87 J105.4
RLD3_C3_72B_WE_B: length 170.3
  TOP w0.152: U1.K29 104.74,71.34 v2(104.24,71.84) ; U141.F6 v2(92.23,118.32) ; U142.F6 v2(77.32,118.17)
  TOP w0.241: v2(92.23,109.32) R954.2
  05_SIG2 w0.262: v2(92.23,118.32) 91.73,117.82 91.73,117.11 93.02,115.82 93.43,115.82 93.73,115.53 93.73,110.12 92.93,109.32 v2(92.23,109.32)
  07_SIG3 w0.173: v2(104.24,71.84) 104.71,72.31 107.46,72.31 107.7,72.07 107.7,69.6 107.98,69.33 117.58,69.33 117.76,69.16 117.76,67.72 118.04,67.43 118.35,67.43 118.8,67.88 118.8,77.79 118.2,78.39 109.01,78.39 108.79,78.61 108.79,86.16 108.58,86.37 97.95,86.37 97.75,86.57 97.75,90.29 ; 100.74,108.46 100.74,111.5 100.4,111.84 98.94,111.84 98.71,111.61 98.71,110.08 98.4,109.77 97.02,109.77 96.73,110.07 96.73,110.58 96.49,110.82 94.5,110.82 93.51,109.83 92.94,109.83 92.73,110.03 92.73,111.5 92.43,111.81 92.06,111.81 91.74,112.12 91.74,112.57 91.5,112.81 90.93,112.81 90.74,113 90.74,113.61 90.53,113.82 88.04,113.82 87.73,114.12 87.73,114.55 87.45,114.83 86.59,114.83 83.76,117.67 77.82,117.67 v2(77.32,118.17)
  07_SIG3 w0.292: 100.74,108.46 100.74,106.26 98.79,104.31 98.79,101.23 97.21,99.66 97.21,98.83 97.75,98.29 97.75,90.29
  14_SIG4 w0.089: v2(92.23,118.32) 92.43,118.32 92.93,118.82 93.69,118.82 93.79,118.73 93.79,118.3 93.9,118.19 94.05,118.19 94.16,118.3 94.16,118.73 94.27,118.84 94.45,118.84 94.72,118.57 94.72,118.11 94.57,117.96 94.31,117.96 94.2,117.85 94.2,117.64 94.3,117.54 94.61,117.54 94.7,117.45 94.7,117.28 94.57,117.14 93.93,117.14 93.82,117.25 93.82,117.7 93.7,117.82 91.02,117.82 90.71,117.52 90.71,116.98 90.56,116.82 88,116.82 87.73,117.1 87.73,117.63 87.54,117.82 86.95,117.82 86.65,118.12 85.98,118.12 85.76,118.35 85.76,119.65 85.45,119.96 84.68,119.96 84.57,120.07 84.57,120.52 84.46,120.62 84.31,120.62 84.2,120.52 84.2,120.07 84.09,119.96 83.92,119.96 83.83,120.05 83.83,120.43 83.54,120.72 82.76,120.72 82.71,120.67 81.13,120.67 80.82,120.36 80.82,119.96 80.53,119.66 77.89,119.66 77.83,119.59 77.83,118.9 77.59,118.66 77.09,118.66 76.83,118.93 76.83,119.54 76.71,119.66 75.82,119.66 75.68,119.53 75.68,119.16 75.79,119.05 75.79,118.9 75.68,118.79 75.27,118.79 75.16,118.68 75.16,118.53 75.27,118.42 75.68,118.42 75.79,118.31 75.79,118.15 75.68,118.04 75.27,118.04 75.16,117.93 75.16,117.37 75.23,117.3 75.72,117.3 76.08,117.66 77.56,117.66 77.65,117.75 77.65,118.08 77.57,118.17 v2(77.32,118.17)
RLD3_C3_COMP1_72B_TDO: length 33.2
  TOP w0.152: U141.N4 v2(90.23,110.32) ; v1(88.98,107.42) 87.81,108.58 69.47,108.58 68.41,109.64 68.41,110.53 68.76,110.88 68.76,112.6 v2(69.32,113.17) U142.N10
  20_SIG7 w0.089: v1(88.98,107.42) 88.98,107.96 87.76,109.18 87.76,110.56 88.01,110.81 89.74,110.81 v2(90.23,110.32)
RLD3_C3_COMP2_72B_TDO: length 31.7
  TOP w0.152: J105.2 90.76,126.61 71.12,126.61 68.25,123.74 68.25,121.24 v2(69.32,120.17) U142.N4
RLD3_C3_VTERM_0V6: length 53.5
  TOP w0.254: R970.1 v2(83.32,113.17) ; R964.1 83.94,119.14 83.35,119.14 v2(83.32,119.17) ; R976.1 96.11,107.32 v1(96.22,107.21) ; v1(103.52,121.61) 103.08,121.61 103,121.52 R952.1 R957.1 102.87,120.42 v1(103.4,120.42) ; R955.1 83.94,120.19 v2(83.32,120.19) ; v1(103.28,115.37) 103.1,115.55 R968.1 ; v2(83.32,117.17) 83.33,117.17 R966.1 ; v2(83.32,118.17) 83.33,118.17 R971.1 ; R960.1 v2(83.32,111.17) ; v1(91.47,107.44) 91.47,107.83 R975.1 R977.1 R965.1 ; R954.1 v1(92.23,107.43) ; R967.1 94.54,126.25 R953.1 96,126.85 v1(96.42,126.85) ; v1(103.81,117.93) 103.21,117.33 R972.1 ; R958.1 v2(83.32,112.17) ; R963.1 v2(83.32,115.17) ; R959.1 v2(83.32,114.17) ; R956.1 v1(103.23,116.57)
  TOP w0.381: R974.1 R968.1
  11_PWR2 w0.381: 64,137.98 J104.1 ; J104.1 65.61,139.59 ; J104.1 65.61,137.98 ; J104.1 64.8,137.72 ; J104.1 64.8,139.85 ; J104.1 65.87,138.79 ; J104.1 64,139.59 ; J104.1 63.74,138.79
  BOTTOM w0.254: v2(83.32,120.19) v2(83.32,119.17) ; v2(83.32,119.17) 83.35,119.14 83.92,119.14 C1241.1 84.6,119.81 85.72,119.81 86.23,119.3 R990.1 ; v2(83.32,119.17) v2(83.32,118.17) v2(83.32,117.17) 83.33,117.17 83.98,117.17 C1239.1 ; C1244.1 103.46,118.3 103.78,118.62 v1(103.78,118.69) ; v1(103.4,120.42) 103.07,120.76 R957.1 ; v2(83.32,111.17) 83.69,110.79 C1237.1 ; C1243.1 92.31,125.15 v1(92.2,125.05) ; v1(103.23,116.57) R956.1 ; v1(103.28,115.37) 103.1,115.55 R968.1 ; v2(83.32,114.17) 83.38,114.11 C1240.1 ; C1242.1 C1246.1 91.6,107.58 v1(91.47,107.44) ; C1245.1 103.11,122.24 103.53,122.66 v1(103.53,123.11) ; R972.1 103.21,117.33 v1(103.81,117.93) ; U143.3 57.17,134.72 57.26,134.8 57.26,136.19 ; v2(83.32,112.17) 83.54,111.95 C1238.1 ; Z87.1 92.63,106.6 92.23,107.01 v1(92.23,107.43)
  BOTTOM w0.381: R974.1 R968.1
  vias: v1(60.22,135.56) v1(61.49,135.56) v1(64.19,135.53) v1(65.46,135.53)
