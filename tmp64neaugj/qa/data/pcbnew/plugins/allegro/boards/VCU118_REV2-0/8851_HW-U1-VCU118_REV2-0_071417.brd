# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_RX2_N: length 76.8
  TOP w0.147: U2.B24 70.65,5.52 arc(70.6,5.75) 70.48,5.95 70.46,5.97 arc(70.33,6.16) 70.28,6.39 70.28,9.5 arc(70.36,9.7) 70.56,9.78 70.71,9.78 arc(70.77,9.77) 70.82,9.73 v6(71.15,9.41) ; U1.AC3 117.74,45.34 v2(117.24,44.84)
  03_SIG1 w0.183: v6(71.15,9.41) 71.44,9.7 arc(71.5,9.74) 71.57,9.75 72.15,9.75 arc(73.72,10.41) 74.37,11.98 74.37,20.09 arc(74.64,20.74) 75.29,21.01 77.84,21.01 arc(78.55,21.15) 79.16,21.55 82.98,25.38 arc(83.36,25.63) 83.8,25.71 87.61,25.71 arc(88.45,25.77) 89.28,25.93 arc(89.98,26.22) 90.59,26.68 93.13,29.22 arc(95.01,30.48) 97.24,30.92 105.32,30.92 arc(107.2,31.3) 108.79,32.36 108.94,32.52 arc(109.13,32.79) 109.19,33.12 arc(109.23,33.29) 109.32,33.43 116.99,41.09 arc(117.23,41.45) 117.31,41.88 arc(117.37,42.18) 117.53,42.44
  03_SIG1 w0.237: v2(117.24,44.84) 117.24,44.97 arc(117.5,45.24) 117.77,44.97 117.77,42.88 arc(117.75,42.74) 117.69,42.6 117.56,42.47 arc(117.54,42.45) 117.53,42.44
PCIE_RX2_P: length 76.7
  TOP w0.147: v2(117.24,45.84) 117.74,46.34 U1.AC4 ; v6(71.15,10.41) 70.83,10.09 arc(70.78,10.05) 70.71,10.04 70.56,10.04 arc(70.18,9.88) 70.02,9.5 70.02,6.39 arc(69.97,6.16) 69.84,5.97 69.82,5.95 arc(69.7,5.75) 69.65,5.52 69.65,3.49
  03_SIG1 w0.183: v6(71.15,10.41) 71.44,10.11 arc(71.5,10.07) 71.57,10.06 72.15,10.06 arc(73.5,10.62) 74.07,11.98 74.07,20.09 arc(74.42,20.95) 75.29,21.31 77.84,21.31 arc(78.44,21.43) 78.94,21.77 82.77,25.59 arc(83.24,25.91) 83.8,26.02 87.61,26.02 arc(88.41,26.07) 89.2,26.22 arc(89.83,26.48) 90.37,26.9 92.91,29.44 arc(94.9,30.76) 97.24,31.23 105.32,31.23 arc(107.08,31.58) 108.57,32.58 108.73,32.73 arc(108.85,32.91) 108.89,33.12 arc(108.95,33.4) 109.11,33.64 116.77,41.31 arc(116.95,41.57) 117.01,41.88 117.01,41.94 arc(116.96,42.18) 116.83,42.39 ; 116.82,42.4 arc(116.82,42.41) 116.81,42.41
  03_SIG1 w0.237: v2(117.24,45.84) 117.1,45.71 arc(116.82,45.28) 116.72,44.78 116.72,42.64 arc(116.74,42.52) 116.81,42.41 ; 116.83,42.39 arc(116.83,42.4) 116.82,42.4
PCIE_RX3_N: length 70.5
  TOP w0.147: U2.B28 74.65,5.52 arc(74.6,5.75) 74.48,5.95 74.45,5.97 arc(74.33,6.16) 74.28,6.39 74.28,9.5 arc(74.36,9.7) 74.56,9.78 74.71,9.78 arc(74.77,9.77) 74.82,9.73 v6(75.15,9.41) ; v2(119.24,42.84) 118.74,43.34 U1.AD1
  03_SIG1 w0.183: v6(75.15,9.41) 75.44,9.7 arc(75.5,9.74) 75.57,9.75 75.76,9.75 arc(76.17,9.93) 76.34,10.34 76.34,12.91 arc(76.41,13.24) 76.59,13.51 78.33,15.25 arc(78.76,15.89) 78.91,16.65 78.91,17.11 arc(79.04,17.77) 79.41,18.32 81.61,20.53 arc(82.41,21.06) 83.36,21.25 86.99,21.25 arc(87.41,21.33) 87.77,21.57 90.69,24.49 arc(90.89,24.79) 90.96,25.14 90.96,25.19 arc(91.01,25.43) 91.14,25.64 92.33,26.82 arc(92.55,26.97) 92.82,27.03 92.94,27.03 arc(93.55,27.15) 94.07,27.49 95.53,28.96 arc(96.47,29.58) 97.57,29.8 106.29,29.8 arc(107.78,30.1) 109.05,30.95 117.45,39.35 arc(118.28,40.58) 118.57,42.04 118.57,43.03 arc(118.66,43.26) 118.9,43.36 119.02,43.36 arc(119.1,43.34) 119.16,43.31
  03_SIG1 w0.237: v2(119.24,42.84) 119.24,43.14 arc(119.22,43.22) 119.18,43.29 arc(119.17,43.3) 119.16,43.31
PCIE_RX3_P: length 70.6
  TOP w0.147: U2.B27 73.65,5.52 arc(73.7,5.75) 73.82,5.95 73.84,5.97 arc(73.97,6.16) 74.02,6.39 74.02,9.5 arc(74.18,9.88) 74.56,10.04 74.71,10.04 arc(74.78,10.05) 74.83,10.09 v6(75.15,10.41) ; v2(119.24,43.84) 118.74,44.34 U1.AD2
  03_SIG1 w0.183: v6(75.15,10.41) 75.44,10.11 arc(75.5,10.07) 75.57,10.06 75.76,10.06 arc(75.96,10.14) 76.04,10.34 76.04,12.91 arc(76.13,13.35) 76.38,13.73 78.11,15.46 arc(78.48,16.01) 78.6,16.65 78.6,17.11 arc(78.76,17.88) 79.19,18.53 81.4,20.74 arc(82.3,21.34) 83.36,21.55 86.99,21.55 arc(87.29,21.61) 87.55,21.78 90.47,24.71 arc(90.61,24.91) 90.65,25.14 90.65,25.19 arc(90.72,25.55) 90.93,25.85 92.11,27.04 arc(92.44,27.25) 92.82,27.33 92.94,27.33 arc(93.43,27.43) 93.85,27.71 95.31,29.17 arc(96.35,29.86) 97.57,30.11 106.29,30.11 arc(107.67,30.38) 108.84,31.16 117.24,39.56 arc(118,40.7) 118.26,42.04 118.26,43.03 arc(118.45,43.48) 118.9,43.66 arc(119.04,43.69) 119.17,43.78
  03_SIG1 w0.237: 119.17,43.78 v2(119.24,43.84)
PCIE_RX4_N: length 75.3
  TOP w0.147: v6(79.15,10.41) 79.47,10.09 arc(79.52,10.05) 79.59,10.04 79.74,10.04 arc(80.12,9.88) 80.28,9.5 80.28,6.39 arc(80.33,6.16) 80.46,5.97 80.48,5.95 arc(80.6,5.75) 80.65,5.52 U2.B34 ; v2(120.24,44.84) 119.74,45.34 U1.AE3
  03_SIG1 w0.183: v6(79.15,10.41) 78.86,10.11 arc(78.8,10.07) 78.73,10.06 78.54,10.06 arc(78.27,10.17) 78.16,10.45 78.16,10.98 arc(78.67,12.22) 79.9,12.73 82.51,12.73 arc(83.51,13.15) 83.92,14.15 83.92,19.07 arc(84.23,19.81) 84.97,20.12 87.62,20.12 arc(88.28,20.25) 88.85,20.63 95.28,27.06 arc(96.7,28.01) 98.39,28.35 110.82,28.35 arc(111.85,28.55) 112.73,29.13 113.98,30.39 arc(114.86,31.7) 115.16,33.24 115.16,33.96 arc(115.43,35.32) 116.21,36.48 119.74,40.01 arc(120.2,40.69) 120.36,41.5 120.36,41.74 arc(120.4,41.96) 120.52,42.14
  03_SIG1 w0.237: v2(120.24,44.84) 120.24,45.07 arc(120.49,45.32) 120.74,45.07 120.74,42.66 arc(120.68,42.38) 120.52,42.14
PCIE_RX4_P: length 75.3
  TOP w0.147: v2(120.24,45.84) 119.74,46.34 U1.AE4 ; v6(79.15,9.41) 79.48,9.73 arc(79.53,9.77) 79.59,9.78 79.74,9.78 arc(79.94,9.7) 80.02,9.5 80.02,6.39 arc(79.97,6.16) 79.85,5.97 79.82,5.95 arc(79.7,5.75) 79.65,5.52 U2.B33
  03_SIG1 w0.183: v6(79.15,9.41) 78.86,9.7 arc(78.8,9.74) 78.73,9.75 78.54,9.75 arc(78.05,9.96) 77.85,10.45 77.85,10.98 arc(78.45,12.43) 79.9,13.04 82.51,13.04 arc(83.29,13.36) 83.62,14.15 83.62,19.07 arc(84.01,20.03) 84.97,20.43 87.62,20.43 arc(88.17,20.54) 88.64,20.85 95.06,27.28 arc(96.59,28.29) 98.39,28.65 110.82,28.65 arc(111.74,28.83) 112.51,29.35 113.77,30.61 arc(114.57,31.82) 114.86,33.24 114.86,33.96 arc(115.15,35.44) 115.99,36.69 119.52,40.22 arc(119.92,40.81) 120.05,41.5 120.05,41.74 arc(120.05,41.74) 120.05,41.74 arc(120.03,41.93) 119.96,42.11
  03_SIG1 w0.237: v2(120.24,45.84) 119.86,45.47 arc(119.77,45.33) 119.74,45.16 119.74,42.64 arc(119.75,42.48) 119.8,42.33 119.82,42.31 arc(119.86,42.27) 119.9,42.22 arc(119.93,42.17) 119.96,42.11
PCIE_RX5_N: length 68.4
  TOP w0.147: v6(83.15,10.41) 83.47,10.09 arc(83.52,10.05) 83.59,10.04 83.74,10.04 arc(84.12,9.88) 84.28,9.5 84.28,6.39 arc(84.33,6.16) 84.45,5.97 84.48,5.95 arc(84.6,5.75) 84.65,5.52 U2.B38 ; v2(121.24,42.84) 120.74,43.34 U1.AF1
  07_SIG3 w0.183: v6(83.15,10.41) 82.86,10.11 arc(82.8,10.07) 82.73,10.06 82.54,10.06 arc(82.37,10.13) 82.3,10.31 82.3,11.42 arc(82.59,12.12) 83.29,12.42 84.33,12.42 arc(85.52,12.65) 86.53,13.33 86.83,13.63 arc(87.01,13.7) 87.19,13.63 arc(87.37,13.55) 87.55,13.63 87.58,13.66 arc(87.65,13.84) 87.58,14.02 arc(87.5,14.2) 87.58,14.38 88.19,14.99 arc(88.86,15.44) 89.65,15.59 90.69,15.59 arc(92.07,16.16) 92.64,17.54 92.64,19.66 arc(92.72,20.08) 92.95,20.43 93.63,21.11 arc(94.14,21.45) 94.73,21.56 96.07,21.56 arc(96.7,21.69) 97.23,22.05 101.46,26.27 arc(102.18,26.76) 103.03,26.92 106.38,26.92 arc(107.67,27.18) 108.76,27.91 110.95,30.1 arc(111.22,30.51) 111.31,30.99 111.31,31.64 arc(111.25,31.95) 111.08,32.21 arc(111.04,32.27) 111.03,32.33 111.03,32.79 arc(111.08,33.04) 111.22,33.26 111.64,33.67 arc(111.91,33.85) 112.22,33.92 112.89,33.92 arc(113.66,34.07) 114.32,34.51 117.48,37.68 arc(117.84,37.92) 118.26,38 118.77,38 arc(119.18,38.08) 119.54,38.32 119.96,38.74 arc(120.08,38.79) 120.19,38.74 arc(120.31,38.69) 120.43,38.74 120.58,38.89 arc(120.63,39.01) 120.58,39.13 arc(120.53,39.24) 120.58,39.36 121.09,39.87 arc(121.28,40.15) 121.34,40.48 121.34,41.05 arc(121.38,41.23) 121.48,41.37
  07_SIG3 w0.237: 121.48,41.37 121.61,41.5 arc(121.7,41.65) 121.74,41.82 121.74,42.23 arc(121.72,42.33) 121.66,42.42 v2(121.24,42.84)
PCIE_RX5_P: length 68.5
  TOP w0.147: v2(121.24,43.84) 120.74,44.34 U1.AF2 ; U2.B37 83.65,5.52 arc(83.7,5.75) 83.82,5.95 83.84,5.97 arc(83.97,6.16) 84.02,6.39 84.02,9.5 arc(83.94,9.7) 83.74,9.78 83.59,9.78 arc(83.53,9.77) 83.48,9.73 v6(83.15,9.41)
  07_SIG3 w0.183: v6(83.15,9.41) 82.86,9.7 arc(82.8,9.74) 82.73,9.75 82.54,9.75 arc(82.15,9.92) 81.99,10.31 81.99,11.42 arc(82.37,12.34) 83.29,12.72 84.33,12.72 arc(85.4,12.93) 86.31,13.54 87.97,15.2 arc(88.74,15.72) 89.65,15.9 90.69,15.9 arc(91.85,16.38) 92.33,17.54 92.33,19.66 arc(92.44,20.19) 92.74,20.64 93.42,21.33 arc(94.02,21.73) 94.73,21.87 96.07,21.87 arc(96.58,21.97) 97.02,22.26 98.53,23.77 99.17,24.41 101.25,26.49 arc(102.07,27.04) 103.03,27.23 106.38,27.23 arc(107.55,27.46) 108.54,28.12 110.73,30.31 arc(110.94,30.62) 111.01,30.99 111.01,31.64 arc(110.97,31.83) 110.86,32 arc(110.76,32.15) 110.72,32.33 110.72,32.79 arc(110.8,33.16) 111.01,33.48 111.42,33.89 arc(111.79,34.14) 112.22,34.22 112.89,34.22 arc(113.54,34.35) 114.1,34.73 117.27,37.89 arc(117.73,38.2) 118.26,38.3 118.77,38.3 arc(119.07,38.36) 119.32,38.54 120.88,40.09 arc(121,40.27) 121.04,40.48 121.04,40.79 arc(121,41.01) 120.87,41.19 arc(120.77,41.35) 120.74,41.52
  07_SIG3 w0.237: v2(121.24,43.84) 121.24,43.71 arc(121.22,43.62) 121.17,43.55 120.88,43.25 arc(120.77,43.1) 120.74,42.92 120.74,41.52
PCIE_RX6_N: length 68.6
  TOP w0.147: U1.AG3 121.74,45.34 v2(122.24,44.84) ; U2.B42 88.65,5.52 arc(88.6,5.75) 88.48,5.95 88.45,5.97 arc(88.33,6.16) 88.28,6.39 88.28,9.5 arc(88.12,9.88) 87.74,10.04 87.59,10.04 arc(87.52,10.05) 87.47,10.09 v6(87.15,10.41)
  03_SIG1 w0.183: v6(87.15,10.41) 86.86,10.11 arc(86.8,10.07) 86.73,10.06 86.54,10.06 arc(86.42,10.11) 86.37,10.23 86.37,12.17 arc(86.42,12.4) 86.56,12.61 87.95,14 arc(88.19,14.36) 88.28,14.8 88.28,17.79 arc(88.34,18.1) 88.52,18.36 89.29,19.14 arc(89.73,19.43) 90.25,19.53 arc(90.7,19.62) 91.09,19.88 94.39,23.18 arc(95.13,23.67) 96,23.85 arc(96.48,23.9) 96.95,24.08 arc(97.23,24.25) 97.48,24.46 98.22,25.2 arc(100.46,26.7) 103.1,27.22 111.53,27.22 arc(112.91,27.5) 114.08,28.28 116.64,30.84 arc(116.83,31.12) 116.89,31.45 arc(116.96,31.77) 117.14,32.05 117.9,32.81 arc(118.13,32.96) 118.41,33.02 118.54,33.02 118.56,33.03 arc(119.04,33.16) 119.45,33.44 120.2,34.2 arc(121.76,36.54) 122.31,39.29 122.31,40.87 arc(122.34,41.01) 122.42,41.13
  03_SIG1 w0.237: v2(122.24,44.84) 122.24,45.02 arc(122.49,45.27) 122.74,45.02 122.74,41.36 arc(122.68,41.23) 122.55,41.17 arc(122.49,41.16) 122.42,41.13
PCIE_RX6_P: length 68.6
  TOP w0.147: v6(87.15,9.41) 87.48,9.73 arc(87.53,9.77) 87.59,9.78 87.74,9.78 arc(87.94,9.7) 88.02,9.5 88.02,6.39 arc(87.97,6.16) 87.84,5.97 87.82,5.95 arc(87.7,5.75) 87.65,5.52 U2.B41 ; U1.AG4 121.74,46.34 v2(122.24,45.84)
  03_SIG1 w0.183: v6(87.15,9.41) 86.86,9.7 arc(86.8,9.74) 86.73,9.75 86.54,9.75 arc(86.21,9.89) 86.07,10.23 86.07,12.17 arc(86.14,12.52) 86.34,12.82 87.73,14.21 arc(87.91,14.48) 87.97,14.8 87.97,17.79 arc(88.06,18.21) 88.3,18.58 89.08,19.35 arc(89.61,19.71) 90.25,19.84 arc(90.59,19.91) 90.88,20.1 94.18,23.4 arc(95.01,23.96) 96,24.15 arc(96.41,24.2) 96.81,24.35 arc(97.05,24.49) 97.26,24.68 98,25.42 arc(100.34,26.98) 103.1,27.53 111.53,27.53 arc(112.79,27.78) 113.87,28.5 116.42,31.05 arc(116.54,31.23) 116.59,31.45 arc(116.67,31.89) 116.93,32.27 117.68,33.02 arc(118.02,33.25) 118.41,33.32 arc(118.46,33.33) 118.52,33.33 118.53,33.33 arc(118.91,33.43) 119.23,33.66 119.99,34.41 arc(121.48,36.65) 122.01,39.29 122.01,41.04 arc(121.97,41.22) 121.87,41.38
  03_SIG1 w0.237: v2(122.24,45.84) 121.98,45.58 arc(121.8,45.32) 121.74,45 121.74,41.7 arc(121.77,41.52) 121.87,41.38
PCIE_RX7_N: length 63.8
  TOP w0.147: U1.AH1 122.74,43.34 v2(123.24,42.84) ; U2.B46 92.65,5.52 arc(92.6,5.75) 92.48,5.95 92.46,5.97 arc(92.33,6.16) 92.28,6.39 92.28,9.5 arc(92.12,9.88) 91.74,10.04 91.59,10.04 arc(91.52,10.05) 91.47,10.09 v6(91.15,10.41)
  07_SIG3 w0.183: 123.61,41.5 123.48,41.37 arc(123.38,41.24) 123.35,41.07 123.35,40.41 arc(123.29,40.09) 123.1,39.81 122.57,39.27 arc(122.49,39.08) 122.57,38.89 122.71,38.74 arc(122.71,38.35) 122.32,38.35 122.18,38.5 arc(121.98,38.58) 121.79,38.5 121.32,38.02 arc(121.09,37.68) 121,37.27 121,35.12 arc(120.93,34.73) 120.71,34.4 119.42,33.11 arc(119.14,32.93) 118.82,32.86 116.14,32.86 arc(115.99,32.83) 115.85,32.74 114.45,31.34 arc(114.37,31.22) 114.34,31.08 arc(114.28,30.79) 114.12,30.54 111.27,27.69 arc(110.82,27.39) 110.28,27.28 110.21,27.28 arc(110,27.24) 109.83,27.12 108.49,25.78 arc(108.35,25.65) 108.2,25.54 arc(107.58,25.23) 106.9,25.12 105.09,25.12 arc(104.66,25.03) 104.29,24.79 103.15,23.65 arc(102.69,23.35) 102.15,23.24 100.65,23.24 arc(100.35,23.18) 100.1,23.01 97.23,20.14 arc(97.07,19.9) 97.01,19.61 97.01,15.57 arc(96.95,15.24) 96.76,14.97 95.7,13.91 arc(93.78,12.63) 91.52,12.18 90.86,12.18 arc(90.46,12.01) 90.3,11.61 90.3,10.31 arc(90.37,10.13) 90.54,10.06 90.73,10.06 arc(90.8,10.07) 90.86,10.11 v6(91.15,10.41)
  07_SIG3 w0.237: v2(123.24,42.84) 123.66,42.42 arc(123.72,42.33) 123.74,42.23 123.74,41.82 arc(123.7,41.65) 123.61,41.5
PCIE_RX7_P: length 63.8
  TOP w0.147: v2(123.24,43.84) 122.74,44.34 U1.AH2 ; U2.B45 91.65,5.52 arc(91.7,5.75) 91.82,5.95 91.85,5.97 arc(91.97,6.16) 92.02,6.39 92.02,9.5 arc(91.94,9.7) 91.74,9.78 91.59,9.78 arc(91.53,9.77) 91.48,9.73 v6(91.15,9.41)
  07_SIG3 w0.183: v6(91.15,9.41) 90.86,9.7 arc(90.8,9.74) 90.73,9.75 90.54,9.75 arc(90.15,9.92) 89.99,10.31 89.99,11.61 arc(90.25,12.23) 90.86,12.48 91.52,12.48 arc(93.67,12.91) 95.49,14.12 96.55,15.18 arc(96.66,15.36) 96.71,15.57 96.71,19.61 arc(96.79,20.01) 97.02,20.36 99.89,23.23 arc(100.23,23.46) 100.65,23.54 102.15,23.54 arc(102.58,23.63) 102.94,23.87 104.07,25 arc(104.54,25.32) 105.09,25.43 106.9,25.43 arc(107.49,25.52) 108.02,25.78 arc(108.15,25.88) 108.27,25.99 109.61,27.34 arc(109.89,27.52) 110.21,27.59 110.28,27.59 arc(110.7,27.67) 111.06,27.91 113.9,30.75 arc(114,30.9) 114.04,31.08 arc(114.09,31.34) 114.23,31.55 115.64,32.96 arc(115.87,33.11) 116.14,33.17 118.82,33.17 arc(119.03,33.21) 119.2,33.33 120.49,34.61 arc(120.65,34.85) 120.7,35.12 120.7,37.27 arc(120.8,37.8) 121.1,38.24 122.89,40.02 arc(123.01,40.2) 123.05,40.41 123.05,40.93 arc(122.99,41.23) 122.82,41.49
  07_SIG3 w0.237: v2(123.24,43.84) 122.86,43.46 arc(122.77,43.33) 122.74,43.17 122.74,41.68 arc(122.76,41.58) 122.82,41.49
PCIE_RX8_N: length 69.2
  TOP w0.147: v6(96.15,10.41) 96.47,10.09 arc(96.52,10.05) 96.59,10.04 96.74,10.04 arc(97.12,9.88) 97.28,9.5 97.28,6.39 arc(97.33,6.16) 97.45,5.97 97.48,5.95 arc(97.6,5.75) 97.65,5.52 U2.B51 ; U1.AJ3 123.74,45.34 v2(124.24,44.84)
  03_SIG1 w0.183: v6(96.15,10.41) 95.86,10.11 arc(95.8,10.07) 95.73,10.06 93.22,10.06 arc(92.81,10.23) 92.63,10.65 92.63,19.68 arc(92.66,19.82) 92.75,19.95 93.63,20.83 arc(96.3,22.61) 99.44,23.24 102.65,23.24 arc(103.6,23.43) 104.41,23.97 arc(105.34,24.59) 106.43,24.8 111.4,24.8 arc(113.53,25.23) 115.33,26.43 120.74,31.84 arc(121.03,32.28) 121.13,32.79 arc(121.21,33.17) 121.42,33.49 121.81,33.87 arc(123.65,36.63) 124.29,39.88 124.29,40.8 arc(124.34,41.04) 124.48,41.24 124.61,41.38
  03_SIG1 w0.237: v2(124.24,44.84) 124.24,45.05 arc(124.49,45.3) 124.74,45.05 124.74,41.68 arc(124.7,41.51) 124.61,41.38
PCIE_RX8_P: length 69.1
  TOP w0.147: v6(96.15,9.41) 96.48,9.73 arc(96.53,9.77) 96.59,9.78 96.74,9.78 arc(96.94,9.7) 97.02,9.5 97.02,6.39 arc(96.97,6.16) 96.84,5.97 96.82,5.95 arc(96.7,5.75) 96.65,5.52 U2.B50 ; v2(124.24,45.84) 123.74,46.34 U1.AJ4
  03_SIG1 w0.183: 123.84,41.49 123.85,41.48 arc(123.95,41.34) 123.99,41.16 123.99,39.88 arc(123.36,36.74) 121.59,34.09 121.2,33.7 arc(120.93,33.28) 120.83,32.79 arc(120.75,32.39) 120.52,32.05 120.11,31.64 115.12,26.65 arc(113.41,25.51) 111.4,25.11 106.43,25.11 arc(105.22,24.87) 104.2,24.18 arc(103.49,23.71) 102.65,23.54 99.44,23.54 arc(96.18,22.9) 93.42,21.05 92.53,20.16 arc(92.38,19.94) 92.33,19.68 92.33,10.65 arc(92.59,10.02) 93.22,9.75 95.73,9.75 arc(95.8,9.74) 95.86,9.7 v6(96.15,9.41)
  03_SIG1 w0.237: v2(124.24,45.84) 123.98,45.58 arc(123.8,45.32) 123.74,45 123.74,41.75 arc(123.76,41.61) 123.84,41.49
PCIE_RX9_N: length 57.2
  TOP w0.147: v6(100.15,10.41) 100.47,10.09 arc(100.52,10.05) 100.59,10.04 100.74,10.04 arc(101.12,9.88) 101.28,9.5 101.28,6.39 arc(101.33,6.16) 101.45,5.97 101.48,5.95 arc(101.6,5.75) 101.65,5.52 U2.B55 ; U1.AK1 v2(125.24,42.84)
  07_SIG3 w0.183: 125.61,41.5 125.48,41.37 arc(125.38,41.24) 125.35,41.07 125.35,39.84 arc(125.26,39.35) 124.98,38.94 124.81,38.77 arc(124.74,38.6) 124.81,38.44 arc(124.88,38.27) 124.81,38.1 124.76,38.05 arc(124.59,37.98) 124.42,38.05 arc(124.26,38.12) 124.09,38.05 124.03,38 arc(123.97,37.83) 124.03,37.66 arc(124.1,37.49) 124.03,37.33 123.98,37.27 arc(123.81,37.2) 123.65,37.27 arc(123.48,37.34) 123.31,37.27 123.2,37.16 arc(122.6,36.26) 122.39,35.2 122.39,34.39 arc(122.23,33.6) 121.78,32.93 120.22,31.37 arc(119.86,31.13) 119.45,31.05 arc(119.05,30.97) 118.71,30.74 117.48,29.52 arc(116.96,29.17) 116.35,29.05 arc(115.56,28.89) 114.89,28.44 111.49,25.04 arc(111.05,24.75) 110.53,24.65 109.21,24.65 arc(108.9,24.58) 108.64,24.41 107.66,23.43 arc(107.17,23.1) 106.58,22.99 105.96,22.99 arc(105.65,22.92) 105.38,22.75 101.2,18.57 arc(101.08,18.38) 101.04,18.17 101.04,17.27 arc(101.07,17.09) 101.17,16.94 arc(101.41,16.6) 101.49,16.19 101.49,15.58 arc(101.39,15.09) 101.11,14.67 100.5,14.07 arc(99.61,12.73) 99.3,11.15 99.3,10.31 arc(99.37,10.13) 99.54,10.06 99.73,10.06 arc(99.8,10.07) 99.86,10.11 v6(100.15,10.41)
  07_SIG3 w0.237: v2(125.24,42.84) 125.66,42.42 arc(125.72,42.33) 125.74,42.23 125.74,41.82 arc(125.7,41.65) 125.61,41.5
PCIE_RX9_P: length 57.2
  TOP w0.147: v6(100.15,9.41) 100.48,9.73 arc(100.53,9.77) 100.59,9.78 100.74,9.78 arc(100.94,9.7) 101.02,9.5 101.02,6.39 arc(100.97,6.16) 100.84,5.97 100.82,5.95 arc(100.7,5.75) 100.65,5.52 U2.B54 ; U1.AK2 v2(125.24,43.84)
  07_SIG3 w0.183: v6(100.15,9.41) 99.86,9.7 arc(99.8,9.74) 99.73,9.75 99.54,9.75 arc(99.15,9.92) 98.99,10.31 98.99,11.15 arc(99.33,12.85) 100.29,14.28 100.9,14.89 arc(101.11,15.21) 101.18,15.58 101.18,16.19 arc(101.12,16.48) 100.96,16.73 arc(100.79,16.98) 100.73,17.27 100.73,18.17 arc(100.8,18.5) 100.99,18.78 105.17,22.96 arc(105.53,23.21) 105.96,23.29 106.58,23.29 arc(107.05,23.38) 107.45,23.65 108.42,24.63 arc(108.78,24.87) 109.21,24.95 110.53,24.95 arc(110.93,25.03) 111.27,25.26 114.67,28.66 arc(115.44,29.17) 116.35,29.35 arc(116.85,29.45) 117.27,29.73 118.49,30.96 arc(118.93,31.25) 119.45,31.35 arc(119.75,31.41) 120,31.58 121.57,33.15 arc(121.95,33.72) 122.08,34.39 122.08,35.2 arc(122.32,36.38) 122.98,37.37 124.77,39.16 arc(124.97,39.47) 125.05,39.84 125.05,40.93 arc(124.99,41.23) 124.82,41.49
  07_SIG3 w0.237: v2(125.24,43.84) 124.86,43.46 arc(124.77,43.33) 124.74,43.17 124.74,41.68 arc(124.76,41.58) 124.82,41.49
PCIE_RX10_N: length 60.4
  TOP w0.147: v6(104.15,10.41) 104.47,10.09 arc(104.52,10.05) 104.59,10.04 104.74,10.04 arc(105.12,9.88) 105.28,9.5 105.28,6.39 arc(105.33,6.16) 105.46,5.97 105.48,5.95 arc(105.6,5.75) 105.65,5.52 U2.B59 ; v2(127.24,42.84) U1.AM1
  05_SIG2 w0.183: v6(104.15,10.41) 103.86,10.11 arc(103.8,10.07) 103.73,10.06 103.35,10.06 arc(103.18,10.13) 103.11,10.29 arc(103.04,10.46) 102.88,10.52 102.61,10.52 arc(102.45,10.46) 102.38,10.29 102.38,10.18 arc(102.35,10.1) 102.26,10.06 102.14,10.06 arc(101.39,10.37) 101.08,11.11 101.08,11.97 arc(101.14,12.1) 101.27,12.16 arc(101.4,12.21) 101.45,12.34 101.45,12.7 arc(101.4,12.84) 101.27,12.89 arc(101.14,12.94) 101.08,13.08 101.08,14.42 arc(101.13,14.66) 101.26,14.85 arc(101.44,15.12) 101.5,15.43 101.5,16.8 arc(101.45,17.05) 101.31,17.27 arc(101.17,17.47) 101.12,17.71 101.12,18.08 arc(101.24,18.67) 101.57,19.16 102.77,20.36 arc(102.87,20.43) 103,20.45 arc(103.19,20.49) 103.36,20.6 105.42,22.67 arc(105.72,22.86) 106.07,22.93 106.72,22.93 arc(107.04,23) 107.32,23.18 108.46,24.32 arc(108.78,24.54) 109.17,24.62 110.62,24.62 arc(110.86,24.66) 111.06,24.8 112.07,25.81 arc(112.4,26.03) 112.78,26.1 112.96,26.1 arc(115.29,26.57) 117.27,27.89 119.09,29.71 arc(119.83,30.2) 120.71,30.38 arc(121.32,30.5) 121.83,30.84 123.9,32.92 arc(124.18,33.33) 124.28,33.83 124.28,36.28 arc(124.4,36.88) 124.74,37.39 126.97,39.62 arc(127.27,40.06) 127.37,40.58 127.37,40.87 arc(127.42,41.1) 127.54,41.29
  05_SIG2 w0.237: v2(127.24,42.84) 127.56,42.52 arc(127.69,42.32) 127.74,42.09 127.74,41.59 arc(127.72,41.49) 127.66,41.41 127.54,41.29
PCIE_RX10_P: length 60.5
  TOP w0.147: v2(127.24,43.84) U1.AM2 ; v6(104.15,9.41) 104.48,9.73 arc(104.53,9.77) 104.59,9.78 104.74,9.78 arc(104.94,9.7) 105.02,9.5 105.02,6.39 arc(104.97,6.16) 104.85,5.97 104.82,5.95 arc(104.7,5.75) 104.65,5.52 U2.B58
  05_SIG2 w0.183: 126.84,41.29 126.95,41.18 arc(127.03,41.05) 127.07,40.9 127.07,40.58 arc(126.98,40.18) 126.76,39.84 124.52,37.61 arc(124.12,37) 123.98,36.28 123.98,33.83 arc(123.9,33.45) 123.69,33.13 121.61,31.06 arc(121.2,30.78) 120.71,30.68 arc(119.72,30.49) 118.88,29.92 117.15,28.2 117.06,28.11 arc(115.18,26.85) 112.96,26.41 112.78,26.41 arc(112.28,26.31) 111.85,26.02 110.84,25.01 arc(110.74,24.95) 110.62,24.92 109.17,24.92 arc(108.67,24.82) 108.24,24.54 107.1,23.4 arc(106.93,23.28) 106.72,23.24 106.07,23.24 arc(105.6,23.15) 105.21,22.88 103.14,20.82 arc(103.08,20.77) 103,20.76 arc(102.76,20.71) 102.55,20.57 101.36,19.38 arc(100.96,18.78) 100.82,18.08 100.82,17.71 arc(100.89,17.35) 101.09,17.05 arc(101.17,16.94) 101.19,16.8 101.19,15.43 arc(101.16,15.23) 101.05,15.07 arc(100.85,14.77) 100.78,14.42 100.78,11.11 arc(101.18,10.15) 102.14,9.75 103.73,9.75 arc(103.8,9.74) 103.86,9.7 v6(104.15,9.41)
  05_SIG2 w0.237: v2(127.24,43.84) 127.1,43.71 arc(126.83,43.3) 126.74,42.83 126.74,41.53 arc(126.76,41.4) 126.84,41.29
PCIE_RX11_N: length 59.5
  TOP w0.147: U2.B63 109.65,5.52 arc(109.6,5.75) 109.48,5.95 109.46,5.97 arc(109.33,6.16) 109.28,6.39 109.28,9.5 arc(109.12,9.88) 108.74,10.04 108.59,10.04 arc(108.52,10.05) 108.47,10.09 v6(108.15,10.41) ; v2(129.24,42.84) U1.AP1
  05_SIG2 w0.183: v6(108.15,10.41) 107.86,10.11 arc(107.8,10.07) 107.73,10.06 106.26,10.06 arc(105.88,10.22) 105.72,10.6 105.72,11.48 arc(105.83,11.74) 106.09,11.85 106.21,11.85 arc(106.57,12.21) 106.21,12.58 106.09,12.58 arc(105.83,12.69) 105.72,12.94 105.72,14.25 arc(105.63,14.7) 105.38,15.08 arc(105.14,15.44) 105.05,15.87 105.05,16.4 arc(105.1,16.64) 105.24,16.84 105.37,16.97 arc(105.5,17.17) 105.55,17.41 105.55,18.13 arc(105.47,18.53) 105.24,18.87 arc(105.1,19.08) 105.05,19.33 105.05,20.25 arc(105.12,20.57) 105.3,20.84 106,21.55 arc(106.18,21.66) 106.39,21.71 109.46,21.71 arc(110.55,21.92) 111.48,22.54 113.4,24.47 arc(114.2,25) 115.13,25.18 115.72,25.18 arc(116.88,25.41) 117.86,26.07 120.24,28.44 arc(120.48,28.61) 120.77,28.66 120.92,28.66 arc(121.17,28.7) 121.4,28.82 121.42,28.82 125.24,32.64 arc(125.55,33.1) 125.65,33.64 125.65,35.22 arc(125.79,35.93) 126.19,36.52 128.75,39.08 arc(129.21,39.77) 129.37,40.58 129.37,40.83 arc(129.42,41.09) 129.57,41.31
  05_SIG2 w0.237: 129.57,41.31 129.66,41.41 arc(129.72,41.49) 129.74,41.59 129.74,42.09 arc(129.69,42.32) 129.56,42.52 v2(129.24,42.84)
PCIE_RX11_P: length 59.4
  TOP w0.147: v6(108.15,9.41) 108.48,9.73 arc(108.53,9.77) 108.59,9.78 108.74,9.78 arc(108.94,9.7) 109.02,9.5 109.02,6.39 arc(108.97,6.16) 108.84,5.97 108.82,5.95 arc(108.7,5.75) 108.65,5.52 U2.B62 ; v2(129.24,43.84) U1.AP2
  05_SIG2 w0.183: v6(108.15,9.41) 107.86,9.7 arc(107.8,9.74) 107.73,9.75 106.26,9.75 arc(105.66,10) 105.42,10.6 105.42,14.25 arc(105.35,14.58) 105.16,14.86 arc(104.86,15.32) 104.75,15.87 104.75,16.4 arc(104.82,16.75) 105.02,17.06 105.15,17.19 arc(105.22,17.29) 105.24,17.41 105.24,18.13 arc(105.18,18.42) 105.02,18.66 arc(104.82,18.96) 104.75,19.33 104.75,20.25 arc(104.83,20.69) 105.08,21.06 105.78,21.76 arc(106.06,21.95) 106.39,22.01 109.46,22.01 arc(110.44,22.2) 111.26,22.76 113.19,24.68 arc(114.08,25.28) 115.13,25.49 115.72,25.49 arc(116.76,25.69) 117.65,26.28 120.02,28.66 arc(120.36,28.89) 120.77,28.97 120.92,28.97 arc(121.08,28.99) 121.22,29.07 arc(121.26,29.09) 121.29,29.12 125.02,32.85 arc(125.26,33.21) 125.35,33.64 125.35,35.22 arc(125.51,36.04) 125.98,36.74 128.53,39.29 arc(128.93,39.89) 129.07,40.58 129.07,40.9 arc(129.05,40.99) 129.02,41.08 arc(128.99,41.13) 128.95,41.18
  05_SIG2 w0.237: v2(129.24,43.84) 129.11,43.72 arc(128.83,43.3) 128.74,42.81 128.74,41.53 arc(128.76,41.4) 128.84,41.29 128.95,41.18
PCIE_RX12_N: length 56.6
  TOP w0.147: U1.AT1 130.74,43.34 v2(131.24,42.84) ; U2.B67 113.65,5.52 arc(113.6,5.75) 113.48,5.95 113.45,5.97 arc(113.33,6.16) 113.28,6.39 113.28,9.5 arc(113.12,9.88) 112.74,10.04 112.59,10.04 arc(112.52,10.05) 112.47,10.09 v6(112.15,10.41)
  05_SIG2 w0.183: v6(112.15,10.41) 111.86,10.11 arc(111.8,10.07) 111.73,10.06 111.31,10.06 arc(111.15,10.12) 111.08,10.28 arc(111.01,10.45) 110.84,10.52 110.59,10.52 arc(110.42,10.45) 110.35,10.28 arc(110.29,10.12) 110.13,10.06 arc(109.37,10.37) 109.06,11.13 109.06,11.75 arc(109.13,11.92) 109.3,11.99 arc(109.48,12.07) 109.55,12.24 109.55,12.48 arc(109.48,12.65) 109.3,12.73 arc(109.13,12.8) 109.06,12.97 109.06,14.19 arc(109.12,14.53) 109.31,14.81 arc(109.48,15.06) 109.54,15.36 109.54,16.25 arc(109.46,16.65) 109.24,16.98 arc(109.1,17.19) 109.05,17.43 109.05,18.32 arc(109.09,18.5) 109.19,18.65 111.95,21.41 arc(113.91,22.72) 116.23,23.18 arc(117.66,23.47) 118.86,24.27 120.31,25.72 arc(120.9,26.28) 121.53,26.8 122.22,27.31 arc(122.78,27.79) 123.3,28.32 123.87,28.96 arc(124.43,29.67) 124.91,30.43 arc(125.09,30.69) 125.3,30.93 arc(125.73,31.34) 126.2,31.71 arc(126.58,32.01) 126.93,32.33 127.95,33.36 arc(128.24,33.78) 128.34,34.28 128.34,35.97 arc(128.52,36.9) 129.05,37.68 130.96,39.6 arc(131.26,40.05) 131.37,40.58 131.37,40.88 arc(131.41,41.1) 131.53,41.28
  05_SIG2 w0.237: v2(131.24,42.84) 131.68,42.4 arc(131.72,42.34) 131.74,42.26 131.74,41.59 arc(131.72,41.49) 131.66,41.41 131.53,41.28
PCIE_RX12_P: length 56.6
  TOP w0.147: U1.AT2 130.74,44.34 v2(131.24,43.84) ; U2.B66 112.65,5.52 arc(112.7,5.75) 112.82,5.95 112.84,5.97 arc(112.97,6.16) 113.02,6.39 113.02,9.5 arc(112.94,9.7) 112.74,9.78 112.59,9.78 arc(112.53,9.77) 112.48,9.73 v6(112.15,9.41)
  05_SIG2 w0.183: v6(112.15,9.41) 111.86,9.7 arc(111.8,9.74) 111.73,9.75 110.13,9.75 arc(109.15,10.16) 108.75,11.13 108.75,14.19 arc(108.84,14.64) 109.1,15.03 arc(109.2,15.18) 109.23,15.36 109.23,16.25 arc(109.18,16.53) 109.02,16.76 arc(108.82,17.07) 108.75,17.43 108.75,18.32 arc(108.81,18.61) 108.97,18.87 111.73,21.62 arc(113.79,23) 116.23,23.49 arc(117.54,23.75) 118.65,24.49 120.09,25.93 arc(120.7,26.51) 121.34,27.04 122.03,27.56 arc(122.58,28.01) 123.07,28.52 123.64,29.16 arc(124.18,29.85) 124.65,30.58 arc(124.84,30.88) 125.08,31.15 arc(125.53,31.57) 126.02,31.95 arc(126.38,32.24) 126.71,32.55 127.74,33.57 arc(127.96,33.9) 128.03,34.28 128.03,35.97 arc(128.24,37.01) 128.83,37.9 130.75,39.81 arc(130.98,40.17) 131.07,40.58 131.07,40.9 arc(131.03,41.05) 130.95,41.18
  05_SIG2 w0.237: 130.95,41.18 130.84,41.29 arc(130.76,41.4) 130.74,41.53 130.74,42.98 arc(130.8,43.32) 130.99,43.6 v2(131.24,43.84)
PCIE_RX13_N: length 55.6
  TOP w0.147: v6(116.15,10.41) 116.47,10.09 arc(116.52,10.05) 116.59,10.04 116.74,10.04 arc(117.12,9.88) 117.28,9.5 117.28,6.39 arc(117.33,6.16) 117.46,5.97 117.48,5.95 arc(117.6,5.75) 117.65,5.52 U2.B71 ; v2(133.24,42.84) 132.74,43.34 U1.AV1
  05_SIG2 w0.183: v6(116.15,10.41) 115.86,10.11 arc(115.8,10.07) 115.73,10.06 114.85,10.06 arc(114.26,10.3) 114.02,10.89 114.02,11.11 arc(114.08,11.26) 114.23,11.32 114.3,11.32 arc(114.49,11.4) 114.58,11.6 114.58,11.77 arc(114.49,11.97) 114.3,12.05 arc(114.1,12.13) 114.02,12.33 114.02,12.5 arc(114.1,12.7) 114.3,12.78 arc(114.51,12.87) 114.59,13.08 114.59,13.22 arc(114.51,13.43) 114.3,13.51 arc(114.1,13.59) 114.02,13.79 114.02,14.04 arc(113.95,14.36) 113.77,14.64 113.2,15.21 arc(113.09,15.37) 113.05,15.57 113.05,16.62 arc(113.11,16.9) 113.27,17.14 113.46,17.33 arc(113.62,17.57) 113.67,17.85 113.67,18.31 arc(113.58,18.76) 113.33,19.14 113.23,19.24 arc(113.09,19.45) 113.04,19.69 113.04,19.87 arc(113.11,20.23) 113.31,20.53 113.99,21.21 arc(114.74,21.71) 115.62,21.89 118.67,21.89 arc(118.99,21.95) 119.27,22.14 119.93,22.79 arc(120.31,23.09) 120.75,23.27 arc(121.06,23.41) 121.33,23.64 121.95,24.26 arc(122.09,24.42) 122.2,24.58 arc(122.24,24.67) 122.27,24.76 122.33,25.28 arc(122.33,25.29) 122.34,25.3 122.34,25.31 arc(122.48,25.66) 122.71,25.96 126.04,29.29 arc(126.15,29.45) 126.19,29.65 arc(126.25,29.97) 126.44,30.25 128.73,32.54 arc(129.45,33.62) 129.7,34.89 129.7,35.52 arc(129.93,36.65) 130.57,37.62 132.67,39.72 arc(133.13,40.4) 133.29,41.2 133.29,42.72 arc(133.27,42.79) v2(133.24,42.84)
PCIE_RX13_P: length 55.6
  TOP w0.147: U1.AV2 132.74,44.34 v2(133.24,43.84) ; v6(116.15,9.41) 116.48,9.73 arc(116.53,9.77) 116.59,9.78 116.74,9.78 arc(116.94,9.7) 117.02,9.5 117.02,6.39 arc(116.97,6.16) 116.85,5.97 116.82,5.95 arc(116.7,5.75) 116.65,5.52 U2.B70
  05_SIG2 w0.183: v6(116.15,9.41) 115.86,9.7 arc(115.8,9.74) 115.73,9.75 114.85,9.75 arc(114.05,10.09) 113.71,10.89 113.71,14.04 arc(113.67,14.25) 113.55,14.42 112.99,14.99 arc(112.81,15.26) 112.75,15.57 112.75,16.62 arc(112.82,17.01) 113.05,17.35 113.24,17.55 arc(113.34,17.69) 113.37,17.85 113.37,18.31 arc(113.3,18.64) 113.11,18.92 113.01,19.03 arc(112.81,19.33) 112.73,19.69 112.73,19.87 arc(112.83,20.35) 113.1,20.75 113.77,21.42 arc(114.62,21.99) 115.62,22.19 118.67,22.19 arc(118.88,22.23) 119.05,22.35 119.71,23.01 arc(120.15,23.35) 120.66,23.57 arc(120.9,23.67) 121.1,23.84 arc(121.1,23.85) 121.11,23.85 121.11,23.85 arc(121.21,23.95) 121.31,24.05 121.74,24.48 arc(121.85,24.6) 121.94,24.74 arc(121.96,24.77) 121.96,24.8 122.03,25.34 arc(122.03,25.35) 122.04,25.36 122.04,25.38 arc(122.22,25.81) 122.5,26.18 125.82,29.5 arc(125.87,29.57) 125.88,29.65 arc(125.97,30.09) 126.22,30.46 128.51,32.75 arc(129.17,33.73) 129.4,34.89 129.4,35.52 arc(129.65,36.77) 130.36,37.83 132.46,39.93 arc(132.85,40.51) 132.98,41.2 132.98,42.23 132.98,42.27 arc(132.94,42.39) 132.86,42.49 132.85,42.5
  05_SIG2 w0.237: v2(133.24,43.84) 132.97,43.58 arc(132.8,43.32) 132.74,43.01 132.74,42.77 arc(132.77,42.63) 132.85,42.5
PCIE_RX14_N: length 53.3
  TOP w0.147: U1.AY1 134.74,43.34 v2(135.24,42.84) ; U2.B75 121.65,5.52 arc(121.6,5.75) 121.48,5.95 121.46,5.97 arc(121.33,6.16) 121.28,6.39 121.28,9.5 arc(121.12,9.88) 120.74,10.04 120.59,10.04 arc(120.52,10.05) 120.47,10.09 v6(120.15,10.41)
  05_SIG2 w0.183: v2(135.24,42.84) 135.24,42.46 arc(135.24,42.45) 135.24,42.45 arc(135.26,42.36) 135.28,42.28 arc(135.29,42.23) 135.29,42.18 135.29,41.99 arc(135.29,41.92) 135.28,41.85 arc(135.28,41.85) 135.28,41.84 arc(135.03,40.76) 134.4,39.84 131.34,36.79 arc(131.08,36.41) 130.97,35.96 130.94,35.42 130.9,34.89 arc(130.57,33.24) 129.64,31.85 128.54,30.75 arc(128.42,30.58) 128.37,30.37 arc(128.25,29.92) 127.93,29.58 arc(127.81,29.49) 127.72,29.39 127.71,29.36 123.6,25.26 arc(123.48,25.08) 123.44,24.87 123.44,24.66 arc(123.35,24.18) 123.08,23.77 120.61,21.31 arc(119.89,20.83) 119.04,20.66 118.67,20.66 arc(117.93,20.36) 117.63,19.62 arc(117.53,19.13) 117.25,18.71 arc(117.11,18.49) 117.06,18.24 117.06,17.86 arc(117.08,17.72) 117.17,17.6 arc(117.41,17.23) 117.5,16.79 117.5,15.6 arc(117.45,15.36) 117.32,15.17 arc(117.17,14.94) 117.12,14.67 117.12,13.33 arc(117.21,13.11) 117.43,13.02 arc(117.65,12.93) 117.74,12.71 117.74,12.6 arc(117.65,12.38) 117.43,12.29 arc(117.21,12.2) 117.12,11.98 117.12,10.98 arc(117.39,10.33) 118.03,10.06 arc(118.24,10.15) 118.33,10.35 arc(118.41,10.56) 118.62,10.65 118.77,10.65 arc(118.97,10.56) 119.06,10.35 arc(119.14,10.15) 119.35,10.06 119.73,10.06 arc(119.8,10.07) 119.86,10.11 v6(120.15,10.41)
PCIE_RX14_P: length 53.3
  TOP w0.147: U1.AY2 134.74,44.34 v2(135.24,43.84) ; U2.B74 120.65,5.52 arc(120.7,5.75) 120.82,5.95 120.84,5.97 arc(120.97,6.16) 121.02,6.39 121.02,9.5 arc(120.94,9.7) 120.74,9.78 120.59,9.78 arc(120.53,9.77) 120.48,9.73 v6(120.15,9.41)
  05_SIG2 w0.183: v6(120.15,9.41) 119.86,9.7 arc(119.8,9.74) 119.73,9.75 118.03,9.75 arc(117.17,10.11) 116.81,10.98 116.81,14.67 arc(116.89,15.06) 117.11,15.38 arc(117.17,15.48) 117.2,15.6 117.2,16.79 arc(117.13,17.11) 116.95,17.38 arc(116.8,17.6) 116.75,17.86 116.75,18.24 arc(116.82,18.61) 117.04,18.93 arc(117.25,19.24) 117.32,19.62 arc(117.72,20.57) 118.67,20.97 119.04,20.97 arc(119.78,21.11) 120.4,21.53 122.86,23.99 arc(123.07,24.3) 123.14,24.66 123.14,24.87 arc(123.2,25.2) 123.39,25.48 127.47,29.56 arc(127.6,29.71) 127.76,29.84 127.76,29.84 arc(127.98,30.07) 128.07,30.39 arc(128.14,30.7) 128.32,30.96 129.43,32.07 arc(130.29,33.36) 130.6,34.89 arc(130.6,34.89) 130.6,34.9 130.66,35.97 arc(130.8,36.53) 131.13,37 134.18,40.06 arc(134.75,40.88) 134.98,41.86 134.98,41.86 arc(134.98,41.93) 134.98,41.99 134.98,42.18 arc(134.98,42.21) 134.98,42.24 134.95,42.34 arc(134.95,42.34) 134.95,42.35 arc(134.91,42.43) 134.85,42.5
  05_SIG2 w0.237: v2(135.24,43.84) 134.97,43.58 arc(134.8,43.32) 134.74,43.01 134.74,42.77 arc(134.77,42.63) 134.85,42.5
PCIE_RX15_N: length 50.1
  TOP w0.147: v6(124.15,10.41) 124.47,10.09 arc(124.52,10.05) 124.59,10.04 124.74,10.04 arc(125.12,9.88) 125.28,9.5 125.28,6.39 arc(125.33,6.16) 125.45,5.97 125.48,5.95 arc(125.6,5.75) 125.65,5.52 U2.B79 ; v2(137.24,42.84) 136.74,43.34 U1.BB1
  05_SIG2 w0.183: v6(124.15,10.41) 123.86,10.11 arc(123.8,10.07) 123.73,10.06 122.88,10.06 arc(122.24,10.33) 121.97,10.97 121.97,11.73 arc(122.05,11.93) 122.25,12.01 arc(122.45,12.09) 122.53,12.29 122.53,12.46 arc(122.45,12.66) 122.25,12.74 arc(122.05,12.82) 121.97,13.02 121.97,13.19 arc(122.05,13.39) 122.25,13.47 arc(122.45,13.56) 122.53,13.75 122.53,13.92 arc(122.45,14.12) 122.25,14.2 arc(122.05,14.29) 121.97,14.49 121.97,19.47 arc(122.19,20.57) 122.82,21.51 124.06,22.76 arc(124.22,23) 124.28,23.28 124.28,23.37 arc(124.33,23.6) 124.46,23.8 124.97,24.31 arc(124.98,24.33) 125,24.34 arc(125.17,24.58) 125.33,24.83 arc(125.58,25.21) 125.89,25.56 131.47,31.13 arc(132.09,32.06) 132.3,33.16 132.3,34.76 arc(132.56,36.05) 133.29,37.14 136.66,40.51 arc(137.12,41.21) 137.29,42.03 137.29,42.72 arc(137.27,42.79) v2(137.24,42.84)
PCIE_RX15_P: length 50.1
  TOP w0.147: v6(124.15,9.41) 124.48,9.73 arc(124.53,9.77) 124.59,9.78 124.74,9.78 arc(124.94,9.7) 125.02,9.5 125.02,6.39 arc(124.97,6.16) 124.84,5.97 124.82,5.95 arc(124.7,5.75) 124.65,5.52 U2.B78 ; v2(137.24,43.84) 136.74,44.34 U1.BB2
  05_SIG2 w0.183: v6(124.15,9.41) 123.86,9.7 arc(123.8,9.74) 123.73,9.75 122.88,9.75 arc(122.02,10.11) 121.66,10.97 121.66,19.47 arc(121.91,20.69) 122.6,21.72 123.85,22.97 arc(123.94,23.11) 123.98,23.28 123.98,23.37 arc(124.05,23.72) 124.24,24.01 124.74,24.51 arc(124.75,24.52) 124.76,24.54 arc(124.92,24.75) 125.06,24.98 arc(125.34,25.4) 125.68,25.78 131.25,31.35 arc(131.8,32.18) 132,33.16 132,34.76 arc(132.28,36.17) 133.08,37.36 136.44,40.72 arc(136.84,41.32) 136.98,42.03 136.98,42.2 arc(136.98,42.24) 136.98,42.28 arc(136.94,42.39) 136.86,42.49 136.85,42.5
  05_SIG2 w0.237: v2(137.24,43.84) 136.97,43.58 arc(136.8,43.32) 136.74,43.01 136.74,42.77 arc(136.77,42.63) 136.85,42.5
PCIE_TX0_C_N: length 12.9
  TOP w0.147: C61.1 65.25,14.3 v1(65.18,14.23)
  10_GND w0.163: v1(65.18,14.23) 64.85,13.91 arc(64.82,13.85) 64.81,13.79 64.81,10.41 arc(64.63,9.53) 64.14,8.79 63.59,8.24 arc(63.36,7.9) 63.28,7.5 63.28,6.21 arc(63.32,6.02) 63.42,5.87 63.47,5.82 arc(63.6,5.62) 63.65,5.39 U2.A17
PCIE_TX0_C_P: length 12.9
  TOP w0.147: C60.1 64.1,14.3 v1(64.18,14.23)
  10_GND w0.163: U2.A16 62.65,5.46 arc(62.69,5.64) 62.79,5.79 62.88,5.88 arc(62.98,6.04) 63.02,6.22 63.02,7.5 arc(63.12,8) 63.4,8.43 63.95,8.98 arc(64.39,9.63) 64.54,10.41 64.54,13.79 arc(64.53,13.85) 64.5,13.91 v1(64.18,14.23)
PCIE_TX0_N: length 72.1
  TOP w0.147: C61.2 65.25,17.95 v1(65.18,18.02) ; v2(114.24,47.84) U1.Y6
  07_SIG3 w0.183: 110.6,42.45 110.51,42.35 arc(110.48,42.33) 110.46,42.3 arc(110.4,42.17) 110.38,42.04 110.38,41.78 arc(110.33,41.55) 110.2,41.35 109.93,41.08 arc(109.78,40.98) 109.59,40.94 106.17,40.94 arc(104.69,40.64) 103.44,39.81 99.54,35.91 arc(98.7,35.35) 97.72,35.15 arc(96.28,34.87) 95.07,34.05 93.03,32.01 arc(92.24,31.49) 91.31,31.3 80.06,31.3 arc(79.18,31.13) 78.43,30.63 77.41,29.61 arc(77.13,29.42) 76.81,29.36 69.81,29.36 arc(68.95,29.19) 68.23,28.7 66.16,26.64 arc(65.76,26.04) 65.62,25.34 65.62,25.09 arc(65.69,24.73) 65.9,24.43 arc(66.27,23.87) 66.4,23.21 66.4,22.58 arc(66.48,22.39) 66.67,22.31 66.85,22.31 arc(67.12,22.03) 66.85,21.76 66.67,21.76 arc(66.48,21.68) 66.4,21.49 66.4,20.67 arc(66.35,20.41) 66.2,20.19 65.86,19.85 arc(65.78,19.66) 65.86,19.46 65.92,19.4 arc(65.92,19.01) 65.53,19.01 65.47,19.07 arc(65.28,19.15) 65.08,19.07 arc(65.05,19.04) 65.02,19 64.9,18.85 arc(64.85,18.76) 64.83,18.65 64.83,18.44 arc(64.84,18.37) 64.88,18.32 v1(65.18,18.02)
  07_SIG3 w0.237: 110.6,42.45 arc(110.7,42.6) 110.74,42.77 110.74,45.88 arc(110.87,46.21) 111.2,46.34 112.22,46.34 arc(112.38,46.37) 112.51,46.46 112.62,46.58 arc(112.69,46.67) 112.71,46.78 112.71,46.78 arc(112.75,46.98) 112.86,47.14 112.92,47.21 arc(113.05,47.3) 113.21,47.35 arc(113.46,47.43) 113.67,47.58 113.71,47.63 arc(113.85,47.73) 114,47.8 arc(114.11,47.83) v2(114.24,47.84)
PCIE_TX0_P: length 72.1
  TOP w0.147: C60.2 64.1,17.95 v1(64.18,18.02) ; v2(114.24,48.84) U1.Y7
  07_SIG3 w0.183: v1(64.18,18.02) 64.47,18.32 arc(64.51,18.37) 64.52,18.44 64.52,18.65 arc(64.56,18.86) 64.66,19.04 64.78,19.19 64.78,19.2 64.87,19.29 arc(64.87,19.29) 64.87,19.29 65.99,20.41 arc(66.07,20.53) 66.1,20.67 66.1,23.21 arc(65.99,23.75) 65.68,24.21 arc(65.41,24.62) 65.32,25.09 65.32,25.34 arc(65.48,26.16) 65.94,26.85 68.01,28.92 arc(68.83,29.47) 69.81,29.66 76.81,29.66 arc(77.02,29.7) 77.2,29.82 78.22,30.84 arc(79.06,31.41) 80.06,31.61 91.31,31.61 arc(92.12,31.77) 92.81,32.23 94.85,34.27 arc(96.17,35.15) 97.72,35.46 arc(98.59,35.63) 99.32,36.12 103.23,40.02 arc(104.58,40.93) 106.17,41.24 109.59,41.24 arc(109.66,41.26) 109.72,41.3 109.98,41.56 arc(110.05,41.66) 110.07,41.78 110.07,42.14 arc(110.06,42.21) 110.02,42.27 109.91,42.38
  07_SIG3 w0.237: v2(114.24,48.84) 113.91,48.52 arc(113.85,48.46) 113.78,48.42 arc(113.68,48.37) 113.57,48.35 arc(113.53,48.34) 113.49,48.34 113.06,48.34 arc(112.83,48.25) 112.74,48.01 112.74,47.83 arc(112.59,47.47) 112.22,47.32 111.1,47.32 arc(110.84,47.21) 110.74,46.95 arc(110.56,46.52) 110.13,46.34 110.07,46.34 arc(109.83,46.25) 109.74,46.01 109.74,42.8 arc(109.78,42.57) 109.91,42.38
PCIE_TX1_C_N: length 16
  TOP w0.147: v1(69.54,17.53) 69.61,17.6 C59.1
  10_GND w0.163: U2.A22 68.65,5.41 arc(68.61,5.6) 68.5,5.77 68.42,5.84 arc(68.32,6) 68.28,6.19 68.28,7.48 arc(68.39,8.04) 68.71,8.51 68.91,8.72 arc(69.11,9.01) 69.18,9.35 69.18,17.09 arc(69.19,17.16) 69.22,17.21 v1(69.54,17.53)
PCIE_TX1_C_P: length 16
  TOP w0.147: C58.1 68.47,17.6 v1(68.54,17.53)
  10_GND w0.163: v1(68.54,17.53) 68.86,17.21 arc(68.9,17.16) 68.91,17.09 68.91,9.35 arc(68.86,9.11) 68.73,8.9 68.52,8.7 arc(68.15,8.14) 68.02,7.48 68.02,6.27 arc(67.97,6.01) 67.82,5.79 arc(67.69,5.61) 67.65,5.39 U2.A21
PCIE_TX1_N: length 67.6
  TOP w0.147: C59.2 69.61,21.25 v1(69.54,21.32) ; v2(116.24,47.84) U1.AB6
  07_SIG3 w0.183: v1(69.54,21.32) 69.09,21.77 arc(69.01,21.89) 68.99,22.03 68.99,22.37 arc(69.02,22.44) 69.09,22.47 arc(69.16,22.5) 69.19,22.57 69.19,23.1 arc(69.16,23.17) 69.09,23.2 arc(69.02,23.23) 68.99,23.3 68.99,26.83 arc(69.38,27.77) 70.32,28.16 71.25,28.16 arc(71.45,28.08) 71.53,27.89 71.53,27.51 arc(71.8,27.23) 72.08,27.51 72.08,27.89 arc(72.16,28.08) 72.35,28.16 78.63,28.16 arc(78.99,28.23) 79.29,28.43 80.67,29.8 arc(81.02,30.03) 81.45,30.12 92.2,30.12 arc(92.74,30.23) 93.2,30.53 93.33,30.66 arc(94.1,31.17) 95.01,31.35 95.48,31.35 arc(95.86,31.43) 96.18,31.64 96.56,32.02 arc(96.7,32.24) 96.75,32.49 96.75,32.99 arc(97.02,33.63) 97.66,33.9 98.63,33.9 arc(99.31,34.03) 99.89,34.42 104.4,38.93 arc(105.37,39.58) 106.52,39.8 110.23,39.8 arc(110.56,39.87) 110.84,40.05 112.09,41.31 arc(112.28,41.59) 112.34,41.91 arc(112.38,42.13) 112.51,42.31 112.62,42.42
  07_SIG3 w0.237: v2(116.24,47.84) arc(116.01,47.8) 115.81,47.67 115.68,47.53 arc(115.47,47.39) 115.23,47.34 115.18,47.34 arc(114.87,47.21) 114.74,46.9 arc(114.57,46.51) 114.18,46.34 arc(114.07,46.32) 113.98,46.26 113.8,46.08 arc(113.78,46.06) 113.77,46.04 arc(113.77,46.04) 113.77,46.04 arc(113.74,45.99) 113.74,45.93 113.74,44.82 arc(113.6,44.48) 113.26,44.34 113.2,44.34 arc(113.07,44.32) 112.97,44.25 112.87,44.15 arc(112.77,44) 112.74,43.83 112.74,42.72 arc(112.71,42.56) 112.62,42.42
PCIE_TX1_P: length 67.6
  TOP w0.147: C58.2 68.47,21.25 v1(68.54,21.32) ; v2(116.24,48.84) U1.AB7
  07_SIG3 w0.183: 111.84,42.47 111.96,42.35 arc(112.02,42.26) 112.04,42.16 112.04,41.91 arc(111.99,41.7) 111.87,41.52 110.62,40.27 arc(110.44,40.15) 110.23,40.11 106.52,40.11 arc(105.25,39.86) 104.18,39.14 99.68,34.64 arc(99.2,34.32) 98.63,34.2 97.66,34.2 arc(96.8,33.85) 96.45,32.99 96.45,32.49 arc(96.42,32.35) 96.34,32.24 95.96,31.86 arc(95.74,31.71) 95.48,31.66 95.01,31.66 arc(93.98,31.45) 93.11,30.87 92.99,30.75 arc(92.63,30.51) 92.2,30.42 81.45,30.42 arc(80.91,30.32) 80.45,30.01 79.08,28.65 arc(78.87,28.51) 78.63,28.47 70.32,28.47 arc(69.16,27.99) 68.68,26.83 68.68,21.46 arc(68.68,21.46) 68.68,21.46 v1(68.54,21.32)
  07_SIG3 w0.237: v2(116.24,48.84) 115.91,48.52 arc(115.72,48.39) 115.49,48.34 115.06,48.34 arc(114.83,48.25) 114.74,48.01 114.74,47.82 arc(114.72,47.71) 114.69,47.6 arc(114.52,47.39) 114.26,47.32 114.14,47.32 arc(113.85,47.2) 113.74,46.92 arc(113.7,46.72) 113.58,46.55 113.49,46.46 arc(113.36,46.37) 113.21,46.34 arc(112.87,46.2) 112.72,45.86 112.72,45.77 arc(112.7,45.66) 112.64,45.58 112.51,45.45 arc(112.4,45.37) 112.26,45.34 112.06,45.34 arc(111.83,45.25) 111.74,45.02 111.74,42.72 arc(111.76,42.58) 111.84,42.47
PCIE_TX2_C_N: length 11.9
  TOP w0.147: v1(72.54,13.73) 72.61,13.81 C56.1
  10_GND w0.163: v1(72.54,13.73) 72.41,13.6 arc(72.3,13.44) 72.26,13.25 72.26,6.3 arc(72.3,6.11) 72.41,5.95 72.52,5.84 arc(72.62,5.69) 72.65,5.52 U2.A26
PCIE_TX2_C_P: length 11.9
  TOP w0.147: C52.1 71.47,13.81 v1(71.54,13.73)
  10_GND w0.163: v1(71.54,13.73) 71.86,13.42 arc(71.96,13.26) 72,13.08 72,6.37 arc(71.96,6.15) 71.83,5.97 arc(71.7,5.77) 71.65,5.53 U2.A25
PCIE_TX2_N: length 68.1
  TOP w0.147: v1(72.54,17.53) 72.61,17.46 C56.2 ; v2(119.24,47.84) U1.AD6
  07_SIG3 w0.183: 116.53,42.42 116.48,42.37 arc(116.41,42.27) 116.38,42.15 arc(116.38,42.14) 116.37,42.13 arc(116.37,42.11) 116.37,42.1 arc(116.34,41.93) 116.25,41.8 116.1,41.64 arc(116.09,41.64) 116.09,41.64 112.25,37.8 arc(111.97,37.61) 111.65,37.55 109.18,37.55 arc(108.96,37.5) 108.77,37.38 105.56,34.17 arc(105.44,33.99) 105.4,33.78 105.4,32.96 arc(105.11,32.27) 104.42,31.98 102.91,31.98 arc(101.99,31.82) 101.18,31.35 arc(101.18,31.35) 101.17,31.35 arc(101.17,31.35) 101.17,31.35 101.04,31.23 98.27,28.46 arc(97.23,27.76) 95.99,27.52 91.84,27.52 arc(91.19,27.39) 90.64,27.03 90.14,26.52 arc(89.86,26.33) 89.54,26.27 84.47,26.27 arc(83.88,26.15) 83.38,25.82 82.77,25.21 arc(82.57,24.91) 82.5,24.56 82.5,21.95 arc(82.43,21.61) 82.24,21.32 79.87,18.95 arc(79.59,18.77) 79.27,18.7 76.82,18.7 arc(76.63,18.62) 76.55,18.43 76.55,18.23 arc(76.27,17.96) 76,18.23 76,18.43 arc(75.92,18.62) 75.72,18.7 74.37,18.7 arc(74.19,18.63) 74.11,18.44 arc(74.04,18.26) 73.85,18.18 73.82,18.18 arc(73.64,18.26) 73.56,18.44 arc(73.49,18.63) 73.3,18.7 72.74,18.7 arc(72.36,18.54) 72.2,18.15 72.2,17.95 arc(72.21,17.88) 72.25,17.82 v1(72.54,17.53)
  07_SIG3 w0.237: v2(119.24,47.84) 118.87,47.84 arc(118.76,47.81) 118.69,47.72 arc(118.69,47.69) 118.68,47.66 118.68,47.37 arc(118.62,47.05) 118.44,46.78 117.83,46.18 arc(117.76,46.07) 117.74,45.95 117.74,44.79 arc(117.71,44.65) 117.63,44.52 117.53,44.43 arc(117.4,44.34) 117.25,44.31 arc(117.04,44.27) 116.86,44.15 arc(116.79,44.05) 116.76,43.92 116.76,42.75 arc(116.75,42.66) 116.69,42.58 116.53,42.42
PCIE_TX2_P: length 68.1
  TOP w0.147: v2(119.24,48.84) U1.AD7 ; v1(71.54,17.53) 71.47,17.46 C52.2
  07_SIG3 w0.183: v1(71.54,17.53) 71.84,17.82 arc(71.88,17.88) 71.89,17.95 71.89,18.15 arc(72.14,18.76) 72.74,19.01 79.27,19.01 arc(79.48,19.05) 79.65,19.16 82.03,21.54 arc(82.15,21.73) 82.2,21.95 82.2,24.56 arc(82.29,25.03) 82.55,25.43 83.16,26.03 arc(83.76,26.43) 84.47,26.57 89.54,26.57 arc(89.75,26.62) 89.92,26.74 90.43,27.24 arc(91.07,27.67) 91.84,27.82 95.99,27.82 arc(97.11,28.05) 98.06,28.68 100.83,31.45 arc(100.84,31.46) 100.84,31.47 100.98,31.58 arc(100.98,31.58) 100.98,31.58 arc(101.88,32.11) 102.91,32.29 104.42,32.29 arc(104.89,32.49) 105.09,32.96 105.09,33.78 arc(105.16,34.11) 105.34,34.38 108.55,37.59 arc(108.84,37.79) 109.18,37.85 111.65,37.85 arc(111.86,37.9) 112.04,38.01 115.88,41.85 arc(115.95,41.96) 115.97,42.09 115.97,42.19 arc(115.96,42.28) 115.93,42.36 arc(115.9,42.39) 115.87,42.42
  07_SIG3 w0.237: v2(119.24,48.84) 118.8,48.84 arc(118.7,48.82) 118.62,48.77 118.62,48.77 arc(118.4,48.44) 118.32,48.06 118.32,47.44 arc(118.29,47.25) 118.18,47.09 117.72,46.63 117.66,46.56 arc(117.63,46.52) 117.59,46.48 arc(117.46,46.39) 117.31,46.36 117.22,46.36 arc(117.03,46.32) 116.88,46.22 arc(116.77,46.05) 116.73,45.86 116.73,44.78 arc(116.61,44.49) 116.32,44.37 arc(116.06,44.31) 115.84,44.17 arc(115.74,44.02) 115.71,43.84 115.71,42.83 arc(115.75,42.61) 115.87,42.42
PCIE_TX3_C_N: length 14.5
  TOP w0.147: v1(76.91,16.26) 76.98,16.33 C51.1
  10_GND w0.163: v1(76.91,16.26) 76.58,15.94 arc(76.55,15.89) 76.54,15.82 76.54,11.98 arc(76.5,11.8) 76.4,11.65 arc(76.3,11.5) 76.27,11.33 76.27,6.23 arc(76.31,6.04) 76.41,5.88 76.55,5.75 arc(76.62,5.63) 76.65,5.5 U2.A30
PCIE_TX3_C_P: length 14.5
  TOP w0.147: v1(75.91,16.26) 75.83,16.33 C50.1
  10_GND w0.163: v1(75.91,16.26) 76.23,15.94 arc(76.26,15.89) 76.27,15.82 76.27,11.98 arc(76.26,11.9) 76.22,11.84 arc(76.06,11.61) 76,11.33 76,6.2 arc(75.95,5.92) 75.79,5.69 arc(75.69,5.53) 75.65,5.34 U2.A29
PCIE_TX3_N: length 66
  TOP w0.147: C51.2 76.98,19.98 v1(76.91,20.05) ; v2(121.24,47.84) U1.AF6
  07_SIG3 w0.183: v1(76.91,20.05) 76.61,20.35 arc(76.57,20.41) 76.56,20.48 76.56,20.67 arc(76.61,20.8) 76.75,20.86 76.91,20.86 arc(77.19,21.13) 76.91,21.41 76.83,21.41 arc(76.64,21.49) 76.56,21.68 76.56,22.1 arc(76.69,22.75) 77.06,23.31 77.6,23.85 arc(77.79,23.93) 77.99,23.85 78.13,23.7 arc(78.52,23.7) 78.52,24.09 78.38,24.24 arc(78.3,24.43) 78.38,24.63 82.02,28.27 arc(82.8,28.79) 83.72,28.98 93.13,28.98 arc(93.46,29.04) 93.74,29.23 93.87,29.36 arc(94.1,29.52) 94.38,29.57 95.73,29.57 arc(96.61,29.75) 97.35,30.24 105.05,37.94 arc(105.87,38.49) 106.84,38.68 111.13,38.68 arc(111.45,38.74) 111.73,38.93 114.11,41.3 arc(114.3,41.59) 114.36,41.93 114.36,42.17 arc(114.38,42.24) 114.42,42.3 114.62,42.51
  07_SIG3 w0.237: v2(121.24,47.84) 120.92,48.16 arc(120.78,48.36) 120.74,48.6 120.74,48.98 arc(120.63,49.24) 120.37,49.34 117.97,49.34 arc(117.79,49.27) 117.72,49.09 117.72,47.85 arc(117.57,47.49) 117.21,47.34 117.19,47.34 arc(116.97,47.28) 116.81,47.12 116.8,47.09 arc(116.75,46.98) 116.74,46.85 arc(116.59,46.49) 116.23,46.34 116.22,46.34 arc(115.88,46.2) 115.74,45.86 115.74,44.81 arc(115.6,44.48) 115.27,44.34 115.18,44.34 arc(115.08,44.32) 114.99,44.26 114.86,44.14 arc(114.77,44) 114.74,43.83 114.74,42.79 arc(114.71,42.64) 114.62,42.51
PCIE_TX3_P: length 66
  TOP w0.147: v1(75.91,20.05) 75.83,19.98 C50.2 ; v2(121.24,48.84) U1.AF7
  07_SIG3 w0.183: v1(75.91,20.05) 76.2,20.35 arc(76.24,20.41) 76.25,20.48 76.25,22.1 arc(76.41,22.87) 76.84,23.53 81.81,28.49 arc(82.69,29.08) 83.72,29.28 93.13,29.28 arc(93.34,29.32) 93.52,29.44 93.65,29.58 arc(93.99,29.8) 94.38,29.88 95.73,29.88 arc(96.49,30.03) 97.14,30.46 104.83,38.15 arc(105.75,38.77) 106.84,38.98 111.13,38.98 arc(111.34,39.03) 111.52,39.14 113.89,41.52 arc(114.02,41.71) 114.06,41.93 114.06,42.21 arc(114.05,42.27) 114.02,42.31 113.86,42.47
  07_SIG3 w0.237: v2(121.24,48.84) 121.24,49 arc(121.2,49.18) 121.1,49.33 120.87,49.56 arc(120.79,49.68) 120.76,49.83 120.76,49.98 arc(120.73,50.11) 120.66,50.22 arc(120.52,50.31) 120.36,50.34 117.05,50.34 arc(116.83,50.25) 116.74,50.03 116.74,47.83 arc(116.69,47.63) 116.55,47.48 116.49,47.44 arc(116.35,47.37) 116.2,47.34 arc(116.07,47.32) 115.97,47.25 115.87,47.15 arc(115.82,47.1) 115.79,47.04 arc(115.75,46.93) 115.74,46.83 arc(115.7,46.64) 115.6,46.49 115.58,46.47 arc(115.46,46.39) 115.32,46.36 115.24,46.36 arc(114.89,46.21) 114.74,45.86 114.74,44.9 arc(114.7,44.71) 114.59,44.55 114.49,44.44 arc(114.38,44.37) 114.26,44.35 114.2,44.35 arc(113.87,44.21) 113.74,43.89 113.74,42.77 arc(113.77,42.61) 113.86,42.47
PCIE_TX4_C_N: length 12.4
  TOP w0.147: v1(82.04,14.11) 82.12,14.18 C29.1
  10_GND w0.163: 82.65,3.49 82.65,5.56 arc(82.63,5.66) 82.57,5.74 82.56,5.76 arc(82.37,6.04) 82.31,6.36 82.31,10.4 arc(82.18,11.01) 81.84,11.53 arc(81.72,11.71) 81.68,11.92 81.68,13.67 arc(81.69,13.73) 81.72,13.79 v1(82.04,14.11)
PCIE_TX4_C_P: length 12.5
  TOP w0.147: C30.1 80.97,14.18 v1(81.04,14.11)
  10_GND w0.163: U2.A35 81.65,5.47 arc(81.69,5.69) 81.81,5.87 81.9,5.95 arc(82,6.11) 82.04,6.3 82.04,10.4 arc(81.94,10.91) 81.65,11.34 arc(81.47,11.61) 81.41,11.92 81.41,13.67 arc(81.4,13.73) 81.36,13.79 v1(81.04,14.11)
PCIE_TX4_N: length 59.5
  TOP w0.147: C29.2 82.12,17.83 v1(82.04,17.9) ; v2(123.24,47.84) U1.AH6
  07_SIG3 w0.183: 119.04,45.34 118.95,45.34 arc(118.93,45.34) 118.91,45.34 arc(118.88,45.33) 118.85,45.32 arc(118.81,45.29) 118.78,45.25 arc(118.75,45.2) 118.74,45.14 118.74,44.96 arc(118.69,44.69) 118.54,44.46 118.39,44.32 arc(118.16,43.96) 118.07,43.55 118.07,42.37 arc(118.01,42.04) 117.82,41.77 112.73,36.67 arc(112.46,36.49) 112.13,36.42 110.78,36.42 arc(110.35,36.34) 109.98,36.09 106.7,32.81 arc(106.53,32.55) 106.46,32.24 arc(106.41,31.96) 106.24,31.72 105.58,31.05 arc(105.05,30.7) 104.43,30.57 103.11,30.57 arc(102.53,30.46) 102.04,30.13 99.36,27.45 arc(98.06,26.58) 96.54,26.28 92.23,26.28 arc(91.58,26.15) 91.02,25.78 90.08,24.84 arc(89.91,24.59) 89.86,24.29 arc(89.79,23.97) 89.61,23.69 87.51,21.59 arc(87.13,21.34) 86.68,21.25 84.51,21.25 arc(84.29,21.21) 84.1,21.08 83.56,20.55 arc(83.5,20.39) 83.56,20.23 arc(83.63,20.08) 83.56,19.92 83.49,19.84 arc(83.33,19.78) 83.18,19.84 arc(83.02,19.91) 82.86,19.84 82.79,19.77 arc(82.72,19.61) 82.79,19.46 arc(82.85,19.3) 82.79,19.14 82.71,19.07 arc(82.56,19) 82.4,19.07 arc(82.24,19.13) 82.09,19.07 81.8,18.78 arc(81.72,18.67) 81.7,18.53 81.7,18.32 arc(81.71,18.25) 81.75,18.19 v1(82.04,17.9)
  07_SIG3 w0.237: v2(123.24,47.84) 123.12,47.84 arc(122.94,47.81) 122.78,47.7 122.55,47.47 arc(122.41,47.38) 122.24,47.34 122.18,47.34 arc(121.93,47.27) 121.77,47.06 121.75,47.03 arc(121.74,46.98) 121.74,46.94 arc(121.56,46.52) 121.14,46.34 120.22,46.34 arc(119.85,46.19) 119.7,45.82 119.7,45.63 arc(119.62,45.43) 119.41,45.34 119.04,45.34
PCIE_TX4_P: length 59.4
  TOP w0.147: v1(81.04,17.9) 80.97,17.83 C30.2 ; v2(123.24,48.84) U1.AH7
  07_SIG3 w0.183: 119.07,46.32 118.93,46.17 arc(118.84,46.04) 118.81,45.89 118.81,45.76 arc(118.78,45.66) 118.7,45.59 arc(118.6,45.51) 118.52,45.41 arc(118.46,45.28) 118.44,45.14 118.44,44.96 arc(118.41,44.8) 118.32,44.68 118.18,44.53 arc(117.88,44.08) 117.77,43.55 117.77,42.37 arc(117.73,42.16) 117.61,41.98 112.52,36.89 arc(112.34,36.77) 112.13,36.73 110.78,36.73 arc(110.23,36.62) 109.76,36.31 106.48,33.03 arc(106.24,32.67) 106.16,32.24 arc(106.13,32.07) 106.03,31.93 105.36,31.26 arc(104.93,30.98) 104.43,30.88 103.11,30.88 arc(102.42,30.74) 101.83,30.35 99.14,27.66 arc(97.95,26.86) 96.54,26.58 92.23,26.58 arc(91.46,26.43) 90.81,25.99 89.87,25.06 arc(89.63,24.7) 89.55,24.29 arc(89.51,24.08) 89.39,23.91 87.29,21.81 arc(87.01,21.62) 86.68,21.56 84.51,21.56 arc(84.17,21.49) 83.88,21.3 81.58,19 arc(81.44,18.78) 81.39,18.53 81.39,18.32 arc(81.38,18.25) 81.34,18.19 v1(81.04,17.9)
  07_SIG3 w0.237: 119.07,46.32 119.25,46.32 arc(119.4,46.35) 119.53,46.43 119.54,46.44 arc(119.68,46.65) 119.73,46.89 arc(119.76,47.05) 119.85,47.19 arc(119.99,47.29) 120.16,47.32 121.26,47.32 arc(121.51,47.39) 121.69,47.59 arc(121.72,47.71) 121.74,47.83 121.74,47.9 arc(121.87,48.21) 122.18,48.34 122.49,48.34 arc(122.72,48.39) 122.91,48.52 v2(123.24,48.84)
