# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PMBUS_SDA: length 536.8
  TOP w0.14: U80.4 v1(143.19,118.27)
  TOP w0.152: v1(181.87,45.17) U165.11 ; v1(167.19,141.01) U166.11
  03_SIG1 w0.173: v1(212.79,60.96) 212.91,60.84 212.91,60.01 214.31,58.61 214.31,54.94 216.16,53.09 216.16,52.83 216.01,52.68 215.24,52.68 215.06,52.51 215.06,52.33 215.24,52.16 216.01,52.16 216.16,52.01 216.16,50.4 215.98,50.21 215.53,50.21 215.32,50.43 215.32,51.4 v1(215.45,51.54) ; J39.3 234.36,30.89 232.34,30.89 231.37,29.92 230.44,29.92 228.24,32.12 227.41,32.12 v1(227.09,32.44) 227.09,32.75 226.9,32.94 226.54,32.94 226.34,32.74 226.34,32.19 226.22,32.08 225.88,32.08 225.39,32.57 214.77,32.57 210.95,28.75 200.33,28.75 198.75,27.18 196.32,27.18 194.21,25.07 191.95,25.07 191.02,26 191.02,28.33 189.85,29.5 187.85,29.5 187.57,29.78 187.57,30.23 v1(187.66,30.32) ; v1(239.4,111.42) 239.2,111.22 238.92,111.22 236.87,113.27 235.39,113.27 232.17,116.49 227.81,116.49 227.03,117.27 227.03,119.13 221.71,124.45 197.19,124.45 188.65,132.99 186.81,132.99 184.27,135.53 180.37,135.53 179.52,136.37 179.52,138.65 180.14,139.28 180.14,140.12 180.32,140.29 180.64,140.29 180.77,140.42 180.77,140.94 180.64,141.07 v1(180.14,141.07) ; v1(155.32,114.17) 155.38,114.11 155.78,114.11 156.23,114.57 156.23,116.36 157.7,117.83 160.26,117.83 161.47,119.04 162.14,119.04 166.5,123.4 166.5,130.94 167.87,132.31 167.87,139.39 167.7,139.57 166.89,139.57 166.73,139.72 166.73,140.07 166.91,140.25 167.7,140.25 167.87,140.42 167.87,140.98 167.77,141.09 167.26,141.09 v1(167.19,141.01)
  05_SIG2 w0.173: v1(63.73,141.23) 63.16,140.67 63.16,140.52 62.17,139.53 62.17,138.99 62.39,138.77 62.39,135.62 58.2,131.42 55.66,131.42 54.35,130.11 54.35,129.27 52.83,127.76 48.59,127.76 46.46,125.63 46.46,124.33 47.37,123.42 48.64,123.42 v1(48.75,123.31) ; v1(239.4,111.42) 239.3,111.31 238.58,111.31 237.03,109.76 237.03,106.95 236.9,106.82 236.06,105.98 236.06,104.76 235.1,103.8 233.02,103.8 231.49,102.26 231.49,98.2 229.95,96.65 224.39,96.65 222.83,95.1 222.83,80.55 218.69,76.41 218.69,68.45 218.19,67.94 217.63,67.94 213.81,64.12 213.81,64.12 213.49,63.79 213.39,63.7 213.39,63.3 212.86,62.77 212.86,62.04 212.86,61.03 v1(212.79,60.96)
  07_SIG3 w0.173: v1(187.66,30.32) 187.51,30.18 187.51,28.95 186.71,28.15 186.26,28.15 185.34,28.15 183.16,30.33 183.16,42.75 181.99,43.91 181.99,45.05 v1(181.87,45.17) 180.56,46.48 180.56,46.64 180.56,48.49 180,49.05 180,49.95 182.31,52.25 184.86,52.25 185.67,53.07 185.67,54.71 186.69,55.73 190.63,55.73 192.68,53.67 192.68,51.69 193.39,50.98 197.78,50.98 201.59,54.79 201.92,55.12 209.65,55.12 211.68,53.08 214.71,53.08 215.45,52.35 v1(215.45,51.54) ; v1(167.19,141.01) 167.43,141.01 167.74,141.33 167.74,141.77 167.87,141.89 168.29,141.89 168.6,142.19 168.6,142.48 168.73,142.61 178.44,142.61 178.93,142.12 179.04,142.12 179.18,141.98 179.18,141.72 179.31,141.59 179.51,141.59 179.66,141.74 179.66,141.99 179.78,142.12 180.06,142.12 180.19,141.99 180.19,141.73 180.29,141.64 180.55,141.64 180.65,141.73 180.65,142 180.77,142.12 181.01,142.12 181.35,141.78 181.35,141.49 181.22,141.35 180.85,141.35 180.69,141.2 180.69,140.92 180.89,140.73 181.26,140.73 181.35,140.64 181.35,140.38 181.01,140.04 180.35,140.04 179.98,140.41 179.98,140.91 v1(180.14,141.07)
  14_SIG4 w0.089: v1(155.32,114.17) 155.07,114.17 154.94,114.04 153.83,114.04 153.43,113.64 152.33,113.64 151.49,114.47 151.49,115.87 151.49,116.29 148.31,119.48 146.53,119.48 145.75,120.26 144.44,120.26 144.25,120.08 143.7,119.52 143.7,118.78 v1(143.19,118.27)
  BOTTOM w0.152: U156.11 187.92,30.04 187.91,30.07 v1(187.66,30.32) ; v1(215.45,51.54) 215.72,51.27 U4.11 ; R502.2 v1(227.09,32.44) ; U6.11 212.53,61.22 v1(212.79,60.96) ; v1(155.32,114.17) 155.59,114.44 U9.11 ; v1(63.73,141.23) 64.3,141.23 64.79,141.72 65.32,141.72 69.57,145.98 111.43,145.98 113.06,144.35 113.06,136.44 116.12,133.38 130.64,133.38 134.87,137.61 139.8,137.61 145.16,132.24 145.16,131.73 145.58,131.31 150.44,131.31 151.15,130.6 151.15,127.76 148.92,125.53 148.92,120.09 147.85,119.02 143.95,119.02 v1(143.19,118.27) 141.71,116.78 R621.2 ; v1(180.14,141.07) 180.41,140.81 U30.11 ; U150.11 48.48,123.05 v1(48.75,123.31)
  BOTTOM w0.216: v1(239.4,111.42) 238.69,110.71 U164.11
PMOD0_0: length 11.9
  03_SIG1 w0.173: J52.1 227.69,75.15 227.21,75.64 223.81,75.64 221.89,73.71 221.42,73.71 220.96,73.25 220.96,72.28 v1(221.54,71.7)
  BOTTOM w0.152: U41.18 v1(221.54,71.7)
PMOD0_0_LS: length 179.3
  TOP w0.152: v2(135.24,55.84) 134.74,56.34 U1.AY14
  07_SIG3 w0.173: v1(129.02,25.79) 129.08,25.72 133.83,25.72 134.54,26.44 136.55,26.44 137.13,25.86 139.22,25.86 139.8,26.44 145.26,26.44 146.99,24.71 151.05,24.71 152.55,23.21 157.19,23.21 158.21,24.24 160.25,24.24 160.89,24.88 166.93,24.88 170.83,28.78 170.83,33.06 171.65,33.88 171.65,42 171.27,42.38 171.27,44.93 169.7,46.5 169.7,51.51 171.34,53.15 171.34,54.39 178.02,61.07 178.02,62.95 182.08,67.02 182.08,67.38 182.99,68.29 183.24,68.29 183.56,67.97 183.8,67.97 184.17,68.34 184.17,68.58 183.85,68.9 183.85,69.15 184.21,69.51 184.46,69.51 184.78,69.19 185.03,69.19 185.39,69.56 185.39,69.8 185.07,70.12 185.07,70.37 185.44,70.73 185.68,70.73 186,70.41 186.25,70.41 186.61,70.78 186.61,71.02 186.29,71.35 186.29,71.59 187.6,72.9 189.39,72.9 191.98,75.49 192.22,75.49 192.7,75.01 192.94,75.01 193.31,75.38 193.31,75.62 192.83,76.1 192.83,76.34 194.19,77.71 210.23,77.71 v1(211.71,79.18)
  20_SIG7 w0.089: v1(129.02,25.79) 128.77,26.04 128.57,26.04 128.48,26.12 128.48,27.4 130.84,29.75 130.84,35.19 135.71,40.06 135.71,47.07 136.06,47.42 136.52,47.42 136.79,47.69 136.79,48.06 137.04,48.31 137.54,48.31 137.74,48.51 137.74,51.05 137.44,51.34 137.03,51.34 136.74,51.64 136.74,52.05 136.44,52.34 136.03,52.34 135.74,52.64 135.74,55.34 v2(135.24,55.84)
  BOTTOM w0.152: U41.3 215.67,71.7 215.31,72.06 213.74,72.06 211.55,74.25 211.55,79.03 v1(211.71,79.18)
PMOD0_1: length 12.1
  03_SIG1 w0.173: v1(223.98,72.35) 223.98,71.94 224.15,71.76 224.45,71.76 224.7,72.02 224.7,72.81 224.89,73 226.1,73 226.28,72.83 226.28,72.54 226.11,72.37 225.58,72.37 225.45,72.23 225.45,71.34 225.59,71.19 226.03,71.19 226.19,71.35 226.19,71.68 226.28,71.76 227.27,71.76 227.69,71.35 228.29,71.35 228.65,71.71 J52.3
  BOTTOM w0.152: U41.17 v1(223.98,72.35)
PMOD0_1_LS: length 180.8
  TOP w0.152: v2(135.24,56.84) 134.74,57.34 U1.AY15
  07_SIG3 w0.173: v1(129.4,26.49) 129.4,26.59 130.36,27.56 139.04,27.56 139.27,27.79 144.86,27.79 147.31,25.33 151.38,25.33 152.35,24.36 154.25,24.36 155.22,25.33 157.7,25.33 158.04,25.66 162.42,25.66 162.58,25.5 166.22,25.5 168.26,27.54 168.26,31.68 169.09,32.51 169.09,38.64 170.02,39.57 170.02,44.28 169.09,45.21 169.09,53.67 174.8,59.38 174.8,61.39 187.25,73.84 188.85,73.84 194.84,79.83 196.41,79.83 196.58,79.65 196.58,78.69 196.75,78.52 197.27,78.52 197.45,78.69 197.45,79.65 197.62,79.83 198.14,79.83 198.31,79.65 198.31,78.69 198.48,78.52 199,78.52 199.17,78.69 199.17,79.65 199.35,79.83 199.86,79.83 200.04,79.65 200.04,79.25 200.22,79.06 200.74,79.06 200.9,79.22 200.9,79.65 201.07,79.83 v1(213.59,79.83)
  20_SIG7 w0.089: v1(129.4,26.49) 129.4,27.53 131.5,29.63 131.5,35.07 136.76,40.33 136.76,47.05 137,47.29 137.43,47.29 137.73,47.58 137.73,47.99 138.01,48.28 138.4,48.28 138.74,48.62 138.74,51.08 138.44,51.37 138.04,51.37 137.71,51.71 137.71,52.04 137.37,52.37 137.04,52.37 136.77,52.65 136.77,54.98 136.37,55.37 136.04,55.37 135.77,55.65 135.77,55.98 135.24,56.51 v2(135.24,56.84)
  BOTTOM w0.152: U41.4 215.52,72.35 215.46,72.41 214.28,72.41 211.92,74.77 211.92,78.16 v1(213.59,79.83)
PMOD0_2: length 13.2
  03_SIG1 w0.173: J52.5 226.49,70.07 226.03,70.53 223.58,70.53 223.37,70.33 223.37,69.85 223.2,69.67 222.39,69.67 222.13,69.94 222.13,71.26 222.81,71.94 222.81,72.76 222.57,73 v1(221.54,73)
  BOTTOM w0.152: U41.16 v1(221.54,73)
PMOD0_2_LS: length 178.7
  TOP w0.152: U1.AW15 133.74,57.34 v2(134.24,56.84)
  07_SIG3 w0.173: v1(212.59,76.88) 210.94,75.23 203.07,75.23 197.63,69.79 193.92,69.79 186.52,62.39 186.52,60.65 182.61,56.74 179.06,56.74 175.59,53.27 175.59,51.02 176.54,50.07 176.54,48.67 176.01,48.13 176.01,44.9 176.43,44.48 177.44,44.48 178.59,43.33 180.17,43.33 181.25,42.24 181.25,33.7 177.63,30.08 176.74,30.08 173.8,27.14 173.8,26.06 171.68,23.95 170.16,23.95 168.85,22.64 166.17,22.64 164.71,21.18 162.96,21.18 162.59,20.81 161.53,20.81 161.16,21.18 160.44,21.18 160.13,21.49 160.13,21.91 159.86,22.18 152.65,22.18 150.63,24.21 146.71,24.21 145.03,25.89 140.03,25.89 139.45,25.3 135.71,25.3 135.64,25.37 134.75,25.37 134.54,25.17 v1(127.84,25.17)
  20_SIG7 w0.089: v2(134.24,56.84) 134.74,56.34 134.74,52.64 135.03,52.34 135.44,52.34 135.74,52.05 135.74,51.64 136.03,51.34 136.44,51.34 136.74,51.05 136.74,48.46 136.52,48.24 135.95,48.24 135.72,48.01 135.72,47.64 135.43,47.35 135.03,47.35 134.74,47.05 134.74,39.87 130.27,35.4 130.27,29.97 127.84,27.54 v1(127.84,25.17)
  BOTTOM w0.152: v1(212.59,76.88) 212.59,75.37 214.95,73 U41.5
PMOD0_3: length 12
  05_SIG2 w0.173: v1(223.98,73.65) 223.98,74.17 224.18,74.37 225.2,74.37 225.65,73.92 225.65,70.59 226.99,69.25 226.99,68.02 227.48,67.53 J52.7
  BOTTOM w0.152: U41.15 v1(223.98,73.65)
PMOD0_3_LS: length 179.8
  TOP w0.152: U1.AV15 132.74,57.34 v2(133.24,56.84)
  07_SIG3 w0.173: v1(213.81,76.76) 213.81,76.38 211.42,73.98 204.49,73.98 198.28,67.77 196.57,67.77 193.17,64.38 193.17,61.6 190.38,58.81 189.83,58.81 188.37,57.36 184.79,57.36 183.07,55.63 182.93,55.5 181.61,55.5 178.92,52.81 178.92,49.23 180,48.15 180,44.92 180.48,44.44 180.62,44.44 181.99,43.07 182.52,42.54 182.52,33.41 177.85,28.74 177.19,28.74 174.94,26.48 174.94,23.86 173.41,22.34 171.22,22.34 171,22.55 170.35,22.55 169.61,21.81 169.61,21.63 168.15,20.17 168.15,18.74 167.41,18 162.49,18 161.73,18.76 160.38,18.76 160.05,19.09 160.05,19.52 159.75,19.82 157.21,19.82 156.82,20.22 148.79,20.22 146.18,22.83 143.94,22.83 143.31,23.47 142.01,23.47 141.35,22.81 140.46,22.81 139.88,22.23 135.23,22.23 133.46,23.99 v1(126.76,23.99)
  20_SIG7 w0.089: v2(133.24,56.84) 133.64,56.44 133.64,52.18 133.74,52.08 133.74,51.64 134.03,51.34 134.5,51.34 134.74,51.11 134.74,48.54 134.59,48.39 133.98,48.39 133.74,48.16 133.74,47.64 133.47,47.36 132.94,47.36 132.74,47.16 132.74,39.44 128.85,35.56 128.85,31.62 128.1,30.87 128.1,29.88 126.75,28.52 126.75,24.01 v1(126.76,23.99)
  BOTTOM w0.152: v1(213.81,76.76) 213.81,75.36 215.52,73.65 U41.6
PMOD0_4: length 12.8
  03_SIG1 w0.173: J52.2 229.46,76.88 223.8,76.88 221.54,74.62 v1(221.54,74.3)
  BOTTOM w0.152: U41.14 v1(221.54,74.3)
PMOD0_4_LS: length 182.5
  TOP w0.152: U1.AV16 132.74,58.34 v2(133.24,57.84)
  07_SIG3 w0.173: v1(214.76,76.71) 214.06,77.4 213.5,77.4 213.17,77.07 213.17,76.67 211.17,74.68 203.54,74.68 197.47,68.6 196.61,68.6 192.35,64.34 192.35,61.8 189.91,59.36 189.6,59.36 188.19,57.96 184.61,57.96 183.16,56.51 182.84,56.18 179.43,56.18 176.14,52.9 176.14,51.5 178.17,49.47 178.17,47.71 178.68,47.2 178.68,45.09 179.89,43.89 180.39,43.89 181.38,42.9 181.94,42.34 181.94,33.61 177.86,29.52 177.14,29.52 174.35,26.73 174.35,24.54 173.2,23.4 170.4,23.4 168.98,21.98 168.98,21.79 166.13,18.94 162.33,18.94 161.96,19.31 161.22,19.31 160.05,20.49 160.05,20.72 159.55,21.22 157.44,21.22 156.94,20.72 149.05,20.72 146.22,23.55 144.22,23.55 142.65,25.12 140.89,25.12 140.23,24.46 136.55,24.46 136.07,23.98 134.7,23.98 134.11,24.56 v1(127.25,24.56)
  20_SIG7 w0.089: v1(127.25,24.56) 127.25,27.74 129.47,29.96 129.47,35.39 133.74,39.66 133.74,47.25 133.91,47.42 134.46,47.42 134.71,47.67 134.71,48 135.12,48.41 135.53,48.41 135.74,48.61 135.74,51.05 135.44,51.34 135.03,51.34 134.74,51.64 134.74,52.05 134.44,52.34 134.07,52.34 133.84,52.57 133.84,57.24 v2(133.24,57.84)
  BOTTOM w0.152: v1(214.76,76.71) 214.76,74.92 215.37,74.3 U41.7
PMOD0_5: length 12.7
  03_SIG1 w0.173: v1(223.98,74.95) 223.98,74.36 224.17,74.17 224.63,74.17 224.84,74.38 224.84,74.82 225.01,74.99 225.53,74.99 225.68,74.83 225.68,74.03 225.87,73.85 226.28,73.85 226.46,74.03 226.46,74.66 226.63,74.83 227.05,74.83 227.22,74.66 227.22,74.14 227.52,73.85 229.96,73.85 J52.4
  BOTTOM w0.152: U41.13 v1(223.98,74.95)
PMOD0_5_LS: length 184.5
  TOP w0.152: v2(132.24,57.84) 131.74,58.34 U1.AU16
  07_SIG3 w0.173: v1(161.83,21.44) 162.44,21.44 162.73,21.73 164.44,21.73 165.9,23.19 168.62,23.19 169.93,24.5 171.45,24.5 173.24,26.29 173.24,27.36 176.51,30.63 177.4,30.63 178.37,31.6 178.37,33.56 180.34,35.53 180.34,40.34 179.88,40.79 177.11,40.79 176.12,41.78 174.57,41.78 174.24,42.11 174.24,42.88 175.45,44.08 175.45,48.36 175.99,48.9 175.99,49.84 175.03,50.79 175.03,53.99 179.55,58.5 179.79,58.5 180.15,58.14 180.4,58.14 180.76,58.51 180.76,58.75 180.4,59.11 180.4,59.36 181.82,60.78 181.82,61.49 183.54,63.21 186.19,63.21 194.39,71.41 194.63,71.41 195.48,70.57 195.76,70.57 196.11,70.91 196.11,71.16 195.25,72.02 195.25,72.26 195.61,72.63 195.86,72.63 197.57,70.92 197.84,70.92 198.2,71.27 198.2,71.51 196.47,73.24 196.47,73.49 196.83,73.85 197.08,73.85 198.72,72.21 199.05,72.21 199.37,72.53 199.37,72.78 197.69,74.46 197.69,74.71 198.76,75.78 199.37,75.78 199.54,75.61 199.54,73.84 199.76,73.62 200.23,73.62 200.4,73.79 200.4,75.61 200.58,75.78 201.09,75.78 201.27,75.61 201.27,75.14 201.44,74.97 201.96,74.97 202.13,75.14 202.13,75.61 202.3,75.78 210.71,75.78 213.02,78.09 214.59,78.09 v1(215.17,77.52)
  16_SIG5 w0.089: v1(161.83,21.44) 162.46,21.44 163.3,22.28 163.3,23.57 160.15,26.72 154.08,26.72 150.9,29.9 149.1,29.9 139.4,39.6 136.3,39.6 133.74,42.16 133.74,47.21 133.59,47.35 133.1,47.35 132.84,47.61 132.84,49.02 132.47,49.39 132.15,49.39 131.85,49.7 131.85,50.07 131.46,50.46 131.02,50.46 130.84,50.65 130.84,56.03 131.05,56.25 131.52,56.25 131.84,56.56 131.84,57.44 v2(132.24,57.84)
  BOTTOM w0.152: v1(215.17,77.52) 215.17,77.01 215.3,76.88 215.3,75.11 215.45,74.95 U41.8
PMOD0_6: length 15.5
  05_SIG2 w0.173: v1(221.54,75.6) 222.91,76.97 224.49,76.97 227.43,74.03 227.43,71.9 227.99,71.34 229.92,71.34 J52.6
  BOTTOM w0.152: U41.12 v1(221.54,75.6)
PMOD0_6_LS: length 181
  TOP w0.152: v2(131.24,56.84) 130.74,57.34 U1.AT15
  07_SIG3 w0.173: v1(160.65,21.7) 160.95,22 162.04,22 162.23,22.19 162.23,22.77 163.21,23.75 167.78,23.75 168.49,24.45 168.49,24.64 169.28,25.44 169.71,25.44 170.09,25.06 171.12,25.06 171.36,25.3 171.36,25.54 170.7,26.2 170.7,26.44 171.07,26.81 171.31,26.81 171.97,26.15 172.21,26.15 172.64,26.58 172.64,27.55 174.66,29.57 174.66,29.81 174.11,30.37 174.11,30.64 174.45,30.98 174.72,30.98 175.27,30.43 175.52,30.43 175.8,30.7 175.8,33.5 175.44,33.86 173.94,33.86 172.81,34.98 172.81,43.06 172.52,43.35 172.52,44.64 172.89,45.01 174.6,45.01 174.8,45.21 174.8,47.12 174.6,47.32 174.09,47.32 173.91,47.14 173.91,46.63 173.74,46.46 172.97,46.46 172.72,46.2 171.87,46.2 171.7,46.37 171.7,46.89 171.87,47.06 172.69,47.06 172.86,47.24 172.86,47.76 172.69,47.93 171.87,47.93 171.7,48.1 171.7,48.62 171.87,48.79 172.38,48.79 172.55,48.96 172.55,49.48 172.38,49.66 171.87,49.66 171.7,49.83 171.7,50.94 171.93,51.18 172.32,51.18 172.86,50.64 173.1,50.64 173.45,50.99 173.45,51.27 172.61,52.11 172.61,52.35 172.98,52.72 173.22,52.72 173.79,52.15 174.04,52.15 174.41,52.51 174.41,52.76 173.83,53.33 173.83,53.57 181.26,61 181.26,61.72 183.31,63.77 185.97,63.77 198.53,76.34 210.48,76.34 212.84,78.69 214.88,78.69 215.03,78.54 v1(215.65,78.54)
  16_SIG5 w0.089: v2(131.24,56.84) 130.94,56.84 130.46,56.36 130,56.36 129.83,56.18 129.83,50.46 129.96,50.33 130.53,50.33 130.77,50.09 130.77,49.53 130.98,49.32 131.52,49.32 131.74,49.1 131.74,41.8 134.54,38.99 139.12,38.99 148.95,29.16 150.93,29.16 153.84,26.25 159.91,26.25 160.17,25.99 160.17,25.86 160.09,25.78 160.09,25.66 160.34,25.41 160.47,25.41 160.55,25.48 160.67,25.48 160.92,25.23 160.92,25.11 160.85,25.03 160.85,24.9 161.1,24.65 161.22,24.65 161.3,24.73 161.43,24.73 162.05,24.11 162.05,22.27 161.72,21.95 160.9,21.95 v1(160.65,21.7)
  BOTTOM w0.152: U41.9 215.91,75.6 215.72,75.79 215.72,77.68 215.65,77.76 v1(215.65,78.54)
PMOD0_7: length 14
  05_SIG2 w0.173: v1(223.98,76.25) 225.11,75.12 225.42,75.12 226.21,74.33 226.21,70.92 228.35,68.78 229.94,68.78 J52.8
  BOTTOM w0.152: U41.11 v1(223.98,76.25)
PMOD0_7_LS: length 178.8
  TOP w0.152: v2(131.24,57.84) 130.74,58.34 U1.AT16
  07_SIG3 w0.173: v1(216.56,78.02) 216.56,78.62 215.91,79.27 212.58,79.27 210.2,76.89 197.83,76.89 192.53,71.6 192.29,71.6 191.4,72.48 191.16,72.48 190.79,72.12 190.79,71.87 191.68,70.99 191.68,70.74 191.31,70.38 191.07,70.38 190.18,71.26 189.94,71.26 189.57,70.9 189.57,70.65 190.46,69.77 190.46,69.52 190.09,69.16 189.85,69.16 188.96,70.04 188.72,70.04 188.35,69.68 188.35,69.43 189.24,68.55 189.24,68.3 188.93,67.99 188.6,67.99 187.18,69.41 186.93,69.41 186.57,69.05 186.57,68.8 187.99,67.38 187.99,67.13 187.63,66.77 187.38,66.77 185.96,68.19 185.71,68.19 185.35,67.83 185.35,67.58 186.77,66.16 186.77,65.91 186.4,65.55 186.16,65.55 184.74,66.97 184.49,66.97 182.61,65.09 181.06,65.09 178.67,62.7 178.67,59.32 171.15,51.8 171.15,46.03 171.87,45.31 171.87,42.97 172.23,42.61 172.23,34.48 173.23,33.48 173.23,29.39 171.67,27.82 170.7,27.82 167.18,24.3 162.75,24.3 161.57,23.12 v1(161.57,22.55)
  16_SIG5 w0.089: v1(161.57,22.55) 161.57,23.42 160.41,24.58 160.28,24.58 159.62,23.92 159.49,23.92 159.24,24.17 159.24,24.3 159.9,24.96 159.9,25.08 159.21,25.78 153.62,25.78 150.98,28.42 148.87,28.42 138.96,38.33 133.86,38.33 130.74,41.45 130.74,49.16 130.53,49.38 129.9,49.38 129.65,49.63 129.65,57.02 129.91,57.28 130.67,57.28 v2(131.24,57.84)
  BOTTOM w0.152: U41.10 216.3,76.25 216.13,76.43 216.13,76.85 216.56,77.28 v1(216.56,78.02)
PMOD1_0: length 13.5
  03_SIG1 w0.173: J53.1 234.93,91.62 234.79,91.49 234.16,91.49 234.04,91.37 234.04,90.86 233.89,90.72 233.51,90.72 233.39,90.84 233.39,91.24 233.14,91.49 231.68,91.49 231.51,91.32 231.51,90.81 231.34,90.64 230.03,90.64 229.86,90.47 229.86,90.12 230,89.98 231.34,89.98 v1(231.89,89.43)
  BOTTOM w0.152: v1(231.89,89.43) 232.54,88.78 U42.18
PMOD1_0_LS: length 260.1
  TOP w0.152: U1.N28 107.74,70.34 v2(107.24,70.84)
  14_SIG4 w0.089: v1(231.9,78.38) 231.9,78.77 231.76,78.9 231.32,78.9 231.19,78.77 231.19,77.67 230.86,77.34 221.39,77.34 219.51,75.46 206.99,75.46 204.3,72.76 204.12,72.76 203.8,73.08 203.8,73.26 204.49,73.95 204.49,74.12 204.22,74.39 204.05,74.39 203.36,73.7 203.18,73.7 202.96,73.92 202.79,73.92 202.52,73.66 202.52,73.48 203.68,72.32 203.68,72.15 203.42,71.88 203.24,71.88 202.08,73.04 201.91,73.04 201.64,72.78 201.64,72.6 202.8,71.44 202.8,71.27 202.25,70.72 201.78,70.72 201.65,70.84 201.65,71.82 201.53,71.95 201.16,71.95 201.03,71.82 201.03,70.84 200.91,70.72 193.15,70.72 185.11,62.67 185.11,60.36 184.05,59.3 184.05,55.67 184.05,55.67 184.05,55.25 183.64,54.84 183.64,50.74 184.49,49.89 184.49,49.29 183.34,48.14 183.34,47.47 184.65,46.17 184.65,43.75 183.62,42.73 183.62,28.93 180.45,25.76 180.45,24.17 173.48,17.2 169.47,17.2 167.41,15.14 165.2,15.14 164.95,15.39 159.41,15.39 158.7,14.67 139.74,14.67 136.88,17.53 136.03,17.53 134.85,18.72 129.64,18.72 127.39,20.98 124.03,20.98 120.45,24.56 119.89,24.56 119.46,24.13 v1(119.46,24.08)
  18_SIG6 w0.089: v2(107.24,70.84) 107.84,70.24 107.84,69.54 108.03,69.34 108.42,69.34 108.64,69.12 108.64,66.4 107.64,65.4 107.64,64.67 107.41,64.44 106.96,64.44 106.64,64.12 106.64,63.67 106.41,63.44 105.96,63.44 105.64,63.12 105.64,62.67 105.41,62.44 104.96,62.44 104.64,62.12 104.64,61.65 104.43,61.44 103.96,61.44 103.64,61.11 103.64,59.57 103.43,59.36 102.94,59.36 102.74,59.16 102.74,58.64 102.44,58.34 102.03,58.34 101.74,58.05 101.74,38.78 101.91,38.61 103.34,38.61 103.51,38.43 103.51,37.92 103.34,37.74 101.91,37.74 101.74,37.57 101.74,37.05 101.91,36.88 103.17,36.88 103.33,36.72 103.33,36.2 103.15,36.02 101.91,36.02 101.74,35.84 101.74,35.33 101.91,35.15 103.17,35.15 103.33,34.99 103.33,34.48 103.15,34.29 101.91,34.29 101.74,34.12 101.74,33.78 102.6,32.92 102.6,32.01 103.91,30.7 104.92,30.7 106.05,29.58 106.05,29.12 105.55,28.62 104.71,28.62 104.63,28.53 104.63,28.04 105.52,27.15 106.59,27.15 106.9,27.45 108.46,27.45 108.7,27.22 108.7,26.22 108.84,26.08 109.91,26.08 110.09,26.26 110.09,26.89 110.31,27.11 110.97,27.11 113.04,25.04 115.48,25.04 116.57,23.95 119.33,23.95 v1(119.46,24.08)
  BOTTOM w0.152: U42.3 232.54,79.02 v1(231.9,78.38)
PMOD1_1: length 14.8
  03_SIG1 w0.173: v1(231.89,88.16) 231.53,88.16 231.25,87.89 231.25,86.19 231.44,86 231.85,86 232.06,86.21 232.06,87.25 232.22,87.42 233.46,87.42 233.64,87.25 233.64,86.89 233.46,86.72 232.86,86.72 232.7,86.55 232.7,86.17 232.86,86 234.6,86 234.77,86.18 234.77,87.83 J53.3
  BOTTOM w0.152: U42.17 v1(231.89,88.16)
PMOD1_1_LS: length 258.1
  TOP w0.152: U1.M30 v2(106.24,72.84)
  14_SIG4 w0.089: v1(231.89,79.88) 231.89,79.5 232.41,78.98 232.41,78.95 232.41,78 231.19,76.78 222.93,76.78 222.81,76.66 222.81,76.25 222.68,76.13 222.31,76.13 222.18,76.25 222.18,76.66 222.06,76.78 221.66,76.78 220.75,75.87 220.75,75.7 220.86,75.58 220.86,75.41 220.6,75.14 220.42,75.14 220.31,75.26 220.14,75.26 219.82,74.94 207.41,74.94 201.25,68.78 197.21,68.78 195.75,70.24 193.86,70.24 186.54,62.92 186.54,61.05 184.55,59.07 184.55,56.44 185.79,55.2 185.79,52.07 184.96,51.24 184.96,48.96 184.61,48.61 184.61,47.4 185.52,46.48 185.52,43.94 184.14,42.56 184.14,28.7 183.36,27.93 183.36,23.53 182.17,22.33 181.99,22.33 181,23.32 180.83,23.32 180.47,22.97 180.47,22.79 181.46,21.8 181.46,21.63 181.11,21.27 180.93,21.27 179.95,22.26 179.77,22.26 179.42,21.91 179.42,21.74 180.41,20.75 180.41,20.57 180.05,20.22 179.88,20.22 178.89,21.21 178.71,21.21 178.36,20.86 178.36,20.68 179.35,19.69 179.35,19.51 179,19.16 178.82,19.16 177.83,20.15 177.66,20.15 177.31,19.8 177.31,19.62 178.29,18.63 178.29,18.46 176.83,16.99 176.81,16.99 173.71,13.89 165.51,13.89 164.52,14.88 160.88,14.88 160.05,14.05 159.05,14.05 158.9,14.2 135.58,14.2 134.43,15.36 133.51,15.36 130.79,18.08 129.56,18.08 127.18,20.47 123.82,20.47 v1(120.23,24.06)
  18_SIG6 w0.089: v2(106.24,72.84) 106.84,72.24 106.84,70.56 107.07,70.33 107.41,70.33 107.64,70.1 107.64,69.29 107.84,69.09 107.84,66.15 106.74,65.05 106.74,64.64 106.44,64.34 106.03,64.34 105.74,64.05 105.74,63.64 105.44,63.34 104.03,63.34 103.74,63.05 103.74,62.85 103.74,61.64 103.44,61.34 103.03,61.34 102.74,61.05 102.74,59.64 102.44,59.34 102.03,59.34 101.74,59.05 101.74,58.64 101.72,58.62 101.72,58.62 101.45,58.34 101.03,58.34 100.74,58.05 100.74,33.75 101.31,33.17 101.31,32.01 101.47,31.86 101.47,31.61 100.8,30.94 100.8,30.69 101.16,30.33 101.41,30.33 102.08,31 102.33,31 103.76,29.56 103.76,27.82 106.07,25.52 109.67,25.52 110.16,25.02 111.62,25.02 113.24,23.4 119.58,23.4 v1(120.23,24.06)
  BOTTOM w0.152: U42.4 v1(231.89,79.88)
PMOD1_2: length 13.6
  05_SIG2 w0.173: J53.5 233.88,86.54 233.6,86.27 233.6,85.19 233.4,84.99 231.56,84.99 231.28,85.26 231.28,89.26 231.11,89.43 v1(230.59,89.43)
  BOTTOM w0.152: U42.16 231.24,88.78 v1(230.59,89.43)
PMOD1_2_LS: length 258.5
  TOP w0.152: U1.N30 v2(107.24,72.84)
  14_SIG4 w0.089: v1(119.2,25.82) 120.18,25.82 120.22,25.86 120.29,25.93 120.29,25.93 120.6,26.23 121.2,26.23 122.15,27.18 129.46,27.18 131.58,25.05 133.12,25.05 137.6,20.58 140.6,20.58 145.09,16.09 157.49,16.09 160.12,18.72 162.28,18.72 163.08,17.93 165.83,17.93 170.35,22.45 171.12,22.45 171.37,22.2 173.28,22.2 174.1,23.01 177.11,23.01 178.79,24.69 178.79,28.01 182.11,31.33 182.11,33.83 182.11,43.35 180.44,45.01 180.44,49.85 181.33,50.75 181.33,52.09 180.28,53.14 180.28,59.56 181.74,61.02 181.74,61.87 182.5,62.62 182.5,64.42 184.19,66.11 184.19,67.51 195.4,78.72 197.52,78.72 197.7,78.54 197.7,77.37 197.83,77.23 198.32,77.23 198.44,77.36 198.44,78.86 198.57,78.99 198.94,78.99 199.06,78.86 199.06,77.36 199.19,77.23 199.56,77.23 199.69,77.36 199.69,78.86 199.81,78.99 200.18,78.99 200.31,78.86 200.31,77.36 200.43,77.23 200.81,77.23 200.93,77.36 200.93,78.86 201.06,78.99 201.43,78.99 201.55,78.86 201.55,77.36 201.68,77.23 211.01,77.23 212.31,78.54 215.02,78.54 215.15,78.67 215.15,78.74 215.44,79.03 215.85,79.03 216.35,78.54 217.02,78.54 217.38,78.18 218.88,78.18 219.57,78.87 230.07,78.87 v1(230.59,78.36)
  18_SIG6 w0.089: v2(107.24,72.84) U1.N30 108.44,72.34 108.74,72.05 108.74,71.64 109.03,71.34 109.44,71.34 109.74,71.05 109.74,70.41 109.84,70.31 109.84,66.06 108.84,65.06 108.84,64.57 108.51,64.24 108.06,64.24 107.84,64.02 107.84,63.57 107.51,63.24 107.06,63.24 106.84,63.02 106.84,62.55 106.53,62.24 106.06,62.24 105.84,62.02 105.84,61.04 105.74,60.94 105.74,57.64 105.44,57.34 105.03,57.34 104.74,57.05 104.74,56.59 104.49,56.34 103.99,56.34 103.84,56.19 103.84,50.55 104.04,50.34 104.44,50.34 104.74,50.05 104.74,41.54 104.91,41.37 105.26,41.37 105.43,41.2 105.43,40.71 105.31,40.59 105.1,40.59 105,40.48 105,40.21 105.13,40.08 105.13,39.84 104.98,39.7 104.98,39.45 105.23,39.21 105.47,39.21 105.62,39.35 105.86,39.35 106.1,39.11 106.1,38.86 105.96,38.72 105.96,38.47 106.2,38.23 106.45,38.23 106.59,38.37 106.84,38.37 107.08,38.13 107.08,37.89 106.94,37.74 106.94,37.5 107.18,37.25 107.43,37.25 107.57,37.4 107.81,37.4 108.06,37.15 108.06,36.91 107.91,36.76 107.91,36.52 108.16,36.28 108.4,36.28 108.55,36.42 108.79,36.42 109.03,36.18 109.03,35.93 108.89,35.79 108.89,35.54 109.14,35.3 109.38,35.3 109.52,35.44 109.77,35.44 110.01,35.2 110.01,34.95 109.87,34.81 109.87,34.57 110.11,34.32 110.36,34.32 110.5,34.47 110.74,34.47 110.92,34.29 110.92,33.21 110.11,32.4 110.11,32.07 110.29,31.89 110.59,31.89 111.13,32.43 111.37,32.43 111.83,31.96 111.83,31.68 111.66,31.5 111.1,31.5 110.92,31.32 110.92,31 111.07,30.85 111.67,30.85 111.85,30.66 111.85,30.31 111.68,30.14 111.31,30.14 111.11,29.94 111.11,29.75 111.54,29.33 111.85,29.33 112.17,29.65 112.4,29.65 112.76,29.29 112.76,29.02 112.39,28.65 112.39,28.41 112.76,28.04 113,28.04 113.29,28.33 113.29,28.71 113.49,28.91 113.96,28.91 114.08,28.79 114.08,27.9 113.61,27.43 113.61,27.19 114,26.8 118.22,26.8 v1(119.2,25.82)
  BOTTOM w0.152: v1(230.59,78.36) 231.24,79.01 U42.5
PMOD1_3: length 12.8
  05_SIG2 w0.173: J53.7 229.63,84 229.43,84.2 229.43,85.38 229.61,85.55 230.35,85.55 230.59,85.79 v1(230.59,88.16)
  BOTTOM w0.152: U42.15 v1(230.59,88.16)
PMOD1_3_LS: length 261.5
  TOP w0.152: U1.P30 v2(108.24,72.84)
  14_SIG4 w0.089: v1(230.59,79.88) 230.08,79.38 229.05,79.38 228.63,79.81 228.63,80.34 228.24,80.72 227.41,80.72 226.87,80.19 213.93,80.19 213.79,80.32 213.38,80.32 213.25,80.19 202.07,80.19 201.95,80.31 201.95,81.51 201.82,81.64 201.45,81.64 201.32,81.51 201.32,80.31 201.2,80.19 200.83,80.19 200.7,80.31 200.7,81.51 200.58,81.64 200.2,81.64 200.08,81.51 200.08,80.31 199.96,80.19 199.58,80.19 199.46,80.31 199.46,81.51 199.33,81.64 198.96,81.64 198.84,81.51 198.84,80.31 198.71,80.19 198.34,80.19 198.21,80.31 198.21,81.51 198.09,81.64 197.71,81.64 197.59,81.51 197.59,80.31 197.47,80.19 197.09,80.19 196.97,80.31 196.97,81.51 196.84,81.64 196.47,81.64 196.35,81.51 196.35,80.31 196.22,80.19 195.19,80.19 183.65,68.65 181.94,68.65 179.2,65.9 179.2,52.17 178.81,51.78 178.81,51.32 178.61,51.12 178.61,50.5 178.52,50.41 178.14,50.41 178.05,50.32 178.05,49.97 178.14,49.88 178.52,49.88 178.61,49.79 178.61,49.43 178.52,49.34 178.14,49.34 178.05,49.26 178.05,48.9 178.14,48.81 178.52,48.81 178.61,48.72 178.61,45.25 181.09,42.77 181.09,42.17 181.09,32.41 172.93,24.25 170.77,24.25 169.09,22.56 165.9,22.56 164.93,21.6 163.16,21.6 162.31,20.75 161.64,20.75 161.35,21.04 160.53,21.04 157.42,17.93 144.65,17.93 139.89,22.7 139.89,22.95 134.57,28.27 121.66,28.27 v1(120.88,27.49)
  18_SIG6 w0.089: v2(108.24,72.84) U1.P30 111.44,72.34 111.74,72.05 111.74,63.64 111.44,63.34 109.03,63.34 108.74,63.05 108.74,62.64 108.44,62.34 108.03,62.34 107.74,62.05 107.74,55.64 107.44,55.34 105.03,55.34 104.84,55.15 104.84,52.51 105.01,52.34 106.44,52.34 106.74,52.05 106.74,42.47 107.08,42.13 109.02,42.13 109.74,41.4 109.74,41.16 108.56,39.98 108.56,39.74 108.92,39.37 109.17,39.37 110.35,40.55 110.59,40.55 110.96,40.18 110.96,39.94 109.78,38.76 109.78,38.51 110.15,38.15 110.39,38.15 111.57,39.33 111.82,39.33 112.18,38.96 112.18,38.72 111,37.54 111,37.29 111.37,36.93 111.61,36.93 112.79,38.11 113.04,38.11 113.4,37.74 113.4,37.5 112.22,36.32 112.22,36.07 112.59,35.7 112.83,35.7 114.01,36.89 114.26,36.89 114.45,36.7 114.45,33.42 114.71,33.16 114.71,30.76 116.58,28.88 118.49,28.88 118.87,28.5 118.87,27.77 119.7,26.94 120.32,26.94 v1(120.88,27.49)
  BOTTOM w0.152: U42.6 v1(230.59,79.88)
PMOD1_4: length 14.8
  03_SIG1 w0.173: v1(229.29,89.43) 229.29,90.86 230.47,92.04 234.56,92.04 235.38,92.86 237.32,92.86 J53.2
  BOTTOM w0.152: v1(229.29,89.43) 229.94,88.78 U42.14
PMOD1_4_LS: length 261.8
  TOP w0.152: v2(108.24,71.84) 108.74,71.34 U1.P29
  14_SIG4 w0.089: v1(118.46,25.78) 118.48,25.78 119.19,25.07 120.68,25.07 122.3,23.45 128.63,23.45 129.13,23.95 132.79,23.95 134.14,22.61 134.14,19.81 134.6,19.35 138.5,19.35 139.57,18.27 139.57,15.93 140.34,15.17 141.26,15.17 141.5,15.41 141.5,16.36 141.67,16.54 142.86,16.54 143.11,16.3 143.11,15.44 143.4,15.15 158.4,15.15 159.53,16.28 162.37,16.28 163.01,16.91 167.77,16.91 168.52,17.67 173.19,17.67 179.95,24.42 179.95,25.98 183.12,29.14 183.12,33.15 183.12,42.94 184.07,43.9 184.07,45.93 182.87,47.13 182.87,48.34 183.11,48.57 183.11,55.03 183.54,55.46 183.54,59.66 183.78,59.9 183.78,62.04 192.97,71.22 196.19,71.22 196.32,71.35 196.32,73.75 196.44,73.87 196.82,73.87 196.94,73.75 196.94,71.35 197.07,71.22 197.44,71.22 197.56,71.35 197.56,73.13 197.72,73.29 198.06,73.29 198.19,73.16 198.19,71.35 198.31,71.22 199.3,71.22 204.1,76.02 216.82,76.02 216.94,76.15 216.94,76.46 217.07,76.58 217.44,76.58 217.57,76.46 217.57,76.15 217.69,76.02 218.07,76.02 218.19,76.15 218.19,76.58 218.31,76.7 218.69,76.7 218.81,76.58 218.81,76.15 218.94,76.02 219.19,76.02 221.02,77.85 228.78,77.85 v1(229.29,78.36)
  18_SIG6 w0.089: v2(108.24,71.84) 108.73,71.35 108.73,70.64 109.05,70.32 109.45,70.32 109.64,70.13 109.64,66.22 108.64,65.22 108.64,64.66 108.42,64.44 107.98,64.44 107.64,64.1 107.64,63.65 107.43,63.44 106.98,63.44 106.64,63.1 106.64,62.63 106.45,62.44 105.98,62.44 105.64,62.1 105.64,61.52 105.46,61.34 105.03,61.34 104.74,61.05 104.74,57.64 104.44,57.34 104.03,57.34 103.74,57.05 103.74,56.64 103.64,56.54 103.64,50.19 103.74,50.09 103.74,39.81 104.68,38.87 104.68,38.23 104.85,38.05 105.55,38.05 105.72,37.88 105.72,37.54 105.55,37.36 104.85,37.36 104.68,37.19 104.68,36.85 104.85,36.67 107.05,36.67 107.24,36.49 107.24,36.14 107.08,35.98 104.85,35.98 104.68,35.81 104.68,35.46 104.85,35.29 107.05,35.29 107.24,35.11 107.24,34.76 107.08,34.6 104.85,34.6 104.68,34.43 104.68,34.17 104.85,34 106.75,34 107.1,33.66 108.44,33.66 108.56,33.78 108.56,34.45 108.74,34.63 109,34.63 109.28,34.36 109.28,29.95 108.81,29.49 108.81,28.88 109.01,28.67 109.37,28.67 109.57,28.87 109.57,29.6 109.8,29.83 110.1,29.83 110.28,29.65 110.28,28.9 110.59,28.59 111.21,28.59 113.6,26.2 116.61,26.2 116.78,26.03 116.78,25.36 116.95,25.19 117.47,25.19 117.64,25.36 117.64,26.03 117.82,26.2 118.04,26.2 v1(118.46,25.78)
  BOTTOM w0.152: v1(229.29,78.36) 229.94,79.01 U42.7
PMOD1_5: length 15.3
  03_SIG1 w0.173: v1(229.29,88.16) 229.96,88.84 232.35,88.84 232.47,88.96 232.47,89.65 232.56,89.73 232.94,89.73 233.04,89.64 233.04,88.94 233.13,88.84 233.51,88.84 233.6,88.93 233.6,89.55 233.71,89.66 234.04,89.66 234.13,89.57 234.13,88.93 234.22,88.84 234.7,88.84 234.87,89.01 234.87,89.83 235.33,90.29 237.35,90.29 J53.4
  BOTTOM w0.152: U42.13 v1(229.29,88.16)
PMOD1_5_LS: length 258.6
  TOP w0.152: U1.L31 v2(105.24,73.84)
  14_SIG4 w0.089: v1(118.72,22.76) 124.03,17.45 125.98,17.45 127.18,16.26 130.02,16.26 130.51,15.77 130.51,14.44 131.52,13.42 173.97,13.42 178.58,18.03 178.76,18.03 179.56,17.23 179.74,17.23 180.09,17.58 180.09,17.76 179.29,18.56 179.29,18.74 179.64,19.09 179.82,19.09 180.62,18.29 180.79,18.29 181.15,18.64 181.15,18.81 180.34,19.62 180.34,19.79 180.7,20.14 180.87,20.14 181.67,19.34 181.85,19.34 182.2,19.69 182.2,19.87 181.4,20.67 181.4,20.85 181.75,21.2 181.93,21.2 182.73,20.4 182.91,20.4 183.26,20.75 183.26,20.93 182.46,21.73 182.46,21.9 183.97,23.42 183.97,27.6 184.65,28.27 184.65,42.38 186.08,43.82 186.08,47.07 187.1,48.08 187.1,51.24 186.63,51.71 186.63,55.03 187.97,56.36 187.97,63.61 194.07,69.71 195.34,69.71 196.74,68.31 201.66,68.31 207.67,74.32 220.52,74.32 221.18,74.98 222.28,74.98 222.94,75.64 224.41,75.64 225.07,76.3 231.5,76.3 232.91,77.72 232.91,79.46 232.38,79.98 232.38,80.21 231.98,80.62 230.02,80.62 v1(229.29,79.88)
  18_SIG6 w0.089: v2(105.24,73.84) U1.L31 105.74,72.61 106.03,72.32 106.38,72.32 106.64,72.06 106.64,70.27 106.74,70.17 106.74,68.64 107.03,68.34 107.44,68.34 107.64,68.14 107.64,66.52 107.3,66.19 106.87,66.19 105.74,65.05 105.74,64.64 105.44,64.34 104.03,64.34 103.74,64.05 103.74,63.64 103.44,63.34 103.03,63.34 102.74,63.05 102.74,61.64 102.44,61.34 102.03,61.34 102.02,61.33 101.98,61.33 101.74,61.09 101.74,59.64 101.44,59.34 101.03,59.34 100.74,59.05 100.74,58.64 100.44,58.34 100.03,58.34 99.74,58.05 99.74,30.62 105.4,24.96 109.44,24.96 109.93,24.47 111.27,24.47 112.9,22.84 118.64,22.84 v1(118.72,22.76)
  BOTTOM w0.152: U42.8 v1(229.29,79.88)
PMOD1_6: length 16
  03_SIG1 w0.173: J53.6 237.34,85.32 231.29,85.32 228.64,87.96 228.64,88.78 v1(227.99,89.43)
  BOTTOM w0.152: v1(227.99,89.43) 228.64,88.78 U42.12
PMOD1_6_LS: length 258
  TOP w0.152: U1.M31 v2(106.24,73.84)
  14_SIG4 w0.089: v1(227.99,78.36) 219.77,78.36 219.09,77.67 216.91,77.67 216.76,77.52 216.27,77.52 216.03,77.29 215.69,77.29 215.66,77.31 215.66,77.72 215.37,78.01 214.07,78.01 213.43,77.37 212.03,77.37 211.38,76.73 196.69,76.73 196.56,76.85 196.56,78.06 196.44,78.19 196.06,78.19 195.94,78.06 195.94,76.85 195.81,76.73 195.56,76.73 195.06,76.23 195.06,74.02 194.46,73.42 193.93,73.42 193.57,73.77 193.57,74.91 193.31,75.18 192.83,75.18 192.09,74.44 192.09,74.26 192.77,73.58 192.77,73.41 192.51,73.14 192.33,73.14 191.65,73.82 191.48,73.82 191.21,73.56 191.21,73.38 191.89,72.7 191.89,72.53 191.63,72.26 191.45,72.26 190.77,72.94 190.6,72.94 186.04,68.39 186.04,65.21 183.12,62.29 182.88,62.29 182.45,61.86 182.45,59.55 181.27,58.36 181.27,52.86 181.84,52.29 181.84,50.54 181.84,49.31 180.95,48.42 180.95,45.23 182.61,43.57 182.61,43.56 182.61,30.98 179.37,27.74 179.37,24.56 174.83,20.02 169.57,20.02 169.04,19.48 168.4,19.48 168.15,19.23 168.15,18.59 166.97,17.42 162.77,17.42 162.66,17.31 159.65,17.31 157.96,15.62 144.53,15.62 142.45,17.7 141.83,17.7 139.64,19.88 137.58,19.88 132.97,24.49 129.28,24.49 127.72,26.05 123.33,26.05 122.81,25.53 121.41,25.53 121.36,25.58 v1(120.92,25.58)
  18_SIG6 w0.089: v1(120.92,25.58) 119.99,25.58 118.92,24.51 116.8,24.51 115.69,25.61 113.36,25.61 110.97,28.01 107.66,28.01 106.69,28.98 106.69,29.78 106.89,29.99 108.5,29.99 108.72,30.21 108.72,30.51 108.5,30.73 107.42,30.73 107.28,30.88 107.28,31.19 107.51,31.43 108.51,31.43 108.65,31.57 108.65,32.01 108.5,32.16 107.46,32.16 107.21,32.41 107.21,32.84 107.08,32.97 106.57,32.97 106.43,32.82 106.43,31.08 106.28,30.94 105.7,30.94 105.5,31.14 105.5,32.22 105.29,32.43 104.87,32.43 104.7,32.26 104.7,31.67 104.5,31.47 103.98,31.47 103.81,31.65 103.81,33.36 104.1,33.65 104.1,38.67 102.74,40.03 102.74,58.06 103.02,58.34 103.55,58.34 103.84,58.63 103.84,61.03 104.05,61.24 104.51,61.24 104.84,61.57 104.84,62.04 105.04,62.24 105.49,62.24 105.84,62.59 105.84,63.03 106.05,63.24 106.49,63.24 106.84,63.59 106.84,64.04 107.04,64.24 107.49,64.24 107.84,64.59 107.84,65.15 108.84,66.15 108.84,69.4 108.74,69.5 108.74,70.05 108.44,70.34 108.03,70.34 107.74,70.64 107.74,72.05 107.44,72.34 107.11,72.34 106.74,72.72 U1.M31 v2(106.24,73.84)
  BOTTOM w0.152: U42.9 228.64,79.01 v1(227.99,78.36)
PMOD1_7: length 14.8
  03_SIG1 w0.173: J53.8 237.32,82.76 233,82.76 227.99,87.77 v1(227.99,88.16)
  BOTTOM w0.152: U42.11 v1(227.99,88.16)
PMOD1_7_LS: length 261.7
  TOP w0.152: U1.R29 109.74,71.34 v2(109.24,71.84)
  14_SIG4 w0.089: v1(227.99,79.88) 227.53,79.43 216.17,79.43 216.06,79.54 215.23,79.54 215.12,79.43 213.94,79.43 213.61,79.1 212.84,79.1 212.28,79.65 211.94,79.65 211.91,79.68 211.5,79.68 211.47,79.65 211.17,79.65 210.85,79.33 210.85,78.17 210.43,77.74 209.99,77.74 209.87,77.86 209.87,79.44 209.74,79.56 209.37,79.56 209.24,79.44 209.24,77.86 209.12,77.74 208.75,77.74 208.62,77.86 208.62,79.44 208.5,79.56 208.12,79.56 208,79.44 208,77.86 207.87,77.74 207.47,77.74 207.34,77.86 207.34,79.31 207.22,79.44 206.85,79.44 206.72,79.31 206.72,77.86 206.6,77.74 206.16,77.74 205.84,78.06 205.84,79.15 205.47,79.53 204.33,79.53 204.21,79.4 204.21,78.57 204.08,78.45 203.71,78.45 203.59,78.57 203.59,79.4 203.46,79.53 203.09,79.53 202.96,79.4 202.96,78.62 202.81,78.47 202.44,78.47 202.34,78.57 202.34,79.4 202.22,79.53 195.38,79.53 183.43,67.57 183.43,66.61 181.22,64.41 181.22,61.21 179.7,59.7 179.7,52.97 180.82,51.84 180.82,50.95 179.93,50.06 179.93,44.75 181.6,43.09 181.6,32.25 173.01,23.67 170.85,23.67 168.49,21.31 167.99,21.31 167.79,21.51 165.6,21.51 165.23,21.13 163.45,21.13 161.54,19.23 159.74,19.23 157.07,16.56 145.28,16.56 136.54,25.3 135.67,25.3 133.23,27.74 121.99,27.74 120.99,26.74 120.39,26.74 120.01,26.37 v1(119.7,26.37)
  18_SIG6 w0.089: v1(119.7,26.37) 119.47,26.37 118.48,27.36 118.21,27.36 117.78,27.78 117.78,27.99 117.34,27.99 117.17,27.82 117.17,27.53 117,27.36 116.48,27.36 116.31,27.53 116.31,28.15 116.12,28.33 115.6,28.33 115.45,28.17 115.45,27.53 115.27,27.36 114.89,27.36 114.7,27.55 114.7,29.83 114.31,30.21 113.34,30.21 113.22,30.09 112.76,30.09 112.47,30.38 112.47,31.21 112.64,31.38 113.92,31.38 114.09,31.55 114.09,32.07 113.92,32.24 112.64,32.24 112.47,32.42 112.47,33.5 112.64,33.67 113.66,33.67 113.84,33.84 113.84,34.36 113.66,34.54 112.64,34.54 112.47,34.71 112.47,34.93 111.88,35.52 111.64,35.52 111.19,35.08 110.95,35.08 110.71,35.32 110.71,35.57 111.15,36.01 111.15,36.25 110.91,36.5 110.66,36.5 110.22,36.06 109.97,36.06 109.73,36.3 109.73,36.54 110.17,36.99 110.17,37.23 109.93,37.48 109.68,37.48 109.24,37.03 109,37.03 108.75,37.28 108.75,37.52 109.2,37.96 109.2,38.21 108.95,38.45 108.71,38.45 108.26,38.01 108.02,38.01 107.77,38.25 107.77,38.5 108.22,38.94 108.22,39.19 107.97,39.43 107.73,39.43 107.29,38.99 107.04,38.99 106.8,39.23 106.8,39.48 108.28,40.95 108.28,41.22 108.03,41.47 107.81,41.47 106.31,39.96 106.06,39.96 105.82,40.21 105.82,40.45 106.63,41.26 106.63,41.57 105.74,42.47 105.74,51.09 105.5,51.33 104.93,51.33 104.64,51.63 104.64,55.54 104.74,55.64 104.74,56.05 105.03,56.34 106.44,56.34 106.74,56.64 106.74,62.05 107.03,62.34 107.44,62.34 107.74,62.64 107.74,63.05 108.03,63.34 108.44,63.34 108.74,63.64 108.74,64.05 109.03,64.34 110.44,64.34 110.74,64.64 110.74,71.05 110.44,71.34 109.74,71.34 v2(109.24,71.84)
  BOTTOM w0.152: U42.10 v1(227.99,79.88)
POR_OVERRIDE_PIN: length 165.9
  TOP w0.152: U1.AG12 v2(122.24,53.84)
  07_SIG3 w0.173: v1(125.97,19.06) 126.18,18.85 129.16,18.85 130.18,17.83 130.18,16.51 130.83,15.85 131.29,15.85 134.54,19.1 143.36,19.1 143.61,18.85 146.74,18.85 147.02,19.13 154.15,19.13 154.85,18.42 159.75,18.42 160.05,18.12 160.05,17.72 160.61,17.16 161.66,17.16 161.95,17.45 168.49,17.45 169.16,18.13 169.16,19.35 169.67,19.86 173.48,19.86 176.4,22.78 193.93,22.78 198.25,18.47 J5.2
  16_SIG5 w0.089: v1(125.97,19.06) 122.5,19.06 122.02,19.53 122.02,21.14 122.63,21.75 122.63,38.96 120.74,40.86 120.74,53.11 120.99,53.36 121.38,53.36 121.86,53.84 v2(122.24,53.84)
  BOTTOM w0.152: v2(122.24,53.84) 121.78,54.3 121.78,55.14 121.98,55.34 122.5,55.34 122.74,55.58 122.74,56.09 122.99,56.34 124.43,56.34 124.74,56.03 124.74,55.66 125.06,55.34 126.44,55.34 126.74,55.05 126.74,54.58 126.97,54.34 127.45,54.34 127.74,54.06 127.74,53.53 127.93,53.34 128.51,53.34 128.74,53.11 128.74,52.61 129,52.34 131.44,52.34 131.74,52.04 131.74,51.64 132.04,51.34 139.5,51.34 139.74,51.11 139.74,50.56 139.95,50.34 140.51,50.34 140.74,50.12 140.74,48.6 140.99,48.34 141.62,48.34 149.48,40.49 149.48,39.27 149.83,38.91 R116.1
PUDC_B_PIN: length 53.1
  TOP w0.152: R418.1 v1(116.08,32.2) ; U1.AD12 v2(119.24,53.84)
  BOTTOM w0.113: 127.8,41.33 127.84,41.37 127.84,42.4 127.8,42.43
  BOTTOM w0.152: v1(116.08,32.2) R418.1 117.31,32.2 117.47,32.04 117.47,27.94 117.94,27.48 119.1,27.48 120,28.38 120,30.66 120.39,31.05 120.39,32.63 121.5,33.74 121.5,35.95 126.22,40.68 127.14,40.68 127.8,41.33 ; v2(119.24,53.84) 118.29,52.9 118.29,45.67 118.62,45.34 119.47,45.34 119.73,45.08 119.73,44.51 119.93,44.31 120.47,44.31 120.75,44.59 120.75,45.13 120.96,45.34 121.46,45.34 121.73,45.06 121.73,44.53 121.93,44.33 122.47,44.33 122.75,44.61 122.75,45.05 123.05,45.35 123.55,45.35 123.69,45.49 123.69,46.14 123.9,46.35 124.53,46.35 124.74,46.14 124.74,45.55 124.96,45.33 125.43,45.33 125.72,45.04 125.72,44.57 125.95,44.34 127.55,44.34 127.75,44.14 127.75,42.49 127.8,42.43
QSFP1_IIC_SCL: length 159.2
  TOP w0.14: U145.11 v1(48.06,24.63)
  03_SIG1 w0.173: v1(48.06,24.63) 47.78,24.63 46.43,25.98 44.15,25.98 43.71,26.42 43.71,26.66 43.96,26.91 43.96,27.16 43.72,27.4 43.47,27.4 43.22,27.15 42.98,27.15 42.73,27.39 42.73,27.64 42.98,27.89 42.98,28.14 42.74,28.38 42.5,28.38 42.24,28.13 42,28.13 41.75,28.37 41.75,28.62 42.01,28.87 42.01,29.11 41.76,29.36 41.52,29.36 41.27,29.1 41.02,29.1 37.58,32.54 37.58,35.05 34.03,38.6 34.03,44.2 32.68,45.55 32.68,66.54 33.13,67 33.13,69.89 31.13,71.89 31.13,87.45 38.6,94.92 38.6,108.97 36.81,110.76 36.81,116.24 36.16,116.89 36.16,127.68 37.87,129.39 43.74,129.39 44.91,130.56 44.91,132.89 43.82,133.99 43.82,143.53 45.06,144.78 45.06,145.41 45.27,145.63 47.84,145.63 49.08,146.86 50.43,146.86 51.01,146.28 51.01,145.28 50.84,145.11 49.91,145.11 49.56,145.46 v1(49.56,146.05)
  BOTTOM w0.152: R608.2 48.74,145.66 49.12,146.05 v1(49.56,146.05) 49.72,145.89 U28.9
QSFP1_IIC_SDA: length 158.4
  TOP w0.14: v1(47.5,23.98) 47.65,23.83 U145.12
  03_SIG1 w0.173: v1(52.12,145.36) 51.57,145.91 51.57,146.51 50.65,147.43 48.86,147.43 47.61,146.18 44.79,146.18 43.74,145.14 43.74,144.27 43.26,143.79 43.26,133.76 44.36,132.66 44.36,130.93 43.37,129.94 37.64,129.94 35.61,127.91 35.61,116.66 36.26,116.01 36.26,110.53 38.04,108.74 38.04,95.15 30.57,87.68 30.57,71.66 32.58,69.66 32.58,67.23 32.12,66.77 32.12,45.32 33.48,43.97 33.48,38.34 37.03,34.79 37.03,32.32 43.92,25.42 46.2,25.42 47.5,24.13 v1(47.5,23.98)
  BOTTOM w0.152: R607.2 48.63,144.52 49.36,145.24 U28.8 52,145.24 v1(52.12,145.36)
QSFP1_INTL: length 17.1
  TOP w0.14: U145.28 53.64,25.03 54.25,25.65 v1(54.25,25.94)
  BOTTOM w0.152: v1(54.25,25.94) 54.78,26.47 55.67,26.47 55.96,26.18 55.96,24.84 57.98,22.81 R1095.2 58.38,23.23 58.57,23.42 60.63,23.42 61.01,23.79 61.01,25.18 59.75,26.43 U17.15
QSFP1_INTL_LS: length 96.7
  TOP w0.152: v2(129.24,62.84) U1.AP21
  14_SIG4 w0.089: v2(126.24,41.84) 126.73,42.33 126.73,44.34 126.85,44.46 126.85,46.23 127.06,46.44 127.54,46.44 127.73,46.62 127.73,47.27 127.84,47.38 127.84,61.01 128.07,61.24 128.53,61.24 128.84,61.55 128.84,62.44 v2(129.24,62.84)
  BOTTOM w0.152: U17.6 59.74,33.42 59.74,32.34 60.62,31.46 80.88,31.46 84.43,35.01 84.43,36.6 87.6,39.77 123.48,39.77 125.01,41.3 125.37,41.3 125.92,41.84 v2(126.24,41.84)
QSFP1_LPMODE: length 11.6
  TOP w0.14: U145.31 54.25,27.43 54.53,27.72 55.02,27.72 v1(55.47,28.17)
  05_SIG2 w0.173: v1(55.47,28.17) 57.31,28.17 v1(59.35,30.21)
  BOTTOM w0.152: v1(59.35,30.21) 60.4,29.16 U17.14
QSFP1_LPMODE_LS: length 95.1
  TOP w0.152: v2(128.24,62.84) U1.AN21
  14_SIG4 w0.089: v2(125.24,41.84) 125.75,42.35 125.75,44.05 126.03,44.33 126.4,44.33 126.65,44.59 126.65,46.31 126.74,46.4 126.74,47.11 126.98,47.35 127.46,47.35 127.67,47.55 127.67,61.12 127.99,61.44 128.44,61.44 128.64,61.64 128.64,62.44 v2(128.24,62.84)
  BOTTOM w0.152: U17.7 60.4,32.41 60.91,31.9 80.34,31.9 83.66,35.23 83.66,36.68 87.29,40.31 123.45,40.31 124.98,41.84 v2(125.24,41.84)
QSFP1_MODPRSL: length 16.2
  TOP w0.14: v1(55.27,25.94) 54.76,25.43 54.58,25.43 53.67,24.52 53.37,24.52 53.08,24.23 U145.27
  05_SIG2 w0.173: v1(59.18,26.04) 59.18,26.62 58.83,26.97 56.31,26.97 v1(55.27,25.94)
  BOTTOM w0.152: R1094.2 57.92,22.13 57.92,22.28 55.27,24.93 v1(55.27,25.94) ; U17.16 59.1,26.12 v1(59.18,26.04)
QSFP1_MODPRSL_LS: length 104.3
  TOP w0.152: U1.AL21 v2(126.24,62.84)
  14_SIG4 w0.089: v2(126.24,62.84) 126.24,62.64 125.84,62.24 125.84,61.35 125.64,61.15 125.64,51.5 125.47,51.33 125.03,51.33 124.74,51.05 124.74,50.56 124.52,50.33 124.03,50.33 124.01,50.31 124,50.31 123.73,50.04 123.73,46.64 123.44,46.35 123.03,46.35 122.74,46.06 122.74,44.55 122.53,44.34 122.03,44.34 121.74,44.05 121.74,43.34 v2(122.24,42.84)
  BOTTOM w0.152: v2(122.24,42.84) 122.73,42.35 123.59,42.35 123.75,42.51 123.75,43.15 123.94,43.33 124.51,43.33 124.75,43.09 124.75,42.56 124.97,42.34 126.42,42.34 126.74,42.02 126.74,41.64 126.45,41.35 125.84,41.35 123.73,39.24 96.66,39.24 88.49,31.07 60.31,31.07 59.1,32.27 U17.5
QSFP1_MODSELL: length 13.5
  TOP w0.14: U145.8 v1(48.06,27.03)
  03_SIG1 w0.173: v1(57.8,25.8) 57.13,26.47 54.82,26.47 54.26,27.03 v1(48.06,27.03)
  BOTTOM w0.152: U17.18 v1(57.8,25.8)
QSFP1_MODSELL_LS: length 99.3
  TOP w0.152: v2(127.24,62.84) U1.AM21
  14_SIG4 w0.089: v2(127.24,62.84) 126.84,62.44 126.84,61.37 126.64,61.17 126.64,50.52 126.45,50.34 126,50.34 125.73,50.06 125.73,47.46 125.64,47.38 125.64,46.55 125.64,46.55 125.44,46.35 125.05,46.35 124.75,46.05 124.75,46.01 124.73,45.99 124.73,44.59 124.46,44.33 124.45,44.33 124.44,44.33 124.03,44.33 123.75,44.05 123.75,43.33 v2(124.24,42.84)
  BOTTOM w0.152: U17.3 57.8,35.07 57.95,35.22 R1190.1 57.95,37.04 58.42,37.51 63.38,37.51 66.59,34.3 81.43,34.3 82.89,35.76 82.89,36.91 86.76,40.77 122.96,40.77 123.76,41.57 123.76,42.06 124.24,42.53 v2(124.24,42.84)
QSFP1_RECCLK_C_N: length 2.3
  TOP w0.104: C28.2 80.38,21.96 80.71,22.29 81.66,22.29 81.85,22.1 U57.17
QSFP1_RECCLK_C_P: length 2.3
  TOP w0.104: U57.16 81.76,22.6 81.66,22.51 80.87,22.51 80.38,23 C25.2
QSFP1_RECCLK_N: length 97.8
  TOP w0.104: U1.AM22 v2(127.24,63.84) ; C28.1 79.31,21.97 R266.2 v1(77.47,21.97)
  16_SIG5 w0.076: v2(127.24,63.84) 126.84,64.24 119.01,64.24 118.35,63.59 118.35,56.32 117.87,55.84 117.87,42.34 117.5,41.98 117.5,41.54 117.54,41.5 117.54,41.48
  16_SIG5 w0.089: v1(77.47,21.97) 77.81,22.31 78.27,22.31 78.54,22.04 78.54,21.39 81.37,18.57 83.73,18.57 84.3,18 87.95,18 88.4,18.44 91.89,18.44 92.96,17.37 100.98,17.37 101.36,16.99 104.71,16.99 106.46,18.74 110.48,18.74 115.82,24.08 115.82,29.98 117.15,31.31 117.15,33.5 116.09,34.55 116.09,37.06 117.54,38.51 117.54,41.48
QSFP1_RECCLK_P: length 97.9
  TOP w0.104: C25.1 79.31,22.97 R266.1 v1(77.47,22.97) ; v2(127.24,64.84) U1.AM23
  16_SIG5 w0.076: 117.27,41.48 117.27,41.5 117.31,41.54 117.31,42.06 117.67,42.43 117.67,55.93 118.15,56.4 118.15,63.67 118.92,64.44 127.15,64.44 127.24,64.53 v2(127.24,64.84)
  16_SIG5 w0.089: 117.27,41.48 117.27,38.63 115.81,37.17 115.81,34.44 116.87,33.38 116.87,31.43 115.54,30.1 115.54,24.19 110.36,19.02 106.34,19.02 104.6,17.27 101.47,17.27 101.09,17.65 93.08,17.65 92,18.72 88.28,18.72 87.84,18.28 84.41,18.28 83.85,18.85 81.48,18.85 78.82,21.51 78.82,22.16 78.39,22.59 77.84,22.59 v1(77.47,22.97)
QSFP1_RESETL: length 14.6
  TOP w0.14: U145.9 v1(48.06,26.23)
  03_SIG1 w0.173: v1(48.06,26.23) 50.14,26.23 51.35,25.02 58.04,25.02 58.45,25.43 v1(58.45,26.27)
  BOTTOM w0.152: U17.17 v1(58.45,26.27)
QSFP1_RESETL_LS: length 137.8
  TOP w0.152: U1.BA22 v2(136.24,63.84)
  18_SIG6 w0.089: v1(61.02,36) 61.72,36.71 61.72,41.53 64.69,44.5 64.69,46.56 62.96,48.29 62.96,64.03 64.65,65.72 64.65,72.7 65.05,73.1 65.05,76.99 v1(66.21,78.14)
  BOTTOM w0.113: 133.46,63.34 133.74,63.06 133.74,62.66 133.95,62.44 134.51,62.44 134.7,62.63 134.7,62.99 134.95,63.24 135.49,63.24 136.09,63.84 v2(136.24,63.84)
  BOTTOM w0.152: v1(61.02,36) 59.84,34.82 58.67,34.82 58.45,34.6 U17.4 ; v1(66.21,78.14) 66.21,78.55 68.02,80.37 81.36,80.37 82.7,81.71 88.49,81.71 91.85,78.34 100.45,78.34 100.74,78.06 100.74,77.63 101.02,77.34 101.44,77.34 101.74,77.04 101.74,76.63 102.02,76.34 102.44,76.34 102.74,76.04 102.74,75.63 103.02,75.34 103.44,75.34 103.74,75.04 103.74,74.65 104.04,74.34 104.44,74.34 104.7,74.08 104.7,73.68 105.08,73.3 105.56,73.3 105.74,73.13 105.74,72.6 105.99,72.34 106.44,72.34 106.71,72.07 106.71,71.68 107.04,71.34 107.5,71.34 107.75,71.09 107.75,70.63 108.02,70.36 108.43,70.36 108.71,70.08 108.71,69.67 109.04,69.34 109.52,69.34 109.7,69.16 109.7,68.68 110.01,68.38 112.47,68.38 112.73,68.63 112.73,69.06 113.03,69.37 113.51,69.37 113.77,69.62 113.77,70.05 114.06,70.35 117.44,70.35 118.26,69.52 118.26,69.11 119.03,68.34 128.45,68.34 128.74,68.06 128.74,67.64 129.04,67.34 129.44,67.34 129.74,67.04 129.74,66.64 130.38,66 131.41,66 132.07,65.34 132.6,65.34 132.74,65.2 132.74,63.64 133.04,63.34 133.46,63.34
QSFP1_RX1_N: length 87.5
  TOP w0.104: v9(46.38,19.03) 46.46,18.95 arc(46.6,18.86) 46.76,18.83 47.39,18.83 arc(47.5,18.85) 47.59,18.91 47.95,19.28 arc(48,19.31) 48.05,19.33 arc(48.07,19.33) 48.08,19.33 48.12,19.33 arc(48.13,19.33) 48.14,19.33 arc(48.17,19.32) 48.2,19.31 arc(48.2,19.31) 48.2,19.31 arc(48.21,19.3) 48.23,19.29 48.43,19.08 arc(48.49,19.04) 48.55,19.03 U145.18
  TOP w0.114: U1.Y1 114.74,43.34 v2(114.24,42.84)
  05_SIG2 w0.109: v2(114.24,42.84) 114.24,43.13 arc(114.2,43.21) 114.13,43.24 113.98,43.24 arc(113.88,43.2) 113.84,43.1 113.84,42.53 arc(113.87,42.35) 113.98,42.2 arc(114.09,42.04) 114.16,41.86 arc(114.17,41.79) 114.17,41.73 114.17,41.28 arc(114.19,41.17) 114.26,41.08
  05_SIG2 w0.152: 114.26,41.08 114.26,40.87 arc(113.76,38.37) 112.35,36.26 109.15,33.06 arc(109.07,32.94) 109.04,32.81 arc(108.97,32.44) 108.76,32.12 108.75,32.11 arc(107.31,31.15) 105.61,30.81 102.3,30.81 arc(101.92,30.74) 101.6,30.52 101.22,30.14 arc(100.84,29.89) 100.4,29.8 99.95,29.8 arc(99.69,29.75) 99.47,29.6 98.18,28.31 arc(97.99,28.18) 97.76,28.14 97.18,28.14 arc(96.96,28.09) 96.77,27.97 92.46,23.66 arc(91.94,23.31) 91.32,23.18 91.06,23.18 arc(90.36,23.04) 89.77,22.65 88.74,21.62 arc(88.06,21.16) 87.26,21.01 83.71,21.01 arc(82.38,20.74) 81.25,19.99 78.82,17.55 arc(78.22,17.15) 77.51,17.01 75,17.01 arc(74.75,16.96) 74.53,16.82 74.39,16.68 arc(74.08,16.47) 73.71,16.39 56.92,16.39 arc(56.16,16.54) 55.52,16.97 55.18,17.31 55.19,17.31 arc(54.91,17.44) 54.61,17.49 49.91,17.49 arc(49.08,17.65) 48.37,18.12 48.34,18.16 arc(48.13,18.47) 48.06,18.84 48.06,19.08 arc(48.01,19.19) 47.91,19.23 arc(47.82,19.21) 47.75,19.16 47.62,19.03 arc(47,18.78) v9(46.38,19.03)
QSFP1_RX1_P: length 87.6
  TOP w0.104: v9(46.38,19.83) 46.5,19.95 arc(46.6,20.01) 46.71,20.04 47.38,20.04 arc(47.49,20.01) 47.59,19.95 47.95,19.59 arc(47.98,19.57) 48.02,19.56 48.18,19.56 arc(48.22,19.56) 48.24,19.58 48.45,19.79 arc(48.5,19.82) 48.55,19.83 U145.17
  TOP w0.114: U1.Y2 114.74,44.34 v2(114.24,43.84)
  05_SIG2 w0.109: v2(114.24,43.84) 114.24,43.55 arc(114.2,43.48) 114.13,43.44 113.98,43.44 arc(113.74,43.34) 113.64,43.1 113.64,42.53 arc(113.69,42.27) 113.83,42.05 arc(113.91,41.95) 113.96,41.82 arc(113.97,41.77) 113.97,41.73 113.97,41.33 arc(113.95,41.21) 113.88,41.1
  05_SIG2 w0.152: 113.88,41.1 113.88,40.87 arc(113.41,38.52) 112.08,36.53 108.88,33.33 arc(108.72,33.09) 108.66,32.81 arc(108.62,32.58) 108.49,32.39 108.48,32.38 arc(107.16,31.5) 105.61,31.19 102.3,31.19 arc(101.78,31.09) 101.33,30.79 100.95,30.41 arc(100.7,30.24) 100.4,30.18 99.95,30.18 arc(99.55,30.1) 99.2,29.87 97.92,28.58 arc(97.84,28.53) 97.76,28.52 97.18,28.52 arc(96.81,28.44) 96.51,28.24 92.19,23.93 arc(91.79,23.66) 91.32,23.56 91.06,23.56 arc(90.21,23.4) 89.5,22.92 88.47,21.89 arc(87.92,21.52) 87.26,21.39 83.71,21.39 arc(82.23,21.09) 80.98,20.26 78.55,17.82 arc(78.07,17.5) 77.51,17.39 75,17.39 arc(74.6,17.31) 74.26,17.09 74.12,16.95 arc(73.93,16.82) 73.71,16.78 56.92,16.78 arc(56.31,16.9) 55.79,17.24 55.72,17.31 55.73,17.31 55.43,17.61 55.4,17.63 arc(55.02,17.81) 54.61,17.87 52.51,17.87 arc(52.41,17.91) 52.38,18 arc(52.34,18.1) 52.24,18.14 51.59,18.14 arc(51.5,18.1) 51.46,18 arc(51.42,17.91) 51.33,17.87 49.91,17.87 arc(49.22,18.01) 48.64,18.39 48.61,18.43 arc(48.48,18.62) 48.44,18.84 48.44,19.17 arc(48.31,19.48) 48,19.61 arc(47.83,19.64) 47.69,19.74 47.59,19.83 arc(46.99,20.08) v9(46.38,19.83)
