# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_C1_DQS2_C: length 53.1
  TOP w0.145: v2(103.24,60.84) U1.J19
  03_SIG1 w0.127: 94.87,56.19 94.9,56.19 94.95,56.24 102.5,56.24 102.84,56.58 102.84,57.02 103.06,57.24 103.5,57.24 103.84,57.58 103.84,58.02 104.06,58.24 104.54,58.24 104.84,58.54 104.84,61.16 104.55,61.45 103.85,61.45 103.61,61.21 103.61,60.95 103.51,60.84 v2(103.24,60.84)
  03_SIG1 w0.178: 81.61,65.76 81.03,66.34 78.88,66.34 78.45,66.76 76.88,66.76 76.76,66.64 76.76,66.39 77.06,66.08 77.06,65.73 v4(77.16,65.64) ; 94.39,56.19 94.87,56.19
  03_SIG1 w0.208: 81.61,65.76 81.97,65.41 81.97,65.02 81.62,64.67 81.62,64 81.97,63.65 81.97,62.88 82.34,62.51 85.63,62.51 86.44,61.7 86.44,61.45 85.88,60.9 85.88,60.4 86.23,60.05 86.73,60.05 87.28,60.6 87.56,60.6 87.73,60.43 87.73,60.22 86.92,59.41 86.92,58.89 87.27,58.54 87.75,58.54 88.55,59.34 88.8,59.34 88.97,59.17 88.97,58.93 88.19,58.15 88.19,57.62 88.54,57.27 89.01,57.27 89.84,58.1 90.09,58.1 90.27,57.93 90.27,57.69 89.44,56.87 89.44,56.36 89.79,56.01 90.28,56.01 91.08,56.81 91.33,56.81 91.95,56.19 94.39,56.19
  BOTTOM w0.145: v4(77.16,65.64) U61.F3
DDR4_C1_DQS2_T: length 52.9
  TOP w0.145: v2(104.24,60.84) U1.K19
  03_SIG1 w0.127: v2(104.24,60.84) 103.88,60.84 103.82,60.9 103.82,61.12 103.94,61.24 104.46,61.24 104.63,61.07 104.63,58.63 104.45,58.45 103.98,58.45 103.63,58.1 103.63,57.67 103.41,57.45 102.97,57.45 102.63,57.11 102.63,56.67 102.41,56.45 94.95,56.45 94.9,56.5 94.87,56.5
  03_SIG1 w0.178: v4(76.36,65.64) 76.65,65.64 76.76,65.74 76.76,65.95 76.45,66.26 76.45,66.76 76.76,67.07 78.58,67.07 79.01,66.64 81.16,66.64 81.61,66.19 ; 94.39,56.5 94.87,56.5
  03_SIG1 w0.208: 94.39,56.5 92.07,56.5 91.45,57.12 90.95,57.12 90.15,56.32 89.92,56.32 89.75,56.49 89.75,56.74 90.57,57.57 90.57,58.06 90.22,58.41 89.72,58.41 88.88,57.58 88.67,57.58 88.5,57.75 88.5,58.02 89.28,58.8 89.28,59.29 88.92,59.64 88.42,59.64 87.63,58.85 87.4,58.85 87.23,59.02 87.23,59.28 88.03,60.09 88.03,60.56 87.68,60.91 87.16,60.91 86.6,60.35 86.36,60.35 86.19,60.53 86.19,60.77 86.74,61.33 86.74,61.83 85.76,62.81 82.46,62.81 82.27,63.01 82.27,63.78 81.92,64.12 81.92,64.55 82.27,64.9 82.27,65.53 81.61,66.19
  BOTTOM w0.145: v4(76.36,65.64) U61.G3
DDR4_C1_DQS3_C: length 37.5
  TOP w0.145: v2(99.24,57.84) 99.74,58.34 U1.E16
  07_SIG3 w0.127: 94.39,57.5 94.49,57.5 94.54,57.45 99.54,57.45 99.76,57.66 99.76,57.78 99.59,57.94 99.33,57.94 v2(99.24,57.84)
  07_SIG3 w0.178: 81.61,66.71 81.48,66.85 80.74,66.85 80.61,66.98 80.61,67.32 80.79,67.51 80.79,67.87 80.95,68.04 v4(81.16,68.04)
  07_SIG3 w0.208: 94.39,57.5 94.11,57.5 93.11,56.49 93.11,56.1 92.66,55.65 92.16,55.65 91.89,55.92 91.89,56.37 91.57,56.69 91.04,56.69 90.72,56.37 90.72,55.79 90.58,55.65 90.3,55.65 90.16,55.79 90.16,56.37 89.84,56.69 89.31,56.69 88.99,56.37 88.99,55.79 88.85,55.65 88.57,55.65 88.43,55.79 88.43,56.37 88.11,56.69 87.58,56.69 87.26,56.37 87.26,55.87 87.12,55.73 86.72,55.73 85.71,56.74 84.63,56.74 84.49,56.87 84.49,57.98 83.72,58.75 83.72,60.07 83.9,60.25 83.9,62.18 83.27,62.81 82.46,62.81 82.33,62.94 82.33,65.99 81.61,66.71
  BOTTOM w0.145: v4(81.16,68.04) U61.A7
DDR4_C1_DQS3_T: length 37.7
  TOP w0.145: U1.F16 100.74,58.34 v2(100.24,57.84)
  07_SIG3 w0.127: v2(100.24,57.84) 99.84,57.45 99.63,57.24 94.56,57.24 94.52,57.19 94.39,57.19
  07_SIG3 w0.178: 81.61,66.28 81.35,66.54 80.62,66.54 80.31,66.85 80.31,67.45 80.49,67.63 80.49,67.9 v4(80.36,68.04)
  07_SIG3 w0.208: 94.39,57.19 94.24,57.19 93.42,56.37 93.42,55.98 92.79,55.35 92.03,55.35 91.58,55.8 91.58,56.25 91.44,56.39 91.16,56.39 91.02,56.25 91.02,55.66 90.7,55.35 90.17,55.35 89.85,55.66 89.85,56.25 89.71,56.39 89.44,56.39 89.3,56.25 89.3,55.66 88.98,55.35 88.45,55.35 88.13,55.66 88.13,56.25 87.99,56.39 87.71,56.39 87.57,56.25 87.57,55.74 87.25,55.42 86.6,55.42 85.59,56.43 84.5,56.43 84.19,56.75 84.19,57.85 83.41,58.63 83.41,60.2 83.59,60.38 83.59,62.05 83.14,62.5 82.34,62.5 82.02,62.81 82.02,65.87 81.61,66.28
  BOTTOM w0.145: v4(80.36,68.04) U61.B7
DDR4_C1_DQS4_C: length 58.8
  TOP w0.145: v2(95.24,59.84) U1.A18
  05_SIG2 w0.178: v2(95.24,59.84) 95.24,60.24 95.15,60.33 94.39,60.33 ; 81.38,94.21 81.38,94.29 81.19,94.48 77.06,94.48 76.86,94.28 76.86,94 77.03,93.83 v4(77.16,93.83)
  05_SIG2 w0.208: 81.38,94.21 81.66,93.93 81.66,91.02 81.52,90.88 78.98,90.88 78.47,90.37 78.47,88.45 79.07,87.85 80.82,87.85 81.13,88.16 81.13,88.88 81.28,89.02 81.5,89.02 81.65,88.87 81.65,88.22 81.91,87.96 83.54,87.96 84.49,87.01 84.49,67.81 85.11,67.19 86.17,67.19 86.5,67.51 89.01,67.51 90.28,66.24 90.28,64.05 94.01,60.33 94.39,60.33
  BOTTOM w0.145: U62.F3 v4(77.16,93.83)
DDR4_C1_DQS4_T: length 58.8
  TOP w0.145: v2(95.24,60.84) U1.A19
  05_SIG2 w0.178: v2(95.24,60.84) 95.02,60.63 94.39,60.63 ; 81.61,94.48 81.31,94.78 76.93,94.78 76.53,94.39 76.53,94.01 v4(76.36,93.83)
  05_SIG2 w0.208: 94.39,60.63 94.14,60.63 90.59,64.18 90.59,66.36 89.14,67.82 86.37,67.82 86.05,67.49 85.24,67.49 84.8,67.93 84.8,87.14 83.67,88.26 82.04,88.26 81.95,88.35 81.95,89 81.62,89.33 81.15,89.33 80.83,89.01 80.83,88.29 80.7,88.15 79.2,88.15 78.77,88.58 78.77,90.24 79.1,90.57 81.65,90.57 81.97,90.89 81.97,94.13 81.61,94.48
  BOTTOM w0.145: v4(76.36,93.83) U62.G3
DDR4_C1_DQS5_C: length 79.9
  TOP w0.145: v2(106.24,63.84) U1.M22
  03_SIG1 w0.127: 94.39,78.19 94.42,78.19 94.47,78.24 95.44,78.24 95.63,78.05 95.63,77.54 95.93,77.24 96.41,77.24 96.63,77.02 96.63,76.53 96.92,76.24 97.4,76.24 97.63,76.01 97.63,75.58 97.97,75.24 98.41,75.24 98.63,75.02 98.63,74.55 98.94,74.24 99.41,74.24 99.63,74.02 99.63,73.55 99.95,73.24 100.42,73.24 100.63,73.02 100.63,72.54 100.94,72.24 101.42,72.24 101.63,72.02 101.63,71.5 101.89,71.24 102.42,71.24 102.63,71.02 102.63,69.59 102.99,69.24 103.41,69.24 103.63,69.01 103.63,68.59 103.98,68.24 104.4,68.24 104.63,68.01 104.63,67.59 104.98,67.24 105.43,67.24 105.63,67.04 105.63,64.59 105.98,64.24 106.66,64.24 106.77,64.13 106.77,63.92 106.69,63.84 v2(106.24,63.84)
  03_SIG1 w0.178: 81.61,96.15 81.61,96.14 81.56,96.09 81.56,95.83 81.4,95.66 81.25,95.66 81.16,95.76 v4(81.16,96.23)
  03_SIG1 w0.208: 94.39,78.19 94.01,78.19 85.59,86.61 81.58,86.61 81.25,86.94 81.25,87.51 81.06,87.7 79.98,87.7 79.8,87.52 79.8,86.99 79.49,86.68 78.88,86.68 78.61,86.95 78.61,87.47 78.43,87.65 78.13,87.65 78,87.52 78,86.62 77.71,86.32 77.14,86.32 76.82,86.64 76.82,87.47 76.58,87.71 76.35,87.71 76.2,87.56 76.2,86.66 75.86,86.32 75.32,86.32 75.01,86.63 75.01,87.55 74.9,87.66 74.58,87.66 74.43,87.51 74.43,87.14 74.12,86.82 73.63,86.82 73.35,87.1 73.35,88.44 73.63,88.72 73.94,88.72 74.12,88.9 74.12,89.18 74.02,89.28 72.88,89.28 72.58,89.58 72.58,90.14 73.32,90.89 81.24,90.89 81.64,91.28 81.64,92.11 82,92.48 82.41,92.48 82.56,92.63 82.56,93.22 82.41,93.37 82.07,93.37 81.64,93.8 81.64,94.46 82.06,94.88 82.47,94.88 82.57,94.98 82.57,95.67 82.08,96.15 81.61,96.15
  BOTTOM w0.145: U62.A7 v4(81.16,96.23)
DDR4_C1_DQS5_T: length 80
  TOP w0.145: v2(107.24,63.84) U1.N22
  03_SIG1 w0.127: v2(107.24,63.84) 106.98,64.1 106.98,64.22 106.75,64.45 106.07,64.45 105.84,64.68 105.84,67.13 105.52,67.45 105.07,67.45 104.84,67.67 104.84,68.09 104.49,68.45 104.07,68.45 103.84,68.68 103.84,69.1 103.5,69.45 103.07,69.45 102.84,69.68 102.84,71.11 102.5,71.45 101.98,71.45 101.84,71.59 101.84,72.11 101.5,72.45 101.02,72.45 100.84,72.63 100.84,73.11 100.5,73.45 100.03,73.45 99.84,73.64 99.84,74.1 99.5,74.45 99.03,74.45 98.84,74.64 98.84,75.1 98.5,75.45 98.06,75.45 97.84,75.66 97.84,76.1 97.49,76.45 97.01,76.45 96.84,76.62 96.84,77.11 96.5,77.45 96.02,77.45 95.84,77.63 95.84,78.13 95.53,78.45 94.47,78.45 94.42,78.5 94.39,78.5
  03_SIG1 w0.178: 81.61,96.46 81.51,96.46 81.33,96.63 80.76,96.63 v4(80.36,96.23)
  03_SIG1 w0.208: 81.61,96.46 82.21,96.46 82.87,95.79 82.87,94.85 82.6,94.58 82.18,94.58 81.94,94.34 81.94,93.93 82.19,93.68 82.53,93.68 82.87,93.34 82.87,92.51 82.54,92.18 82.13,92.18 81.94,91.99 81.94,91.11 81.41,90.58 73.45,90.58 72.88,90.01 72.88,89.7 73,89.58 74.14,89.58 74.42,89.31 74.42,88.78 74.06,88.42 73.76,88.42 73.65,88.31 73.65,87.23 73.76,87.12 73.99,87.12 74.13,87.26 74.13,87.64 74.45,87.96 75.03,87.96 75.31,87.68 75.31,86.76 75.45,86.62 75.73,86.62 75.9,86.79 75.9,87.69 76.22,88.01 76.71,88.01 77.12,87.59 77.12,86.77 77.27,86.62 77.58,86.62 77.7,86.74 77.7,87.65 78,87.95 78.56,87.95 78.92,87.59 78.92,87.07 79,86.99 79.37,86.99 79.49,87.12 79.49,87.65 79.85,88.01 81.19,88.01 81.56,87.64 81.56,87.07 81.71,86.92 85.71,86.92 94.14,78.5 94.39,78.5
  BOTTOM w0.145: U62.B7 v4(80.36,96.23)
DDR4_C1_DQS6_C: length 55.4
  TOP w0.145: v2(105.24,61.84) U1.L20
  07_SIG3 w0.127: 94.39,68.19 94.42,68.19 94.47,68.24 97.5,68.24 97.63,68.11 97.63,67.58 97.5,67.45 95.82,67.45 95.63,67.26 95.63,66.46 95.85,66.24 100.87,66.24 101.32,65.79 104.44,65.79 104.63,65.59 104.63,62.51 104.9,62.24 105.62,62.24 105.7,62.17 105.7,61.99 105.55,61.84 v2(105.24,61.84)
  07_SIG3 w0.178: 81.61,79.89 81.31,80.19 78.56,80.19 78.2,80.54 77.94,80.54 77.87,80.47 77.87,80.21 77.71,80.05 77.49,80.05 77.34,80.21 77.34,80.43 77.22,80.54 77.06,80.54 76.85,80.33 76.85,79.84 76.96,79.73 v4(77.16,79.73)
  07_SIG3 w0.208: 94.39,68.19 94.17,68.19 93.76,68.6 93.76,69.09 93.87,69.2 93.87,69.45 93.7,69.62 93.46,69.62 93.3,69.46 92.9,69.46 92.5,69.86 92.5,70.36 92.85,70.71 92.85,70.97 92.68,71.14 92.45,71.14 92.08,70.77 91.58,70.77 91.23,71.12 91.23,71.62 91.57,71.96 91.57,72.21 91.4,72.38 91.16,72.38 90.82,72.04 90.32,72.04 89.97,72.39 89.97,72.89 90.31,73.23 90.31,73.47 90.14,73.64 89.89,73.64 89.55,73.3 89.05,73.3 88.7,73.65 88.7,74.15 89.05,74.49 89.05,74.73 88.87,74.91 88.63,74.91 88.29,74.57 87.79,74.57 87.44,74.92 87.44,75.41 87.78,75.76 87.78,76 87.61,76.17 87.36,76.17 87.02,75.83 86.53,75.83 86.23,76.12 86.08,76.12 85.7,76.5 84.56,76.5 83.25,77.81 82.12,77.81 81.74,78.19 81.74,79.76 81.61,79.89
  BOTTOM w0.145: v4(77.16,79.73) U63.F3
DDR4_C1_DQS6_T: length 55.2
  TOP w0.145: v2(106.24,61.84) U1.M20
  07_SIG3 w0.127: v2(106.24,61.84) 105.91,62.17 105.91,62.25 105.71,62.45 104.99,62.45 104.84,62.6 104.84,65.68 104.53,66 101.41,66 100.96,66.45 95.94,66.45 95.84,66.55 95.84,67.17 95.91,67.24 97.59,67.24 97.84,67.49 97.84,68.2 97.59,68.45 94.47,68.45 94.42,68.5 94.39,68.5
  07_SIG3 w0.178: 81.61,80.32 81.44,80.49 78.68,80.49 78.33,80.85 76.94,80.85 76.55,80.46 76.55,79.92 v4(76.36,79.73)
  07_SIG3 w0.208: 94.39,68.5 94.29,68.5 94.07,68.72 94.07,68.97 94.18,69.08 94.18,69.57 93.83,69.93 93.33,69.93 93.17,69.76 93.02,69.76 92.8,69.99 92.8,70.23 93.16,70.58 93.16,71.09 92.81,71.44 92.32,71.44 91.95,71.08 91.71,71.08 91.54,71.25 91.54,71.49 91.88,71.84 91.88,72.33 91.53,72.68 91.03,72.68 90.69,72.34 90.45,72.34 90.27,72.51 90.27,72.76 90.61,73.1 90.61,73.6 90.26,73.95 89.77,73.95 89.43,73.61 89.18,73.61 89.01,73.78 89.01,74.02 89.35,74.36 89.35,74.86 89,75.21 88.5,75.21 88.16,74.87 87.92,74.87 87.74,75.04 87.74,75.29 88.09,75.63 88.09,76.13 87.73,76.48 87.24,76.48 86.9,76.14 86.65,76.14 86.36,76.43 86.2,76.43 85.83,76.8 84.69,76.8 83.38,78.11 82.25,78.11 82.04,78.32 82.04,79.89 81.61,80.32
  BOTTOM w0.145: v4(76.36,79.73) U63.G3
DDR4_C1_DQS7_C: length 37.1
  TOP w0.145: v2(101.24,64.84) U1.G23
  03_SIG1 w0.127: v2(101.24,64.84) 101.24,64.96 101.63,65.36 101.63,67.04 101.43,67.24 100.99,67.24 100.63,67.59 100.63,68.07 100.46,68.24 99.99,68.24 99.63,68.59 99.63,69.01 99.41,69.24 98.98,69.24 98.63,69.59 98.63,71.04 98.43,71.24 97.97,71.24 97.63,71.58 97.63,72.03 97.42,72.24 96.91,72.24 96.63,72.51 96.63,73.02 96.42,73.24 95.99,73.24 95.84,73.09 95.84,72.54 95.54,72.24 94.84,72.24 94.5,72.59 94.43,72.59 94.41,72.61
  03_SIG1 w0.178: v4(81.16,82.13) 81.61,82.13 ; 94.39,72.63 94.41,72.61
  03_SIG1 w0.208: 94.39,72.63 94.05,72.96 94.05,73.51 94.25,73.7 94.25,74 93.95,74.29 93.66,74.29 93.46,74.1 92.92,74.1 92.38,74.63 92.38,75.29 92,75.68 91.34,75.68 90.77,76.24 90.77,76.9 90.39,77.28 89.73,77.28 89.19,77.82 89.19,78.48 88.81,78.87 88.15,78.87 87.59,79.43 87.59,80.09 87.2,80.48 86.54,80.48 86.02,80.99 86.02,81.34 85.81,81.56 84.75,81.56 84.43,81.88 84.43,82.1 84.29,82.25 84.04,82.25 83.88,82.08 83.88,81.87 83.57,81.56 82.52,81.56 81.95,82.13 81.61,82.13
  BOTTOM w0.145: v4(81.16,82.13) U63.A7
DDR4_C1_DQS7_T: length 36.9
  TOP w0.145: v2(102.24,66.84) U1.H24
  03_SIG1 w0.127: v2(102.24,66.84) 102.16,66.84 102.05,66.74 101.92,66.74 101.84,66.81 101.84,67.12 101.52,67.45 101.08,67.45 100.84,67.68 100.84,68.15 100.55,68.45 100.07,68.45 99.84,68.68 99.84,69.1 99.5,69.45 99.07,69.45 98.84,69.68 98.84,71.12 98.52,71.45 98.06,71.45 97.84,71.66 97.84,72.12 97.51,72.45 97,72.45 96.84,72.6 96.84,73.11 96.5,73.45 95.91,73.45 95.63,73.17 95.63,72.63 95.45,72.45 94.93,72.45 94.64,72.73 94.64,72.8 94.62,72.82
  03_SIG1 w0.178: 81.61,82.44 81.46,82.44 81.36,82.53 80.57,82.53 80.36,82.32 v4(80.36,82.13)
  03_SIG1 w0.208: 81.61,82.44 82.08,82.44 82.65,81.86 83.44,81.86 83.57,82 83.57,82.21 83.92,82.55 84.41,82.55 84.74,82.23 84.74,82 84.88,81.86 85.93,81.86 86.33,81.47 86.33,81.12 86.67,80.78 87.33,80.78 87.89,80.22 87.89,79.55 88.27,79.17 88.94,79.17 89.5,78.61 89.5,77.95 89.86,77.59 90.51,77.59 91.08,77.02 91.08,76.37 91.46,75.98 92.12,75.98 92.69,75.42 92.69,74.76 93.04,74.4 93.34,74.4 93.53,74.6 94.08,74.6 94.55,74.12 94.55,73.58 94.36,73.38 94.36,73.09 94.62,72.82
  BOTTOM w0.145: v4(80.36,82.13) U63.B7
DDR4_C1_DQS8_C: length 58
  TOP w0.145: v2(97.24,63.84) U1.C22
  16_SIG5 w0.107: 94.6,59.46 94.6,59.53 94.83,59.75 94.83,60.01 95.06,60.24 96.46,60.24 96.82,60.6 96.82,61.05 97.02,61.24 97.49,61.24 97.84,61.59 97.84,62.12 97.96,62.24 98.51,62.24 98.84,62.57 98.84,64.19 98.57,64.45 97.9,64.45 97.64,64.18 97.64,63.95 97.53,63.84 v2(97.24,63.84)
  16_SIG5 w0.108: 81.61,52.05 81.6,52.05 81.57,52.08 76.99,52.08 76.88,51.97 76.88,51.81 v4(77.16,51.54)
  16_SIG5 w0.14: 81.61,52.05 81.72,52.05 81.85,51.92 81.85,48.86 81.66,48.67 78.36,48.67 77.39,47.71 77.39,45.06 77.8,44.65 78.57,44.65 78.96,45.05 78.96,45.26 79.17,45.47 79.59,45.47 79.8,45.26 79.8,44.68 80.17,44.3 82.95,44.3 83.81,43.44 86.77,43.44 92.15,48.82 92.15,57.01 94.6,59.46
  BOTTOM w0.145: v4(77.16,51.54) U64.F3
DDR4_C1_DQS8_T: length 58
  TOP w0.145: v2(98.24,63.84) U1.D22
  16_SIG5 w0.107: 94.39,59.67 94.4,59.68 94.47,59.68 94.62,59.84 94.62,60.09 94.97,60.44 96.38,60.44 96.62,60.68 96.62,61.13 96.93,61.45 97.41,61.45 97.63,61.67 97.63,62.2 97.88,62.44 98.42,62.44 98.64,62.66 98.64,64.1 98.49,64.25 97.99,64.25 97.84,64.1 97.84,63.95 97.95,63.84 v2(98.24,63.84)
  16_SIG5 w0.108: v4(76.36,51.54) 76.63,51.81 76.63,52.07 76.89,52.32 78.71,52.32 78.82,52.43 78.82,52.71 78.92,52.81 79.14,52.81 79.25,52.71 79.25,52.43 79.36,52.32 81.55,52.32 81.58,52.35 81.61,52.35
  16_SIG5 w0.14: 81.61,52.35 81.85,52.35 82.15,52.05 82.15,48.73 81.79,48.37 78.48,48.37 77.7,47.58 77.7,45.18 77.92,44.96 78.44,44.96 78.66,45.17 78.66,45.39 79.05,45.77 79.72,45.77 80.1,45.39 80.1,44.81 80.3,44.61 83.07,44.61 83.94,43.74 86.64,43.74 91.85,48.95 91.85,57.14 94.39,59.67
  BOTTOM w0.145: v4(76.36,51.54) U64.G3
DDR4_C1_DQS9_C: length 33.8
  TOP w0.145: v2(95.24,49.84) U1.A8
  05_SIG2 w0.178: 94.39,50.33 95.47,50.33 95.59,50.2 95.59,50.02 95.41,49.84 v2(95.24,49.84) ; 81.61,54.03 81.24,54.03 v4(81.16,53.94)
  05_SIG2 w0.208: 81.61,54.03 82.08,54.03 82.24,53.87 82.24,53.56 82.58,53.23 83.47,53.23 83.78,53.53 83.78,54.21 83.92,54.35 84.18,54.35 84.34,54.19 84.34,53.43 84.72,53.05 85.89,53.05 86.31,53.46 86.31,54.18 86.46,54.33 86.68,54.33 86.81,54.19 86.81,52.78 86.64,52.61 86.44,52.61 86.07,52.24 86.07,51.68 86.43,51.33 86.72,51.33 86.85,51.19 86.85,50.89 87.3,50.45 87.53,50.45 87.61,50.36 87.61,48.84 87.96,48.49 88.84,48.49 89.25,48.9 89.25,50.28 89.39,50.42 89.66,50.42 89.81,50.27 89.81,48.76 90.13,48.44 90.66,48.44 90.98,48.76 90.98,50.16 91.12,50.3 91.4,50.3 91.54,50.17 91.54,48.63 91.85,48.31 92.3,48.31 92.72,48.72 92.72,49.55 92.92,49.76 93.82,49.76 94.39,50.33
  BOTTOM w0.145: v4(81.16,53.94) U64.A7
DDR4_C1_DQS9_T: length 33.8
  TOP w0.145: v2(95.24,50.84) U1.A9
  05_SIG2 w0.178: v4(80.36,53.94) 80.76,54.34 81.6,54.34 81.61,54.33 ; 94.39,50.63 95.03,50.63 v2(95.24,50.84)
  05_SIG2 w0.208: 81.61,54.33 82.21,54.33 82.54,54 82.54,53.69 82.7,53.53 83.35,53.53 83.47,53.66 83.47,54.34 83.79,54.65 84.31,54.65 84.64,54.32 84.64,53.56 84.85,53.35 85.77,53.35 86.01,53.59 86.01,54.31 86.34,54.63 86.8,54.63 87.12,54.32 87.12,52.65 86.77,52.31 86.57,52.31 86.38,52.11 86.38,51.81 86.55,51.63 86.85,51.63 87.16,51.32 87.16,51.02 87.43,50.75 87.65,50.75 87.91,50.49 87.91,48.97 88.08,48.8 88.71,48.8 88.94,49.03 88.94,50.4 89.26,50.72 89.79,50.72 90.11,50.4 90.11,48.88 90.25,48.74 90.53,48.74 90.67,48.88 90.67,50.29 90.99,50.61 91.52,50.61 91.84,50.29 91.84,48.75 91.98,48.62 92.18,48.62 92.41,48.85 92.41,49.68 92.8,50.06 93.67,50.06 94.24,50.63 94.39,50.63
  BOTTOM w0.145: v4(80.36,53.94) U64.B7
DDR4_C1_ODT: length 147.2
  TOP w0.152: U1.C8 v2(97.24,49.84)
  TOP w0.279: v1(65.81,104.01) 65.86,104.06 R569.2
  05_SIG2 w0.173: v4(73.16,93.83) 72.76,93.43 67.56,93.43
  05_SIG2 w0.292: 67.56,93.43 67.39,93.43 65.86,94.96 65.86,96.44 64.21,98.09 64.21,101.96 65.81,103.55 v1(65.81,104.01)
  18_SIG6 w0.089: 82.2,38.44 81.99,38.24 74.56,38.24 73.76,37.44 v4(73.16,37.44) 73.16,38.24 73.56,38.65 73.56,42.59 73.93,42.97 75.19,42.97 76.3,44.08 76.3,47.56 75.34,48.52 74.8,48.52 74.24,49.08 74.24,50.66 73.36,51.54 v4(73.16,51.54) 73.16,52.91 73.56,53.31 73.56,56.5 73.96,56.91 74.98,56.91 76.06,57.98 76.06,61.82 75.22,62.67 74.7,62.67 74.36,63.01 74.36,64.2 74.37,64.21 74.37,64.63 73.36,65.64 v4(73.16,65.64) 73.16,67.47 73.56,67.87 73.56,75.28 74.11,75.84 74.11,79.18 73.56,79.73 v4(73.16,79.73) 73.16,81.28 73.56,81.68 73.56,85.49 74.15,86.08 74.15,87.82 74.24,87.91 74.55,87.91 74.64,88 74.64,88.27 74.55,88.36 74.24,88.36 74.15,88.45 74.15,88.71 74.24,88.8 74.55,88.8 74.64,88.89 74.64,89.16 74.55,89.25 74.24,89.25 74.15,89.34 74.15,92.84 v4(73.16,93.83) ; 94.39,52.34 96.58,52.34 96.74,52.18 96.74,50.34 v2(97.24,49.84)
  18_SIG6 w0.157: 82.2,38.44 83,39.24 83,41.01 86.68,44.69 86.68,49.56 89.76,52.64 89.76,57.54 90.03,57.82 90.62,57.82 90.93,57.51 90.93,52.64 91.22,52.35 91.81,52.35 92.1,52.64 92.1,57.87 92.4,58.17 92.98,58.17 93.27,57.89 93.27,52.64 93.57,52.34 94.39,52.34
  BOTTOM w0.152: v4(73.16,37.44) U60.K3 ; v4(73.16,51.54) U64.K3 ; v4(73.16,65.64) U61.K3 ; v4(73.16,93.83) U62.K3 ; v4(73.16,79.73) U63.K3
DDR4_C1_PAR: length 159
  TOP w0.152: v2(101.24,51.84) U1.G10
  TOP w0.279: R568.2 85.67,104.01 v1(85.19,103.53)
  03_SIG1 w0.173: 76.24,99.36 75.73,99.36 75.16,98.8 75.16,95.4 73.56,93.8 73.56,93.66 73.32,93.43 72.99,93.43 72.76,93.2 72.76,92.86 72.52,92.63 72.19,92.63 71.96,92.4 71.96,92.06 71.72,91.83 71.39,91.83 71.16,91.59 71.16,91.26 70.92,91.03 68.99,91.03 68.76,91.26 68.76,91.6 68.52,91.83 68.19,91.83 67.96,92.06 67.96,93.43 v4(68.36,93.83)
  03_SIG1 w0.292: v1(85.19,103.53) 84.15,102.49 78.61,102.49 77.13,101.02 77.13,100.26 76.24,99.36
  16_SIG5 w0.089: v4(68.36,93.83) 67.62,93.09 67.62,91.11 67.78,90.96 68.12,90.96 68.37,90.71 68.37,90.43 68.21,90.27 67.87,90.27 67.62,90.02 67.62,80.47 v4(68.36,79.73) 67.92,79.3 67.92,76.37 67.62,76.06 67.62,75.67 67.92,75.36 67.92,66.07 v4(68.36,65.64) 67.81,65.64 65.65,63.48 65.65,61.55 65.91,61.3 65.91,60.09 65.58,59.76 65.58,59.09 66.01,58.65 66.01,53.41 67.38,52.04 67.86,52.04 v4(68.36,51.54) 67.4,50.59 67.18,50.59 65.58,48.98 65.58,44.2 66.41,43.37 66.41,41.98 65.86,41.44 65.86,39.94 v4(68.36,37.44)
  20_SIG7 w0.089: v2(101.24,51.84) 101.74,51.34 101.74,42.47
  20_SIG7 w0.157: v4(68.36,37.44) 67.46,37.44 66.53,36.51 66.53,32.94 69.62,29.85 96.37,29.85 99.42,32.91 99.42,33.56 100.7,34.84 100.7,40.34 101.74,41.37 101.74,42.47
  BOTTOM w0.152: U62.T3 v4(68.36,93.83) ; U63.T3 v4(68.36,79.73) ; U64.T3 v4(68.36,51.54) ; U60.T3 v4(68.36,37.44) ; U61.T3 v4(68.36,65.64)
DDR4_C1_REFIN: length 4.4
  TOP w0.152: U24.1 63.88,86.46 v1(64.42,85.92) 64.79,86.29 R299.2 R300.1
  BOTTOM w0.152: v1(64.42,85.92) 64.13,86.21 C451.1
DDR4_C1_RESET_B: length 165.2
  TOP w0.152: U1.N20 v2(107.24,61.84)
  TOP w0.279: R76.1 v1(81.86,103.84)
  03_SIG1 w0.173: 73.55,99.36 73.55,98.8 73.56,98.8 73.56,95.73 71.96,94.13 71.96,93.66 71.73,93.43 70.59,93.43 70.36,93.2 70.36,92.86 70.12,92.63 69.79,92.63 69.56,92.4 69.56,92.02 69.96,91.62 v4(69.96,91.43)
  03_SIG1 w0.292: v1(81.86,103.84) 81.2,104.5 78.68,104.5 76.58,102.4 75.64,102.4 74.08,100.84 74.08,100.15 73.55,99.62 73.55,99.36
  07_SIG3 w0.173: 101.61,42.08 101.74,42.21 101.74,44.05 102.03,44.34 102.44,44.34 102.74,44.64 102.74,45.05 103.03,45.34 103.44,45.34 103.74,45.64 103.74,46.05 104.03,46.34 104.44,46.34 104.74,46.64 104.74,47.05 105.03,47.34 105.44,47.34 105.74,47.64 105.74,48.05 106.03,48.34 106.44,48.34 106.74,48.64 106.74,49.05 107.03,49.34 107.44,49.34 107.74,49.64 107.74,50.05 108.03,50.34 108.44,50.34 108.74,50.64 108.74,51.05 109.03,51.34 109.44,51.34 109.74,51.64 109.74,52.05 110.03,52.34 110.44,52.34 110.74,52.64 110.74,53.05 111.03,53.34 111.44,53.34 111.74,53.64 111.74,54.05 112.03,54.34 112.44,54.34 112.74,54.64 112.74,60.05 112.44,60.34 112.03,60.34 111.74,60.64 111.74,61.05 111.44,61.34 111.03,61.34 110.74,61.64 110.74,62.05 110.44,62.34 107.74,62.34 v2(107.24,61.84)
  07_SIG3 w0.292: v4(69.96,35.04) 70.72,34.28 73.17,34.28 73.38,34.07 73.38,33.13 73.51,33.01 74.12,33.01 74.27,33.17 74.27,34.25 74.46,34.43 75.09,34.43 75.22,34.3 75.22,33.3 75.43,33.09 76.01,33.09 76.16,33.25 76.16,34.12 76.32,34.28 86.11,34.28 86.88,33.52 87.66,33.52 87.78,33.4 89.36,33.4 92.69,36.74 94.85,36.74 97.93,39.82 99.35,39.82 101.61,42.08
  18_SIG6 w0.089: v4(69.96,91.43) 69.96,89.87 69.56,89.48 69.56,88.43 69.47,88.34 69.29,88.34 69.2,88.25 69.2,87.98 69.29,87.9 69.47,87.9 69.56,87.81 69.56,87.54 69.47,87.45 69.29,87.45 69.2,87.36 69.2,87.1 69.29,87.01 69.47,87.01 69.56,86.92 69.56,78.77 69.79,78.53 70.12,78.53 70.36,78.3 70.36,77.97 69.96,77.57 v4(69.96,77.33) 69.96,76.63 69.56,76.23 69.56,64.67 69.79,64.44 70.12,64.44 70.36,64.2 70.36,63.63 v4(69.96,63.24) 70.65,62.55 70.65,60.77 70.13,60.26 70.13,59.7 69.56,59.13 69.56,53.23 69.39,53.06 68.52,53.06 68.35,52.89 68.35,52.54 68.52,52.37 69.39,52.37 69.56,52.2 69.56,50.57 69.79,50.34 70.12,50.34 70.36,50.1 70.36,49.77 69.96,49.37 v4(69.96,49.14) 69.96,48.46 67.93,46.43 67.93,43.11 68.13,42.91 68.36,42.91 68.53,43.07 69.18,43.07 69.56,42.69 69.56,39.27 69.43,39.15 69.18,39.15 69,38.97 69,38.63 69.18,38.46 69.43,38.46 69.56,38.33 69.56,36.48 69.79,36.24 70.12,36.24 70.36,36.01 70.36,35.44 v4(69.96,35.04)
  BOTTOM w0.152: U63.P1 v4(69.96,77.33) ; U64.P1 v4(69.96,49.14) ; U61.P1 v4(69.96,63.24) ; U62.P1 v4(69.96,91.43) ; U60.P1 v4(69.96,35.04)
DDR4_C1_TEN: length 146.1
  TOP w0.152: U1.A20 v2(95.24,61.84)
  TOP w0.279: R259.1 v1(70.43,103.77)
  05_SIG2 w0.173: v4(70.76,98.63) 70.02,99.36
  05_SIG2 w0.292: v1(70.43,103.77) 70.14,103.77 69.85,103.48 69.85,102.05 69.56,101.76 69.56,99.83 70.02,99.36
  14_SIG4 w0.089: 94.39,61.84 v2(95.24,61.84)
  14_SIG4 w0.157: 94.39,61.84 93.49,61.84 92.51,60.87 86.38,60.87 85.91,61.34 82.71,61.34 82.33,60.95 81.56,60.95 79.8,62.71 78.7,62.71 78.54,62.55 78.54,61.39 78.39,61.24 78.07,61.24 77.91,61.39 77.91,62.55 77.76,62.71 77.44,62.71 77.28,62.55 77.28,61.39 77.13,61.24 76.81,61.24 76.65,61.39 76.65,62.55 76.5,62.71 76.18,62.71 76.02,62.55 76.02,61.39 75.87,61.24 75.55,61.24 75.39,61.39 75.39,62.55 75.24,62.71 74.92,62.71 74.76,62.55 74.76,61.39 74.61,61.24 74.29,61.24 74.13,61.39 74.13,62.55 73.98,62.71 73.66,62.71 73.5,62.55 73.5,61.39 73.35,61.24 73.03,61.24 72.87,61.39 72.87,62.55 72.72,62.71 72.4,62.71 72.24,62.55 72.24,61.39 72.09,61.24 71.77,61.24 71.61,61.39 71.61,62.55 71.46,62.71 71.14,62.71 70.98,62.55 70.98,61.46 70.8,61.28 70.51,61.28 70.35,61.44 70.35,62.55 70.2,62.71 68.02,62.71 66.51,61.2 66.51,60.59 65.64,59.71 65.64,56.26 66.13,55.77 66.13,46.87 v4(70.76,42.24)
  20_SIG7 w0.089: v4(70.76,98.63) U62.N9 71.16,95.15 70.36,94.35 70.36,90.55 70.01,90.21 70.01,89.73 70.1,89.64 70.42,89.64 70.51,89.55 70.51,89.28 70.42,89.19 70.1,89.19 70.01,89.11 70.01,88.48 70.36,88.13 70.36,84.93 v4(70.76,84.53) 71.16,84.13 71.16,70.83 v4(70.76,70.44) U61.N9 71.16,67.55 69.56,65.95 69.56,62.44 70.76,61.24 70.76,60.78 70.58,60.61 69.71,60.61 69.54,60.44 69.54,60.09 69.71,59.92 70.58,59.92 70.76,59.75 v4(70.76,56.34) 71.16,55.94 71.16,53.37 69.56,51.77 69.56,50.52 69.37,50.34 68.12,50.34 67.62,49.84 67.62,46.17 70.76,43.04 v4(70.76,42.24)
  BOTTOM w0.152: U63.N9 v4(70.76,84.53) ; U62.N9 v4(70.76,98.63) ; U61.N9 v4(70.76,70.44) ; U60.N9 v4(70.76,42.24) ; U64.N9 v4(70.76,56.34)
DDR4_C1_VREFA: length 4.1
  TOP w0.254: R558.2 R559.1 C559.1 v4(71.56,35.04)
  BOTTOM w0.381: U60.M1 v4(71.56,35.04)
DDR4_C1_VREFB: length 4.1
  TOP w0.254: v4(71.56,63.24) C696.1 R707.1 R706.2
  BOTTOM w0.381: U61.M1 v4(71.56,63.24)
DDR4_C1_VREFC: length 3
  TOP w0.381: v4(71.56,91.43) 71.56,91.29 71.13,90.86 C699.1 R709.1 R708.2
  BOTTOM w0.381: U62.M1 v4(71.56,91.43)
DDR4_C1_VREFD: length 4.1
  TOP w0.254: v4(71.56,77.33) C954.1 R895.1 R894.2
  BOTTOM w0.381: U63.M1 v4(71.56,77.33)
DDR4_C1_VREFE: length 4.1
  TOP w0.254: v4(71.56,49.14) C557.1 R557.1 R556.2
  BOTTOM w0.381: U64.M1 v4(71.56,49.14)
DDR4_C1_VTERM_0V60_PGOOD: length 269.2
  TOP w0.14: Q17.1 v1(207.7,155.14)
  TOP w0.152: U24.9 60.22,87.53 v1(59.94,87.81) 59.54,87.81 59.41,87.68 R389.2
  03_SIG1 w0.173: v1(59.94,87.81) 59.97,87.83 59.97,88.98 62.08,91.08 62.08,95.4 63.54,96.87 63.54,125.79 61.78,127.55 61.78,132.82 60.9,133.7 60.9,137.14 59.97,138.08 59.97,139.21 60.38,139.62 60.38,145.55 59.75,146.18 58.61,146.18 54.04,150.75 54.04,155.4 v1(54.47,155.84)
  20_SIG7 w0.089: v1(207.7,155.14) 206.77,156.07 201.61,156.07 201.16,155.61 180.48,155.61 178.54,157.56 178.54,171.13 176.98,172.69 58.29,172.69 57.92,172.33 57.92,172 57.54,171.62 57.11,171.62 54.02,168.53 50.12,168.53 48.33,166.74 48.33,160.81 49.97,159.17 51.13,159.17 v1(54.47,155.84)
DDR4_C1_VTERM_EN: length 2
  TOP w0.152: R388.2 59.82,88.82 60.11,88.53 U24.7
DDR4_C1_VTERM_REFOUT: length 2.3
  TOP w0.152: C138.1 59.41,89.97 60.34,89.03 U24.6
DDR4_C1_VTT: length 23.3
  TOP w0.254: U24.3 64.38,88.03 64.77,88.43 v1(64.77,88.62) ; Z43.1 83.27,99.53 82.85,99.95 82.85,102.11
  TOP w0.381: 63.71,96.49 J65.1 ; J65.1 65.58,95.68 ; J65.1 63.71,94.88 ; J65.1 64.52,96.75 ; J65.1 63.45,95.68 ; J65.1 65.32,94.88 ; J65.1 65.32,96.49 ; J65.1 64.52,94.61 ; v1(64.19,91.03) 63.92,90.76 62.9,90.76 C517.1 62.9,91.65 v1(63.68,91.65) ; v1(63.68,93.8) 62.9,93.8 C516.1 62.9,92.91 v1(63.68,92.91)
  BOTTOM w0.381: v1(63.68,93.8) 62.9,93.8 C516.1 62.9,92.91 v1(63.68,92.91)
DDR4_C1_ZQA: length 1.4
  TOP w0.254: v4(77.16,42.24) 76.84,42.55 R386.1
  BOTTOM w0.152: U60.F9 v4(77.16,42.24)
DDR4_C1_ZQB: length 1.4
  TOP w0.254: R704.1 76.84,70.75 v4(77.16,70.44)
  BOTTOM w0.152: U61.F9 v4(77.16,70.44)
DDR4_C1_ZQC: length 1.4
  TOP w0.152: R705.1 76.84,98.94 v4(77.16,98.63)
  BOTTOM w0.152: U62.F9 v4(77.16,98.63)
DDR4_C1_ZQD: length 1.4
  TOP w0.254: v4(77.16,84.53) 76.84,84.84 R893.1
  BOTTOM w0.152: U63.F9 v4(77.16,84.53)
DDR4_C1_ZQE: length 1.4
  TOP w0.254: v4(77.16,56.34) 76.84,56.65 R385.1
  BOTTOM w0.152: U64.F9 v4(77.16,56.34)
DDR4_C2_A0: length 173.7
  TOP w0.152: U139.P3 v4(165.96,33.21) ; U137.P3 v4(165.96,75.75) ; U1.AM27 126.74,69.34 v2(127.24,69.84) ; U135.P3 v4(165.96,47.56) ; U136.P3 v4(165.96,61.66) ; U138.P3 v4(165.96,89.85)
  05_SIG2 w0.173: 142.66,51.16 141.49,52.34 141.03,52.34 140.74,52.64 140.74,53.05 140.44,53.34 140.03,53.34 139.74,53.64 139.74,54.05 139.44,54.34 139.03,54.34 138.74,54.64 138.74,55.05 138.44,55.34 138.03,55.34 137.74,55.64 137.74,56.05 137.44,56.34 137.03,56.34 136.74,56.64 136.74,57.05 136.44,57.34 136.03,57.34 135.74,57.64 135.74,58.05 135.44,58.34 135.03,58.34 134.74,58.64 134.74,59.05 134.44,59.34 134.03,59.34 133.74,59.64 133.74,60.05 133.44,60.34 133.03,60.34 132.74,60.64 132.74,61.05 132.44,61.34 132.03,61.34 131.74,61.64 131.74,62.05 131.44,62.34 131.03,62.34 130.74,62.64 130.74,63.05 130.44,63.34 130.03,63.34 129.74,63.64 129.74,64.05 129.44,64.34 129.03,64.34 128.74,64.64 128.74,65.05 127.78,66 127.37,66 126.74,66.64 126.74,69.08 127.24,69.58 v2(127.24,69.84) ; 165.55,30.14 165.08,30.14 164.76,30.45 164.76,31.86 164.91,32.01 165.4,32.01 165.56,32.16 U139.P3 v4(165.96,33.21)
  05_SIG2 w0.292: 165.55,30.14 166.23,30.14 168.16,28.2 168.16,25.38 167.44,24.66 167.14,24.66 166.93,24.87 166.93,27.68 166.67,27.94 166.31,27.94 166.05,27.68 166.05,24.87 165.76,24.58 162.22,24.58 160.15,26.66 159.13,26.66 157.91,27.87 156.84,27.87 155.99,27.02 154.85,27.02 154.28,27.58 153.27,27.58 153.02,27.33 153.02,27.15 152.86,26.99 152.54,26.99 152.39,27.15 152.39,27.33 152.23,27.48 151.91,27.48 151.76,27.33 151.76,27.15 151.6,26.99 151.28,26.99 151.13,27.15 151.13,27.33 150.95,27.5 148.33,27.5 147.99,27.84 146.84,27.84 145.73,28.95 145.45,28.95 144.31,30.08 144.31,30.67 143.02,31.97 143.02,33.31 142.55,33.77 142.55,39.62 143.99,41.06 143.99,49.84 142.66,51.16
  14_SIG4 w0.089: 165.75,95.39 165.56,95.19 165.56,90.25 v4(165.96,89.85) 165.56,89.45 165.56,85.97 165.27,85.68 165.27,84.25 165.56,83.96 165.56,76.16 v4(165.96,75.75) 165.56,75.35 165.56,72.58 165.33,72.35 165.33,67.31 165.56,67.08 165.56,62.06 v4(165.96,61.66) 165.56,61.26 165.56,56.61 165.68,56.49 165.68,54.12 165.56,54 165.56,47.96 v4(165.96,47.56) U135.P3 165.56,43.35 165.32,43.11 165.32,41.87 165.56,41.63 165.56,34.94 165.44,34.82 165.33,34.82 165.2,34.69 165.2,34.32 165.33,34.19 165.44,34.19 165.56,34.07 165.56,33.61 v4(165.96,33.21)
  14_SIG4 w0.157: v1(166.27,101.61) 166.27,99.62 167.06,98.84 167.06,97.81 166.53,97.28 166.53,96.16 165.75,95.39
  BOTTOM w0.279: R903.2 v1(166.27,101.61)
DDR4_C2_A1: length 177.6
  TOP w0.152: U136.P7 v4(165.96,64.06) ; U138.P7 v4(165.96,92.25) ; U139.P7 v4(165.96,35.61) ; v2(126.24,69.84) 125.74,69.34 U1.AL27 ; U137.P7 v4(165.96,78.15) ; U135.P7 v4(165.96,49.96)
  03_SIG1 w0.173: 133.56,42.27 133.74,42.45 133.74,48.13 133.53,48.34 132.94,48.34 132.74,48.54 132.74,59.05 132.44,59.34 132.03,59.34 131.74,59.64 131.74,60.05 131.44,60.34 131.03,60.34 130.74,60.64 130.74,61.05 130.44,61.34 130.03,61.34 129.74,61.64 129.74,62.05 129.44,62.34 129.03,62.34 128.74,62.64 128.74,63.05 128.44,63.34 128.03,63.34 127.74,63.64 127.74,65.05 127.44,65.34 127.03,65.34 125.74,66.64 125.74,69.34 v2(126.24,69.84)
  03_SIG1 w0.292: 133.56,42.27 133.46,42.18 133.46,28.92 136.88,25.51 142.77,25.51 143.76,26.5 144.29,26.5 144.73,26.06 145.31,26.06 145.85,25.53 145.85,24.94 147.87,22.92 151.26,22.92 151.98,22.2 158.15,22.2 158.72,22.78 159.84,22.78 160.22,23.16 166.24,23.16 168.03,24.95 168.03,33.53 v4(165.96,35.61)
  05_SIG2 w0.173: 166.73,95.39 166.36,95.02 166.36,92.65 v4(165.96,92.25) 166.36,91.85 166.36,84.18 166.16,83.98 166.16,81.02 166.36,80.82 166.36,78.55 v4(165.96,78.15) 166.36,77.75 166.36,71.89 166.54,71.72 166.54,70.45 166.15,70.07 166.15,68.45 166.36,68.25 166.36,64.46 v4(165.96,64.06) 166.36,63.66 166.36,57.74 166.58,57.52 166.58,55.89 166.17,55.48 166.17,53.33 166.36,53.15 166.36,50.36 v4(165.96,49.96) 166.36,49.56 166.36,44.6 166.51,44.45 166.61,44.45 166.77,44.3 166.77,44.08 166.61,43.93 166.51,43.93 166.36,43.78 166.36,43.56 166.51,43.41 166.61,43.41 166.77,43.26 166.77,43.04 166.61,42.89 166.51,42.89 166.36,42.74 166.36,42.53 166.51,42.37 166.61,42.37 166.77,42.22 166.77,42.01 166.61,41.86 166.51,41.86 166.36,41.71 166.36,41.47 166.09,41.21 166.09,41.06 165.94,40.91 165.69,40.91 165.54,40.76 165.54,40.54 165.69,40.39 165.94,40.39 166.09,40.24 166.09,39.47 166.36,39.21 166.36,36.24 165.96,35.84 v4(165.96,35.61)
  05_SIG2 w0.292: v1(164.11,104.96) 166.02,103.06 166.02,102.41 165.62,102.01 165.62,100.07 167.13,98.55 167.13,95.79 166.73,95.39
  BOTTOM w0.279: R904.2 v1(164.11,104.96)
DDR4_C2_A2: length 179.7
  TOP w0.152: U135.R3 v4(166.76,47.56) ; v2(129.24,68.84) 128.74,68.34 U1.AP26 ; U139.R3 v4(166.76,33.21) ; U137.R3 v4(166.76,75.75) ; U136.R3 v4(166.76,61.66) ; U138.R3 v4(166.76,89.85)
  03_SIG1 w0.173: 134.49,42.31 134.74,42.56 134.74,48.11 134.51,48.34 134.04,48.34 133.74,48.63 133.74,59.05 133.44,59.34 133.03,59.34 132.74,59.64 132.74,60.05 132.44,60.34 132.03,60.34 131.74,60.64 131.74,61.05 131.44,61.34 131.03,61.34 130.74,61.64 130.74,62.05 130.44,62.34 130.03,62.34 129.74,62.64 129.74,63.05 129.44,63.34 129.03,63.34 128.74,63.64 128.74,65.06 127.99,65.81 127.42,65.81 126.74,66.5 126.74,68.05 127.03,68.34 127.45,68.34 127.74,68.63 127.74,69.05 128.03,69.34 128.44,69.34 128.44,69.34 128.74,69.34 v2(129.24,68.84) ; 167.16,30.22 167.16,32.81 v4(166.76,33.21)
  03_SIG1 w0.292: 167.16,30.22 167.16,29.36 166.9,29.1 166.1,29.1 165.84,28.85 165.84,28.48 166.1,28.23 166.9,28.23 167.16,27.97 167.16,27.61 166.9,27.35 165.86,27.35 165.6,27.09 165.6,25.66 165.84,25.43 166.14,25.43 166.36,25.65 166.36,26.35 166.48,26.47 166.9,26.47 167.16,26.21 167.16,25.1 165.88,23.83 160.35,23.83 160.28,23.91 158.31,23.91 157.81,23.41 157.24,23.41 157.03,23.2 152.1,23.2 150.81,24.49 147.73,24.49 147.35,24.87 147.35,25.2 145.7,26.85 145.01,26.85 144.55,27.31 143.51,27.31 142.38,26.18 137.16,26.18 134.21,29.13 134.21,42.03 134.49,42.31
  14_SIG4 w0.089: 168.01,91.1 v4(166.76,89.85) 167.16,89.45 167.16,76.15 v4(166.76,75.75) 167.16,75.36 167.16,62.05 v4(166.76,61.66) 167.16,61.26 167.16,54.89 167.15,54.88 167.15,54.52 167.16,54.52 167.16,47.96 v4(166.76,47.56) 167.16,47.16 167.16,44.38 167.54,44 167.54,43.23 167.16,42.85 167.16,34.36 166.76,33.97 v4(166.76,33.21)
  14_SIG4 w0.157: 168.01,91.1 168.02,91.11 168.02,96.25 168.88,97.11 168.88,100.33 168.73,100.48 168.73,102.51 167.92,103.33 167.32,103.33 166.27,104.37 v1(166.27,104.96)
  BOTTOM w0.279: R919.2 v1(166.27,104.96)
DDR4_C2_A3: length 175.7
  TOP w0.152: U135.N7 v4(165.16,49.96) ; U138.N7 v4(165.16,92.25) ; U139.N7 v4(165.16,35.61) ; U1.AP25 128.74,67.34 v2(129.24,67.84) ; U137.N7 v4(165.16,78.15) ; U136.N7 v4(165.16,64.06)
  03_SIG1 w0.173: 136.22,42.22 136.74,42.74 136.74,48.06 136.45,48.34 136.04,48.34 135.74,48.64 135.74,59.05 135.44,59.34 135.03,59.34 134.74,59.64 134.74,60.05 134.44,60.34 134.03,60.34 133.74,60.64 133.74,61.05 133.44,61.34 133.03,61.34 132.74,61.64 132.74,62.05 132.44,62.34 132.03,62.34 131.74,62.64 131.74,63.05 131.44,63.34 131.03,63.34 130.74,63.64 130.74,65.05 129.51,66.27 129.1,66.27 128.74,66.64 128.74,67.34 v2(129.24,67.84) ; 164.63,30.13 165.17,30.13 165.56,30.52 165.56,34.56 165.16,34.96 v4(165.16,35.61)
  03_SIG1 w0.292: 136.22,42.22 135.7,41.71 135.7,33.77 136.19,33.28 136.19,32.57 135.88,32.26 135.88,31.85 136.11,31.62 136.52,31.62 137.22,32.32 141.34,32.32 141.63,32.03 141.63,31.74 141.39,31.5 137.36,31.5 137.08,31.22 137.08,28.82 137.38,28.53 137.79,28.53 137.98,28.73 137.98,30 138.24,30.26 138.72,30.26 139.23,30.77 141.67,30.77 142.06,31.15 142.71,31.15 143.01,30.85 143.01,30.05 142.64,29.68 142.64,29.14 143.02,28.76 144.73,28.76 145.04,29.07 145.78,29.07 147.26,27.58 148.71,27.58 149.01,27.28 149.01,26.83 149.31,26.53 149.71,26.53 149.89,26.71 149.89,27.38 150.1,27.59 150.58,27.59 150.82,27.35 150.82,26.82 151.12,26.53 152.04,26.53 152.96,25.61 153.28,25.61 153.52,25.37 158.84,25.37 160.5,27.03 163.27,27.03 163.68,27.44 163.68,29.18 164.63,30.13
  05_SIG2 w0.173: v4(165.16,35.61) 164.88,35.61 164.76,35.73 164.76,39.84 164.52,40.07 164.52,40.49 164.8,40.77 164.8,41.12 164.49,41.44 164.49,41.69 164.76,41.96 164.76,42.21 164.49,42.48 164.49,42.72 164.76,42.99 164.76,43.49 164.7,43.56 164.37,43.56 164.25,43.68 164.25,43.85 164.34,43.94 164.78,43.94 164.87,44.03 164.87,44.24 164.78,44.33 164.42,44.33 164.31,44.43 164.31,44.62 164.41,44.71 164.68,44.71 164.76,44.79 164.76,49.56 v4(165.16,49.96) 164.63,50.48 164.63,56.1 164.76,56.22 164.76,63.66 v4(165.16,64.06) 164.49,64.72 164.49,72.71 164.76,72.98 164.76,77.75 v4(165.16,78.15) 164.76,78.55 164.76,91.85 v4(165.16,92.25) 164.74,92.67 164.74,94.89 165.03,95.17 165.03,95.39
  05_SIG2 w0.292: 165.03,95.39 165.03,96.49 163.1,98.42 163.1,100.49 v1(162.46,101.12)
  BOTTOM w0.279: R918.2 v1(162.46,101.12)
DDR4_C2_A4: length 182.2
  TOP w0.152: v2(128.24,70.84) 127.74,70.34 U1.AN28 ; U139.N3 v4(165.16,33.21) ; U137.N3 v4(165.16,75.75) ; U135.N3 v4(165.16,47.56) ; U138.N3 v4(165.16,89.85) ; U136.N3 v4(165.16,61.66)
  05_SIG2 w0.173: 163.96,29.88 163.96,30.64 163.96,32.69 164.07,32.81 164.76,32.81 v4(165.16,33.21) ; v2(128.24,70.84) 128.74,70.34 128.74,68.64 128.44,68.34 128.03,68.34 127.74,68.05 127.74,66.64 128.79,65.58 129.21,65.58 129.74,65.05 129.74,64.64 130.03,64.34 130.44,64.34 130.74,64.05 130.74,63.64 131.03,63.34 131.44,63.34 131.74,63.05 131.74,62.64 132.03,62.34 132.44,62.34 132.74,62.05 132.74,61.64 133.03,61.34 133.44,61.34 133.74,61.05 133.74,60.64 134.03,60.34 134.44,60.34 134.74,60.05 134.74,59.64 135.03,59.34 135.44,59.34 135.74,59.05 135.74,58.64 136.03,58.34 136.44,58.34 136.74,58.05 136.74,57.64 137.03,57.34 137.44,57.34 137.74,57.05 137.74,56.64 138.03,56.34 138.44,56.34 138.74,56.05 138.74,55.64 139.03,55.34 139.44,55.34 139.74,55.05 139.74,54.64 140.03,54.34 140.44,54.34 140.74,54.05 140.74,53.64 141.03,53.34 141.53,53.34 142.63,52.24
  05_SIG2 w0.292: 142.63,52.24 144.67,50.2 144.67,40.75 143.4,39.49 143.4,34.31 144.73,32.98 144.73,31.45 146.37,29.81 146.37,29.34 147.06,28.65 147.33,28.65 147.6,28.92 147.6,29.29 147.72,29.41 148.07,29.41 148.23,29.25 148.23,28.74 148.4,28.57 148.72,28.57 148.86,28.71 148.86,29.35 149,29.48 149.31,29.48 149.49,29.3 149.49,28.5 149.67,28.32 149.95,28.32 150.12,28.49 150.12,29.34 150.27,29.48 150.57,29.48 150.75,29.3 150.75,28.56 150.93,28.37 151.21,28.37 151.38,28.55 151.38,29.35 151.52,29.48 151.83,29.48 152.01,29.3 152.01,28.67 152.19,28.49 152.5,28.49 152.64,28.63 152.64,28.89 152.8,29.05 153.11,29.05 153.27,28.89 153.27,28.43 153.38,28.32 154.15,28.32 154.47,28.64 158.08,28.64 158.27,28.84 158.99,28.84 162.58,25.25 162.88,25.25 163.14,25.51 163.14,26.37 163.38,26.61 163.74,26.61 164.01,26.34 164.01,25.51 164.27,25.25 165,25.25 165.38,25.63 165.38,27.01 165.08,27.31 164.03,27.31 163.67,27.67 163.67,28.32 163.86,28.52 165.92,28.52 166.13,28.72 166.13,29.27 165.96,29.43 164.41,29.43 163.96,29.88
  07_SIG3 w0.173: v4(165.16,33.21) 164.76,33.61 164.76,36.57 164.99,36.81 165.32,36.81 165.56,37.04 165.56,38.38 164.61,39.33 164.61,39.6 164.76,39.75 164.76,40.16 164.46,40.46 164.46,40.68 164.76,40.98 164.76,41.2 164.46,41.5 164.46,41.71 164.76,42.02 164.76,42.23 164.46,42.53 164.46,42.75 164.76,43.05 164.76,43.88 164.61,44.03 164.48,44.03 164.33,44.18 164.33,44.39 164.48,44.55 164.61,44.55 164.76,44.7 U135.N3 v4(165.16,47.56) 164.74,47.97 164.74,53.96 164.68,54.02 164.68,56.13 164.76,56.21 164.76,61.26 v4(165.16,61.66) 165.16,62.15 164.76,62.55 U137.N3 v4(165.16,75.75) 164.76,76.15 164.76,89.22 165.16,89.62 v4(165.16,89.85)
  14_SIG4 w0.089: 164.75,95.39 164.75,91.41 165.16,91.01 v4(165.16,89.85)
  14_SIG4 w0.157: v1(160.55,104.96) 161.27,105.68 161.88,105.68 162.3,105.26 162.3,105.25 164.37,103.18 164.37,96.17 164.75,95.78 164.75,95.39
  BOTTOM w0.279: R916.2 160.3,104.72 v1(160.55,104.96)
DDR4_C2_A5: length 176.1
  TOP w0.152: U138.P8 v4(165.96,93.85) ; U139.P8 v4(165.96,37.21) ; U1.AM28 126.74,70.34 v2(127.24,70.84) ; U135.P8 v4(165.96,51.56) ; U136.P8 v4(165.96,65.66) ; U137.P8 v4(165.96,79.75)
  03_SIG1 w0.173: v4(165.96,37.21) 165.56,37.61 165.56,38.61 165.73,38.79 166.03,38.79 166.2,38.96 166.2,39.13 166.35,39.28 166.54,39.28 166.69,39.43 166.69,39.65 166.54,39.8 166.35,39.8 166.2,39.95 166.2,41.84 166.35,41.99 166.62,41.99 166.77,42.14 166.77,42.36 166.62,42.51 166.42,42.51 166.27,42.66 166.27,42.87 166.42,43.03 166.59,43.03 166.74,43.18 166.74,43.39 166.59,43.54 166.35,43.54 166.2,43.7 166.2,44.08 165.56,44.73 165.56,51.16 v4(165.96,51.56) 165.56,51.96 165.56,52.97 165.72,53.14 165.72,56.45 165.56,56.61 U136.P8 v4(165.96,65.66) 165.56,66.06 165.56,67.28 165.35,67.49 165.35,72.28 165.56,72.49 U137.P8 v4(165.96,79.75) 165.56,80.15 165.56,83.74 165.26,84.04 165.26,86.38 165.56,86.68 U138.P8 v4(165.96,93.85) 166.36,94.25 166.36,95.39
  03_SIG1 w0.292: v1(165.38,104.96) 164.74,104.32 164.74,102.21 164.33,101.81 164.33,98.57 166.36,96.54 166.36,95.39
  07_SIG3 w0.173: v2(127.24,70.84) 127.74,70.34 127.74,69.53 127.93,69.33 128.5,69.33 128.71,69.13 128.71,68.55 128.93,68.32 129.55,68.32 129.74,68.14 129.74,67.56 129.91,67.38 130.51,67.38 130.73,67.16 130.73,66.74 131.24,66.23 131.3,66.23 132.11,65.42 132.29,65.42 132.73,64.99 132.73,52.58 132.94,52.37 133.51,52.37 133.71,52.18 133.71,51.64 133.97,51.38 134.48,51.38 134.7,51.16 134.7,50.51 134.88,50.34 135.41,50.34 135.71,50.04 135.71,49.52 135.86,49.37 136.45,49.37 136.73,49.1 136.73,48.49 136.89,48.33 137.47,48.33 137.73,48.06 137.73,47.61 137.95,47.39 138.52,47.39 138.8,47.11 138.8,44.65 139.11,44.34 139.58,44.34 139.76,44.16 139.76,43.06 139.85,42.98 139.85,42.37 ; 166.36,30.45 166.36,30.97 166.12,31.21 165.79,31.21 165.56,31.44 165.56,36.58 165.96,36.98 v4(165.96,37.21)
  07_SIG3 w0.292: 166.36,30.45 166.36,27.76 165.63,27.03 163.63,27.03 163.24,27.42 161.71,27.42 161.55,27.58 161.55,27.95 161.34,28.15 161.03,28.15 160.87,28 160.87,27.58 160.71,27.42 160.4,27.42 160.24,27.58 160.24,28 160.08,28.15 159.77,28.15 159.61,28 159.61,27.58 159.45,27.42 158.1,27.42 157.7,27.81 156.59,27.81 156.11,27.33 154.49,27.33 153.63,28.19 151.42,28.19 151.04,27.81 150.8,27.81 150.57,28.03 150.57,28.24 151,28.67 151,28.88 149.94,29.95 147.65,29.95 147.47,29.76 147.15,29.76 146.97,29.94 146.97,30.92 146.07,31.82 146.07,33.69 144.85,34.91 144.48,34.91 143.71,34.14 143.35,34.14 143.09,34.4 143.09,34.76 143.86,35.53 143.86,35.89 143.61,36.15 143.24,36.15 142.47,35.38 142.11,35.38 141.86,35.64 141.86,36 142.62,36.77 142.62,37.13 142.37,37.39 142,37.39 141.24,36.62 140.87,36.62 140.62,36.88 140.62,37.24 141.38,38.01 141.38,38.37 141.13,38.63 140.76,38.63 140,37.86 139.63,37.86 139.38,38.12 139.38,38.48 140.14,39.25 140.14,39.61 139.85,39.91 139.85,42.37
  BOTTOM w0.279: R917.2 v1(165.38,104.96)
DDR4_C2_A6: length 194.1
  TOP w0.152: U135.P2 v4(165.96,45.96) ; v2(129.24,70.84) 128.74,70.34 U1.AP28 ; U137.P2 v4(165.96,74.15) ; U136.P2 v4(165.96,60.06) ; U139.P2 v4(165.96,31.61) ; U138.P2 v4(165.96,88.25)
  05_SIG2 w0.173: 153.97,33.23 154.38,32.81 160.6,32.81 160.76,32.96 160.76,33.76 160.91,33.91 161.15,33.91 161.4,33.66 162.01,33.66 162.27,33.91 162.87,33.91 163.13,33.66 163.74,33.66 163.99,33.91 164.6,33.91 164.86,33.66 165.47,33.66 165.72,33.91 166.19,33.91 166.36,33.74 166.36,32.24 165.96,31.84 v4(165.96,31.61) ; v2(129.24,70.84) 129.24,70.56 129.74,70.06 129.74,66.64 130.61,65.76 131.03,65.76 131.74,65.05 131.74,64.64 132.03,64.34 132.44,64.34 132.74,64.05 132.74,63.64 133.03,63.34 133.44,63.34 133.74,63.05 133.74,62.64 134.03,62.34 134.44,62.34 134.74,62.05 134.74,61.64 135.03,61.34 135.44,61.34 135.74,61.05 135.74,60.64 136.03,60.34 136.44,60.34 136.74,60.05 136.74,59.64 137.03,59.34 137.44,59.34 137.74,59.05 137.74,58.64 138.03,58.34 138.44,58.34 138.74,58.05 138.74,57.64 139.03,57.34 139.44,57.34 139.74,57.05 139.74,56.64 140.03,56.34 140.44,56.34 140.74,56.05 140.74,55.64 141.03,55.34 141.69,55.34 142.63,54.41
  05_SIG2 w0.292: 153.97,33.23 153.86,33.34 153.47,33.34 153.21,33.08 153.21,32.77 152.95,32.52 152.59,32.52 152.33,32.77 152.33,33.08 152.08,33.34 151.71,33.34 151.45,33.08 151.45,32.08 151.19,31.83 150.76,31.83 150.5,32.09 150.5,33.54 150.22,33.81 149.9,33.81 149.64,33.55 149.64,32.01 149.41,31.78 149.08,31.78 148.78,32.08 148.78,33.17 148.53,33.42 147.34,33.42 147.09,33.17 147.09,32.69 147.27,32.51 147.42,32.51 147.6,32.33 147.6,31.6 147.24,31.24 146.84,31.24 146.24,31.84 146.24,33.79 146.08,33.96 146.08,34.18 146.34,34.44 146.34,34.64 146.12,34.86 145.87,34.86 145.63,34.62 145.41,34.62 145.11,34.92 145.11,35.26 146.85,37 146.85,37.21 146.68,37.37 146.44,37.37 145.35,36.28 145.02,36.28 144.8,36.49 144.8,38.82 146.28,40.3 146.28,41.66 146.41,41.78 146.79,41.78 146.95,41.94 146.95,42.19 146.79,42.35 146.18,42.35 146.02,42.51 146.02,42.82 146.18,42.98 146.81,42.98 146.97,43.14 146.97,43.45 146.81,43.61 146.18,43.61 146.02,43.77 146.02,44.08 146.18,44.24 146.81,44.24 146.97,44.4 146.97,44.71 146.81,44.87 146.18,44.87 146.02,45.03 146.02,45.34 146.18,45.5 146.81,45.5 146.97,45.66 146.97,45.97 146.81,46.13 146.18,46.13 146.02,46.29 146.02,46.6 146.18,46.76 146.81,46.76 146.97,46.92 146.97,47.23 146.81,47.39 146.18,47.39 146.02,47.55 146.02,47.86 146.18,48.02 146.81,48.02 146.97,48.18 146.97,48.49 146.81,48.65 146.18,48.65 146.02,48.81 146.02,49.12 146.18,49.28 146.81,49.28 146.97,49.44 146.97,49.75 146.81,49.91 146.18,49.91 146.02,50.07 146.02,50.38 146.28,50.64 146.28,51 146.11,51.17 145.86,51.17 142.63,54.41
  14_SIG4 w0.089: 166.78,95.39 166.36,94.96 166.36,88.65 v4(165.96,88.25) 166.36,87.85 166.36,83.91 166.25,83.8 166.25,81.5 166.36,81.39 166.36,74.55 v4(165.96,74.15) 166.36,73.76 166.36,69.86 166.03,69.54 166.03,67.68 166.36,67.35 166.36,60.45 v4(165.96,60.06) 166.36,59.66 166.36,58.44 166.53,58.26 166.53,55.67 166.25,55.38 166.25,53.81 166.36,53.7 166.36,46.36 v4(165.96,45.96) 166.36,45.56 166.36,41.57 166.17,41.38 166.17,40.4 166.36,40.21 166.36,33.57 166.35,33.37 166.36,33.37 166.36,32.22 165.96,31.82 v4(165.96,31.61)
  14_SIG4 w0.157: v1(158.85,101.11) 158.85,102.69 158.26,103.28 158.26,105.74 158.93,106.41 163.6,106.41 164.74,105.26 164.74,104.44 166.54,102.64 166.88,102.64 167.67,101.85 167.67,99.49 167.77,99.39 167.77,97.35 167.27,96.85 167.27,95.87 166.78,95.39
  BOTTOM w0.279: R906.2 158.85,100.7 v1(158.85,101.11)
DDR4_C2_A7: length 174
  TOP w0.152: U1.AP27 128.74,69.34 v2(129.24,69.84) ; U136.R8 v4(166.76,65.66) ; U137.R8 v4(166.76,79.75) ; U135.R8 v4(166.76,51.56) ; U139.R8 v4(166.76,37.21) ; U138.R8 v4(166.76,93.85)
  03_SIG1 w0.173: v4(166.76,37.21) 166.36,36.81 164.99,36.81 164.76,36.57 164.76,31.44 164.52,31.21 164.19,31.21 163.96,30.97 163.96,30.6 163.65,30.3 ; 136.9,41.82 137.74,42.66 137.74,48.06 137.45,48.34 137.03,48.34 136.74,48.63 136.74,59.05 136.44,59.34 136.03,59.34 135.74,59.64 135.74,60.05 135.44,60.34 135.03,60.34 134.74,60.64 134.74,61.05 134.44,61.34 134.03,61.34 133.74,61.64 133.74,62.05 133.44,62.34 133.03,62.34 132.74,62.64 132.74,63.05 132.44,63.34 132.03,63.34 131.74,63.64 131.74,65.05 131.04,65.75 130.62,65.75 129.74,66.64 129.74,69.34 v2(129.24,69.84)
  03_SIG1 w0.292: 163.65,30.3 162.91,29.56 162.91,28.09 162.63,27.81 162.23,27.81 162.07,27.96 162.07,28.61 161.92,28.77 161.51,28.77 161.35,28.61 161.35,27.9 161.19,27.74 160.85,27.74 160.69,27.9 160.69,28.61 160.53,28.77 160.12,28.77 159.96,28.61 159.96,27.63 158.46,26.14 157.88,26.14 157.38,26.64 156.73,26.64 156.16,26.07 155.67,26.07 155.43,26.31 155.43,26.57 155.24,26.76 154.71,26.76 154.48,26.54 154.48,26.29 154.27,26.07 153.97,26.07 153.7,26.35 153.32,26.35 151.32,28.35 147.49,28.35 146,29.84 146,31.53 145.76,31.76 145.4,31.76 145.18,31.54 145.18,30.63 144.94,30.4 144.55,30.4 144.26,30.69 144.26,31.07 143.96,31.36 143.5,31.36 143.18,31.68 143.18,32.09 143.31,32.21 144.58,32.21 144.86,32.49 144.86,32.94 144.39,33.41 142.08,33.41 141.68,33.02 137.54,33.02 136.43,34.12 136.43,37.27 136.68,37.51 137.16,37.51 137.45,37.22 137.45,36.78 137.74,36.49 138.16,36.49 138.4,36.73 138.4,38.08 138.16,38.31 136.79,38.31 136.43,38.67 136.43,41.35 136.9,41.82
  07_SIG3 w0.173: 166.36,95.39 166.36,94.25 v4(166.76,93.85) U138.R8 166.36,83.47 166.09,83.2 166.09,82.64 166.36,82.37 166.36,80.15 v4(166.76,79.75) U137.R8 166.36,69.76 166.15,69.55 166.15,68.44 166.36,68.23 166.36,66.06 v4(166.76,65.66) U136.R8 166.36,58.88 166.65,58.59 166.65,56.34 166.19,55.89 166.19,53.22 166.36,53.06 166.36,51.96 v4(166.76,51.56) 166.36,51.16 166.36,44.67 166.21,44.52 166.08,44.52 165.93,44.37 165.93,44.15 166.08,44 166.21,44 166.36,43.85 166.36,43.31 166.51,43.16 166.59,43.16 166.74,43.01 166.74,42.79 166.59,42.64 166.51,42.64 166.36,42.49 166.36,42.27 166.51,42.12 166.59,42.12 166.74,41.97 166.74,41.75 166.59,41.6 166.51,41.6 166.36,41.45 166.36,41.1 166.04,40.78 166.04,40.35 167.16,39.23 167.16,37.61 v4(166.76,37.21)
  07_SIG3 w0.292: v1(163.73,101.15) 163.73,100.05 164.36,99.41 164.36,98.57 166.36,96.58 166.36,95.39
  BOTTOM w0.279: R905.2 v1(163.73,101.15)
DDR4_C2_A8: length 184
  TOP w0.152: U138.R2 v4(166.76,88.25) ; U1.AN26 127.74,68.34 v2(128.24,68.84) ; U135.R2 v4(166.76,45.96) ; U136.R2 v4(166.76,60.06) ; U139.R2 v4(166.76,31.61) ; U137.R2 v4(166.76,74.15)
  03_SIG1 w0.173: v2(128.24,68.84) 128.24,68.61 127.74,68.11 127.74,66.64 128.64,65.74 129.05,65.74 129.74,65.05 129.74,63.64 130.03,63.34 130.44,63.34 130.74,63.05 130.74,62.64 131.03,62.34 131.44,62.34 131.74,62.05 131.74,61.64 132.03,61.34 132.44,61.34 132.74,61.05 132.74,60.64 133.03,60.34 133.44,60.34 133.74,60.05 133.74,59.64 134.03,59.34 134.44,59.34 134.74,59.05 134.74,48.6 135,48.34 135.53,48.34 135.74,48.13 135.74,42.72 135.17,42.15 ; 166.12,30.08 166.36,30.33 166.36,30.97 166.76,31.37 v4(166.76,31.61)
  03_SIG1 w0.292: 135.17,42.15 134.89,41.87 134.89,31.42 135.16,31.15 135.61,31.15 135.96,30.8 135.96,28.68 136.87,27.76 138.48,27.76 138.9,28.18 138.9,29.32 139.63,30.05 141.53,30.05 141.77,29.81 141.77,28.39 142.07,28.09 144.81,28.09 145.16,27.74 146.1,27.74 146.94,26.9 147.92,26.9 148.36,26.46 148.36,25.7 148.7,25.36 151.51,25.36 152.67,24.2 157.1,24.2 157.5,24.6 160.61,24.6 160.7,24.51 164.81,24.51 165.13,24.83 165.13,25.13 164.83,25.42 160.9,25.42 160.61,25.71 160.61,26.08 160.77,26.23 164.49,26.23 164.81,26.56 164.81,28.78 166.12,30.08
  07_SIG3 w0.173: v4(166.76,31.61) 167.16,32.01 167.16,33.86 168.03,34.73 168.03,39.57 167.28,40.31 167.28,40.82 167.16,40.94 167.16,42.77 167.31,42.93 167.56,42.93 167.71,43.08 167.71,43.29 167.56,43.44 167.31,43.44 167.16,43.6 167.16,43.81 167.31,43.96 167.56,43.96 167.71,44.11 167.71,44.33 167.56,44.48 167.31,44.48 167.16,44.63 167.16,45.56 v4(166.76,45.96) 167.16,46.36 167.16,52.52 167.15,52.54 167.15,55.5 167.16,55.51 167.16,59.66 v4(166.76,60.06) 167.16,60.46 167.16,68.28 167.28,68.4 167.28,69.62 167.16,69.75 167.16,73.75 v4(166.76,74.15) 167.16,74.55 167.16,82.57 167.28,82.69 167.28,83.17 167.16,83.29 167.16,87.85 v4(166.76,88.25) 167.16,88.65 167.16,95.39
  07_SIG3 w0.292: v1(159.82,101.1) 159.82,102.54 160.4,103.12 163.32,103.12 164.41,102.03 164.41,100.99 165.9,99.51 166.39,99.51 167.16,98.74 167.16,95.39
  BOTTOM w0.279: R910.2 159.82,100.61 v1(159.82,101.1)
