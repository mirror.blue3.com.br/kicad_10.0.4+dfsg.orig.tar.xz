# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on 13_GND, 15_GND, 17_GND, 19_GND: 240.66,175.31 240.66,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31
GND on 14_SIG4: 240.66,175.31 240.66,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31 ; 40 cut-outs
GND on 16_SIG5: 240.66,175.31 240.66,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31 ; 40 cut-outs
GND on 18_SIG6: 240.66,175.31 240.66,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31 ; 59 cut-outs
GND on 20_SIG7: 240.66,175.31 240.66,13.36 14.38,13.36 14.38,5.11 0.64,5.11 0.64,175.31 ; 59 cut-outs
GND on 21_GND: outline of 120 points within 0.64,5.11 240.66,175.31
VCC1V2 on TOP (solid shape): 226.67,59.92 226.67,57.68 226.89,57.45 227.66,57.45 228,57.12 228,55.46 227.13,54.58 221.98,54.58 221.55,55.02 217.78,55.02 217.78,55.85 220.73,55.85 220.73,55.8 220.74,55.74 220.76,55.69 220.79,55.64 220.82,55.6 220.86,55.56 220.91,55.53 220.96,55.5 221.01,55.49 221.07,55.48 221.12,55.47 221.18,55.48 221.23,55.49 221.28,55.52 221.33,55.54 221.37,55.58 221.41,55.62 221.44,55.67 221.46,55.72 221.48,55.77 221.49,55.83 221.49,55.88 221.48,55.94 221.46,55.99 221.44,56.04 221.41,56.09 221.37,56.13 221.33,56.16 221.28,56.19 221.23,56.22 221.18,56.23 221.12,56.24 221.07,56.23 221.01,56.22 220.96,56.21 220.91,56.18 220.86,56.15 220.82,56.11 220.79,56.07 220.76,56.02 220.74,55.96 220.73,55.91 220.73,55.85 217.78,55.85 217.78,60.35 218.22,60.79 225.79,60.79
VCC1V2_FET_SWITCH on TOP (solid shape): 230.16,46.43 227.43,46.43 227.36,46.5 227.36,49.33 223.39,49.33 223.16,49.56 223.16,52.3 223.5,52.63 230.16,52.63
VCC1V2_FET_SWITCH on BOTTOM (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FET_SWITCH on 03_SIG1 (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FET_SWITCH on 05_SIG2 (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FET_SWITCH on 07_SIG3 (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FET_SWITCH on 14_SIG4 (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FET_SWITCH on 16_SIG5 (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FET_SWITCH on 18_SIG6 (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FET_SWITCH on 20_SIG7 (solid shape): 230.16,46.43 227.36,46.43 227.36,49.33 223.32,49.33 223.14,49.5 223.14,50.78 222.72,51.21 222.72,52.63 230.16,52.63
VCC1V2_FPGA on TOP (solid shape): outline of 96 points within 227.46,51.97 234.27,60.9
VCC1V2_FPGA on BOTTOM (solid shape): 64.35,85.54 64.42,85.53 64.49,85.54 64.86,85.54 65.02,85.39 65.02,82.02 64.84,81.84 61.11,81.84 61.11,83.53 63.53,83.53 64.12,84.12 64.12,85.33 64.33,85.54
VCC1V2_FPGA on BOTTOM (solid shape): 146.81,110.67 146.81,110.07 146.62,109.65 146.81,109.22 146.81,109.04 146.76,108.99 146.08,108.99 145.85,108.76 145.85,106.83 145.95,106.73 145.95,106.18 145.87,106.1 145.53,106.1 145,106.63 144.86,106.63 144.76,106.65 144.68,106.65 144.65,106.65 144.49,106.81 144.49,110.39 145.15,111.05 146.43,111.05
VCC1V2_FPGA on BOTTOM (solid shape): 233.91,59.1 233.91,53.95 233.81,53.85 233.69,53.83 233.63,53.93 232.13,54.89 232.15,53.1 232.2,52.99 232.11,52.91 230.96,52.91 228.93,54.94 228.89,54.94 228.89,57.52 227.46,58.95 227.46,59.87 228.51,60.92 232.09,60.92
VCC1V2_FPGA on BOTTOM: 168.22,37.3 168.22,35.69 168.25,35.66 170.46,35.66 170.74,35.95 170.74,37.68 170.45,37.97 170.24,37.97 170.09,37.82 170.09,37.56 169.86,37.33 168.25,37.33
VCC1V2_FPGA on 05_SIG2: 102.08,73.33 104.57,73.33 104.89,73.01 104.89,71.7 105.09,71.5 108.67,71.5 109.21,70.96 109.21,69.86 109.18,69.83 111.37,67.65 111.37,63.53 110.47,62.64 105.69,62.64 104.51,61.46 104.51,60.71 105.11,60.11 111.76,60.11 112.77,59.1 112.77,54.51 111.47,53.2 101.06,53.2 100.73,53.53 100.73,70.63 101.72,71.62 101.72,72.97
VCC1V2_FPGA on 12_PWR3: 240.03,174.65 240.03,39.78 185.24,39.78 185.24,30.48 180.06,25.3 165.3,25.3 161.16,29.44 150.14,29.44 149.12,30.45 149.12,32.08 153.59,36.55 153.59,58.83 144.88,67.54 132.03,67.54 130.94,68.63 130.94,79.3 135.03,83.39 141.58,83.39 142.54,84.35 142.54,91.11 129.57,104.09 95.4,104.09 92.28,100.96 92.28,83.77 93.45,82.6 102.16,82.6 104.52,80.24 104.52,51.97 102.44,49.89 99.21,49.89 97.64,48.31 85.85,48.31 82.7,45.16 82.7,34.7 82.37,34.37 66.93,34.37 64.31,36.98 64.31,37.03 62.72,38.63 62.72,48.66 64.31,50.25 64.31,66.32 63.02,67.61 56.58,67.61 55.98,68.22 55.98,126.6 51.84,130.73 51.84,134.62 55.04,137.82 56.64,137.82 57.86,136.6 60.27,136.6 60.76,137.08 60.76,174.65
VCC1V2_FPGA on 14_SIG4: 70.97,118.26 70.97,114.22 63.98,107.24 63.98,102.23 61.75,100 43.89,100 42.8,101.09 42.8,106.78 43.66,107.64 49.61,107.64 53.7,111.72 53.7,114.96 57.68,118.95 57.68,120.8 62.33,125.45 72.85,125.45 74.14,124.16 74.14,121.44
VCC1V2_FPGA on 20_SIG7: 154.69,58.29 160.12,58.29 162.05,56.36 172.29,56.36 176.86,60.93 176.86,68.83 170.59,75.11 169.67,75.11 167.87,76.91 153.92,76.91 152.22,75.21 152.22,63.3 154.03,61.49 154.03,58.95
VCC1V8 on TOP (solid shape): 21.36,86.71 18.45,86.71 18.42,86.76 18.42,92.96 21.36,92.96
VCC1V8 on TOP (solid shape): 152.27,120.7 151.76,120.19 151.76,116.86 151.64,116.74 150.37,116.74 147.1,120.01 147.1,120.39 147.12,120.4 147.16,120.44 147.19,120.48 147.22,120.53 147.24,120.58 147.25,120.64 147.25,120.69 147.25,120.75 147.24,120.8 147.22,120.85 147.19,120.9 147.16,120.95 147.12,120.98 147.1,121 147.1,122.87 151.01,122.87 151.02,122.82 151.03,122.76 151.05,122.71 151.08,122.66 151.11,122.62 151.15,122.58 151.2,122.55 151.25,122.52 151.3,122.5 151.35,122.49 151.41,122.49 151.46,122.5 151.52,122.51 151.57,122.53 151.62,122.56 151.66,122.6 151.7,122.64 151.73,122.68 151.75,122.73 151.77,122.79 151.77,122.84 151.77,122.9 151.77,122.95 151.75,123.01 151.73,123.06 151.7,123.1 151.66,123.15 151.62,123.18 151.57,123.21 151.52,123.23 151.46,123.25 151.41,123.25 151.35,123.25 151.3,123.24 151.25,123.22 151.2,123.2 151.15,123.16 151.11,123.13 151.08,123.08 151.05,123.03 151.03,122.98 151.02,122.93 151.01,122.87 147.1,122.87 147.1,124.27 146.63,124.74 145.61,124.74 145.43,124.92 145.43,126.61 152.27,126.61
VCC1V8 on BOTTOM (solid shape): 21.47,90.16 21.47,87.54 21.46,87.54 18.75,87.54 18.54,87.74 18.54,90.1 18.69,90.24 21.38,90.24
VCC1V8 on TOP: 40.72,90.2 38.89,90.2 38.73,90.04 38.73,89.43 38.99,89.18 40.03,89.18 40.59,88.62 40.59,84.67 41.1,84.67 41.1,86.03 41.4,86.34 41.4,89.51
VCC1V8 on BOTTOM: 40.31,89.99 40.31,89.48 40.21,89.38 37.8,89.38 37.71,89.47 37.71,90.29 37.71,90.48 37.62,90.58 37.36,90.58 37.2,90.73 37.2,91.75 38.55,91.75
VCC1V8 on 12_PWR3: 240.03,174.65 240.03,14 13.74,14 13.74,5.74 1.27,5.74 1.27,174.65 ; 2 cut-outs
VCC1V8 on 14_SIG4: 145.54,122.81 153.21,115.14 197.76,115.14 206.12,123.49 206.12,129.59 202.95,132.77 181.31,132.77 176.4,127.86 168.15,127.86 164.95,131.06 146.46,131.06 145.54,130.15
VCC1V8 on 18_SIG6: 193.27,129.21 204.17,129.21 208.48,124.89 208.48,76.99 213.61,71.86 213.61,44.27 214.43,43.46 228.78,43.46 230.95,41.29 230.25,40.59 230.25,17.98 227.41,15.14 218.92,15.14 212.83,21.23 205.66,21.23 195.73,31.17 195.73,116.33 191.77,120.29 191.77,127.71
VCC1V8_FET_SWITCH on TOP (solid shape): 160.19,127.46 160.19,126.11 160.1,126.01 157.53,126.01 157.53,124.43 156.77,123.67 154.23,123.67 154.23,127.4 154.53,127.69 159.96,127.69
VCC1V8_FET_SWITCH on BOTTOM (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FET_SWITCH on 03_SIG1 (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FET_SWITCH on 05_SIG2 (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FET_SWITCH on 07_SIG3 (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FET_SWITCH on 14_SIG4 (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FET_SWITCH on 16_SIG5 (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FET_SWITCH on 18_SIG6 (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FET_SWITCH on 20_SIG7 (solid shape): 160.19,126.01 157.53,126.01 157.53,123.91 156.44,122.82 154.23,122.82 154.23,127.69 160.19,127.69
VCC1V8_FPGA on TOP (solid shape): outline of 282 points within 135.45,124.17 147.21,130.99
VCC1V8_FPGA on BOTTOM (solid shape): 144.88,130.66 144.88,129.64 145.3,129.23 146.02,129.23 146.3,128.95 146.3,127.59 145.92,127.21 144.03,127.21 144.03,127.82 143.3,127.82 143.21,127.91 143.21,130.84 143.38,131.01 144.53,131.01
VCC1V8_FPGA on TOP: 171.54,63.69 170.96,63.69 170.72,63.45 170.72,61.72 171.03,61.41 171.21,61.41 171.21,61.41 171.44,61.41 171.58,61.26 171.58,60.33 171.65,60.26 173.05,60.26 173.16,60.37 173.16,62.99 172.63,62.99 172.26,63.36 171.87,63.36
VCC1V8_FPGA on TOP: 153.95,104.04 153.95,102.46 154.56,101.85 157.16,101.85 157.16,104.39 154.31,104.39
VCC1V8_FPGA on BOTTOM: 129.19,119.54 126.86,119.54 126,120.41 126,129.99 126.2,130.2 128.1,130.2 129.1,129.2 129.1,124.95 130.24,123.82 130.24,120.59
VCC1V8_FPGA on 03_SIG1: 173.56,27.97 173.56,42.17 171.55,44.18 171.55,53.54 169.93,55.17 169.93,63.17 170.36,63.6 171.37,63.6 172.52,62.46 175.16,62.46 176.02,61.59 176.02,48.36 177.54,46.84 177.54,43.33 182.09,38.79 182.09,21.41 177.14,16.46 125.48,16.46 124.24,17.7 124.24,18.79 129.85,24.41 143.92,24.41 146.96,21.36 166.95,21.36
VCC1V8_FPGA on 05_SIG2: 124.61,62.59 128.09,62.59 128.91,61.77 128.91,53.64 128.65,53.39 123.16,53.39 122.86,53.7 122.86,54.25 123.01,54.41 123.34,54.41 123.6,54.66 123.6,61.57
VCC1V8_FPGA on 05_SIG2: 140.97,27.38 142.52,27.38 147.65,22.25 151,22.25 153.26,19.99 154.94,19.99 154.94,20.12 156.41,21.59 156.48,21.53 157.49,21.53 158.47,20.55 158.47,14.88 157.86,14.27 145.92,14.27 144.08,16.12 144.08,17.64 140.08,21.64 140.08,26.49
VCC1V8_FPGA on 07_SIG3: 115.98,53.11 123.57,53.11 123.82,53.37 123.82,55.37 123.57,55.63 115.98,55.63 115.72,55.37 115.72,53.37
VCC1V8_FPGA on 07_SIG3: 144.7,131.28 145.51,130.47 145.51,126.28 144.27,125.04 140.94,125.04 138.99,127 128.57,127 127.13,128.45 127.13,130.1 128.31,131.28
VCC1V8_FPGA on 11_PWR2: 143.38,131.09 155.5,131.09 160.48,126.11 160.48,58.99 159.25,57.76 140.82,57.76 140.06,58.52 127.61,58.52 120.95,65.18 114.81,65.18 110.59,69.39 110.59,72.24 111,72.64 113.13,72.64 114.35,73.86 114.35,77.22 114.63,77.5 121.13,77.5 121.82,78.18 122.33,78.18 122.53,77.98 122.53,73.3 124.41,71.42 140.03,71.42 143.05,74.45 143.05,121.21 140.21,124.05 140.21,127.91
VCC1V8_FPGA on 18_SIG6: 153.8,86.35 151.06,86.35 150.15,85.45 150.15,64.47 148.18,62.5 148.18,51.49 149.36,50.31 151.72,50.31 155.95,54.54 155.95,55.88 158.63,58.56 173.93,58.56 174.8,59.44 174.8,61.02 172.62,63.2 172.62,63.53 172.35,63.8 160.54,63.8 153.98,70.37 153.98,86.18
VCC1V8_FPGA on 20_SIG7: 146.84,14.12 156.74,14.12 159.23,16.61 159.23,25.96 157.38,27.81 152.88,27.81 152.4,27.33 152.4,18.36 152.04,18.01 151.33,18.01 151.05,18.29 151.05,27.56 150.8,27.81 142.42,27.81 141.02,26.42 141.02,19.94
VCC12_MGTAVCC on TOP (solid shape): 156.04,143.66 156.04,137.31 156.02,137.31 156.02,134.39 155.47,133.85 155.47,132.61 155.14,132.28 151.89,132.28 151.89,133.75 151.89,133.75 151.89,134.85 152.27,135.23 153.47,135.23 153.87,135.64 153.87,136.14 153.5,136.52 153.5,138.61 153.27,138.83 151.79,138.83 151.53,139.09 150.37,139.09 149.69,138.42 148.9,138.42 148.89,138.42 148.76,138.44 148.63,138.42 148.63,138.42 148.4,138.42 148.39,138.42 148.26,138.44 148.13,138.42 148.13,138.42 147.9,138.42 147.82,138.43 147.58,138.67 147.17,138.67 147.15,138.69 146.86,138.69 146.76,138.78 146.75,138.84 146.8,138.87 147.43,138.87 147.82,139.26 150.31,139.26 150.46,139.42 150.46,141.12 150.81,141.12 150.82,141.11 151.08,141.05 151.33,141.12 151.64,141.12 151.64,141.42 151.97,141.75 153.36,141.75 153.36,142.01 153.5,142.01 153.5,143.68 153.82,144 155.7,144
VCC12_MGTAVCC on BOTTOM (solid shape): 156.23,143.36 156.23,136.75 156.21,136.75 156.21,133.31 155.48,132.58 153.21,132.58 152.46,133.33 152.46,134.67 153.29,135.5 153.32,135.5 153.71,135.67 153.69,136.1 153.69,138.78 150.7,138.78 150.55,138.93 150.55,140.46 150.9,140.81 151.79,140.81 152.42,141.45 153.69,141.45 153.69,143.12 154.25,143.68 155.91,143.68
VCC12_MGTAVTT on TOP (solid shape): 186.34,63.01 186.34,60.39 186.47,60.39 186.47,60.26 186.98,59.75 186.98,58.86 187.61,58.23 187.61,56.96 188.97,56.96 189.99,55.93 189.99,53.92 188.6,52.53 184.2,52.53 184.15,52.58 181.79,52.58 181.79,52.58 178.59,52.58 178.11,53.06 178.11,55.44 178.38,55.71 180.99,55.71 182.24,56.96 184.95,56.96 184.95,58.8 184.95,58.8 184.95,59.11 185,59.23 185.02,59.37 185.02,60.34 184.95,60.41 184.95,60.77 185.07,60.89 185.33,60.89 185.58,61.15 185.58,63.05 185.71,63.18 186.17,63.18
VCC12_MGTAVTT on BOTTOM (solid shape): 186.47,62.93 186.47,60.26 186.98,59.75 186.98,58.86 187.61,58.23 187.61,56.96 188.97,56.96 189.99,55.93 189.99,53.87 188.65,52.52 178.63,52.52 178.1,53.05 178.1,55.42 178.38,55.7 180.97,55.7 182.22,56.96 184.95,56.96 184.95,60.77 185.07,60.89 185.33,60.89 185.58,61.15 185.58,63.05 185.71,63.18 186.22,63.18
VCC12_P on TOP (solid shape): outline of 318 points within 214.25,139.6 232.89,150.16
VCC12_P on BOTTOM (solid shape): outline of 310 points within 214.25,139.6 232.89,149.77
VCC12_P on 03_SIG1 (solid shape): outline of 676 points within 212.55,139.24 231.62,155.87
VCC12_PCIE on TOP: 47.85,6.76 48.06,6.96 48.06,7.37 48.46,7.77 52.17,7.77 52.2,7.8 54.36,7.8 55.25,8.69 55.25,14.27 54.73,14.79 46.49,14.79 45.99,14.29 45.99,12.61 45.75,12.38 45.75,8.71 45.66,8.62 45.66,6.76
VCC12_PCIE on 10_GND: 47.85,6.76 48.06,6.96 48.06,7.37 48.46,7.77 52.17,7.77 52.2,7.8 54.36,7.8 55.25,8.69 55.25,14.27 54.97,14.55 46.25,14.55 45.99,14.29 45.99,12.61 45.75,12.38 45.75,8.71 45.66,8.62 45.66,6.76
VCC12_Q_OUT on TOP (solid shape): outline of 338 points within 205.31,129.64 219.46,145.06
VCC12_Q_OUT on BOTTOM (solid shape): outline of 332 points within 205.31,129.64 218.31,144.32
VCC12_SW on TOP (solid shape): 146.66,131.49 143.48,131.49 143.48,134.79 146.66,134.79
VCC12_SW on TOP (solid shape): 209.84,45.11 206.44,45.11 205.77,45.77 205.77,49.2 206.03,49.46 209.84,49.46
VCC12_SW on TOP (solid shape): 174.53,139.81 174.53,136.37 174.08,135.91 171.48,135.91 170.69,136.7 170.69,139.75 171.2,140.26 174.08,140.26
VCC12_SW on TOP (solid shape): 161.8,107.77 161.77,107.77 161.77,106.32 160.91,105.46 157.91,105.46 157.5,105.87 157.51,105.9 157.51,108.56 161.8,108.56
VCC12_SW on TOP (solid shape): 181.16,63.39 181.16,63.39 181.14,63.25 181.16,63.11 181.16,63.1 181.16,61 177.86,61 177.86,64.18 181.16,64.18
VCC12_SW on TOP (solid shape): 222,67.2 222,63.42 221.86,63.29 221.84,63.29 221.57,63.2 221.32,63.04 218.41,63.04 218.41,67.39 221.8,67.39
VCC12_SW on TOP (solid shape): 197.31,16.8 197.31,15.94 197.23,15.54 197.31,15.15 197.31,14.11 197.16,13.96 193.75,13.96 193.33,14.37 193.33,17.21 193.68,17.55 196.55,17.55
VCC12_SW on TOP (solid shape): 45.35,131.21 45.35,128.84 44.93,128.42 43.05,128.42 42.98,128.43 42.91,128.42 41.61,128.42 41.45,128.57 41.45,130.68 41.51,130.74 41.53,130.74 41.79,130.85 41.91,131.12 41.91,131.14 42.37,131.6 44.97,131.6
VCC12_SW on BOTTOM (solid shape): 197.44,16.38 197.44,16.16 197.43,16.14 197.23,15.54 197.44,14.93 197.44,14.32 196.98,13.86 192.12,13.86 191.98,14.01 191.98,15.78 194.62,15.78 195.52,16.69 197.13,16.69
VCC12_SW on 03_SIG1: 202.41,143.84 207.8,143.84 211.23,140.41 211.23,130.73 209.6,129.11 202.21,129.11 198.15,133.17 198.15,137.31 200,139.17 200,141.43
VCC12_SW on 05_SIG2: 131.15,162.06 131.15,148.79 135.28,144.66 135.28,144.4 139.47,140.21 139.47,140.21 139.6,140.08 139.6,132.26 140.89,130.96 145.8,130.96 146.28,131.44 146.28,142.25 139.55,148.97 139.55,162.06
VCC12_SW on 07_SIG3: 155.33,105.76 156.7,104.39 168.89,104.39 187.05,122.55 199.21,122.55 204.18,127.52 204.18,133.14 206.11,135.07 206.11,144.06 205.76,144.41 183.64,144.41 182.34,143.1 182.34,140.12 181.18,138.97 178.2,138.97 177.24,138.01 177.24,130.96 175.63,129.35 170.88,129.35 167.97,126.44 167.97,117.64 165.83,115.51 163.8,115.51 160.78,112.49 158.4,112.49 155.33,109.42
VCC12_SW on 11_PWR2: 46.46,174.65 240.03,174.65 240.03,14.02 176.73,14.02 176.73,26.04 172.52,30.25 172.52,39.12 179.73,46.33 179.73,67.08 189.66,77.01 189.66,127.03 199.16,136.53 199.16,149.28 197.33,151.1 186.31,151.1 180.64,145.44 180.64,142.09 175.13,136.58 170.71,136.58 165.73,141.55 137.97,141.55 135.76,143.76 113.61,143.76 104.83,134.98 71.63,134.98 66.09,140.51 62.38,140.51 59.03,137.16 59.03,124.79 58.55,124.31 54.84,124.31 47.96,117.42 45.03,117.42 43.46,115.85 41.05,115.85 40.16,116.74 40.16,130.45 46.46,136.75
VCC12_SW on 14_SIG4, 16_SIG5, 18_SIG6, 20_SIG7: 206.63,143.94 201.37,143.94 198.25,140.82 198.25,134.62 199.01,133.86 208.61,133.86 211.15,136.4 211.15,139.42
VCC12_UTIL_1V35 on TOP (solid shape): 36.17,122.22 34.34,120.4 34.34,119.08 34.34,117.05 34.34,116.81 35.39,115.77 40.23,115.77 41.66,114.35 41.66,114.07 42.13,114.07 42.18,114.01 42.18,112.86 42.39,112.86 42.39,112.85 42.39,111.24 40.32,111.24 38.4,113.16 34.76,113.16 34.57,113.21 34.38,113.16 34.14,113.16 33.47,113.83 33.47,113.85 33.39,114.16 33.12,114.3 33.05,114.33 33.02,114.4 33.02,114.78 33.1,114.78 33.1,116.56 32.79,116.56 32.7,116.65 32.72,116.68 32.75,116.97 32.56,117.2 32.54,117.22 32.54,121.13 32.26,121.41 32.26,121.71 32.3,121.72 32.54,121.84 32.64,122.1 32.64,122.12 32.72,122.2 32.72,122.4 33.1,122.4 33.1,124.18 32.26,124.18 32.26,127.94 33.22,128.91 33.22,129.84 36.17,129.84
VCC12_UTIL_3V3 on TOP (solid shape): 181.08,41.04 184.43,41.04 184.43,37.13 181.08,37.13 181.08,36.98 180.22,36.98 180.22,37.43 180.68,37.43 180.68,38.2 180.22,38.2 180.22,38.7 180.68,38.7 180.68,39.47 180.22,39.47 180.22,39.97 180.68,39.97 180.68,40.74 180.22,40.74 180.22,41.24 181.08,41.24
VCC12_UTIL_3V3 on TOP (solid shape): outline of 206 points within 177.5,13.76 188.06,41.59
VCC12_UTIL_3V3 on BOTTOM (solid shape): 190.28,15.51 190.28,14.13 189.91,13.76 180.8,13.76 180.58,13.98 180.58,15.66 180.85,15.93 189.87,15.93
VCC12_VADJ_1V8 on TOP (solid shape): 192.23,136.07 192.23,135.28 192.25,135.26 192.4,135.11 193.61,135.11 194.94,133.77 194.94,128.32 193.75,127.12 193.02,127.12 191.33,125.43 187.75,125.43 186.13,127.05 180.21,127.05 179.5,126.34 172.95,126.34 171.65,127.63 171.65,130.3 171.96,130.61 174.5,130.61 175.41,129.69 186.51,129.69 188.19,128.01 191.31,128.01 191.74,128.44 191.74,134.32 191.72,134.34 190.32,134.34 189.99,134.67 189.54,134.67 189.39,134.82 189.39,135.82 189.48,135.91 190.6,135.91 190.6,136.04 190.68,136.12 192.18,136.12
VCC12_VCC1V2 on TOP (solid shape): 227.04,45.56 227.03,45.54 227.03,45.47 227.15,45.34 227.74,45.34 227.74,45.34 229.87,45.34 230.25,44.96 230.25,38.45 230.23,38.42 230.23,36.99 228.66,35.42 212.92,35.42 212.06,36.27 206.79,36.27 206.79,39.28 207.36,39.84 210.97,39.84 211.32,39.49 219.52,39.49 221.39,37.62 226.13,37.62 226.54,38.02 226.54,38.94 228.85,38.94 228.86,38.88 228.87,38.83 228.89,38.78 228.92,38.73 228.95,38.68 228.99,38.64 229.04,38.61 229.09,38.59 229.14,38.57 229.19,38.56 229.25,38.56 229.3,38.56 229.36,38.58 229.41,38.6 229.46,38.63 229.5,38.66 229.54,38.7 229.57,38.75 229.59,38.8 229.61,38.86 229.62,38.91 229.62,38.97 229.61,39.02 229.59,39.07 229.57,39.12 229.54,39.17 229.5,39.21 229.46,39.25 229.41,39.28 229.36,39.3 229.3,39.31 229.25,39.32 229.19,39.32 229.14,39.31 229.09,39.29 229.04,39.26 228.99,39.23 228.95,39.19 228.92,39.15 228.89,39.1 228.87,39.05 228.86,38.99 228.85,38.94 226.54,38.94 226.54,43.87 226.06,44.35 224.85,44.35 224.36,44.84 224.36,45.94 224.54,46.12 225.4,46.12 225.4,46.28 227.04,46.28
VCC12_VCC1V8 on TOP (solid shape): 170.92,126.64 170.92,120.02 170.94,119.14 170.94,106.58 170.59,106.22 167,106.22 167,108.28 167.74,109.02 167.74,119.08 169.24,120.58 169.24,124.36 168.96,124.64 162.97,124.64 161.42,123.09 160.48,123.09 160.48,124.12 160.32,124.12 160.32,125.7 160.38,125.76 161.47,125.76 162.71,127 170.56,127
VCC12_VCCINT on TOP (solid shape): outline of 188 points within 213.26,81.66 228.93,133.2
VCC12_VCCINT on BOTTOM (solid shape): 222.34,81.66 219.18,81.66 217.07,83.77 213.94,83.77 213.94,85.29 215.93,85.29 217.42,86.79 219.8,86.79 219.8,92.58 218.03,92.58 216.89,93.73 213.94,93.73 213.94,95.5 215.72,95.5 216.87,96.65 219.8,96.65 219.8,103 218.01,103 216.87,104.14 213.94,104.14 213.94,105.92 215.72,105.92 216.92,107.11 219.8,107.11 219.8,113.41 218.01,113.41 216.87,114.55 213.95,114.55 213.95,116.33 215.72,116.33 216.92,117.53 219.8,117.53 219.8,119.25 222.34,119.25
VCC12_VCCINTIO_BRAM on TOP (solid shape): 206.38,76.22 220.73,76.22 220.98,75.97 220.98,72.82 220.75,72.59 220.65,72.59 220.65,72.63 219.2,72.63 219.2,72.59 217.34,72.59 216.92,73.01 207.03,73.01 205.16,74.88 201.7,74.88 201.57,74.75 201.57,68.54 201.68,68.44 202.85,68.44 203.55,67.74 203.55,66.22 203.45,66.12 202.34,66.12 202.34,65.96 200.75,65.96 200.75,66.21 200.72,66.21 200.72,66.93 200.5,67.16 199.94,67.16 199.18,67.91 199.18,76.93 199.74,77.49 205.11,77.49
VCCINT on TOP (solid shape): 203.16,109.6 199.48,109.6 199.48,105.15 203.16,105.15 203.16,100.61 199.48,100.61 199.48,96.26 203.16,96.26 203.16,91.68 199.27,91.68 199.27,87.05 202.83,87.05 202.83,82.6 190.97,82.6 190.97,114.17 203.16,114.17
VCCINT_FPGA on TOP (solid shape): 186.83,111.19 188.34,111.19 189.43,110.1 189.43,103.62 189.88,103.17 189.88,98.04 188.6,98.04 188.48,98.16 186.83,98.16 186.66,98.13 186.5,98.05 186.49,98.04 186.37,98.04 186.37,97.93 186.36,97.92 186.26,97.58 186.37,97.24 186.37,96.41 186.26,96.07 186.36,95.73 186.37,95.72 186.37,95.6 186.49,95.6 186.5,95.6 186.66,95.52 186.83,95.49 188.48,95.49 188.6,95.6 189.88,95.6 189.88,92.76 188.55,92.76 188.48,92.82 186.83,92.82 186.7,92.81 186.58,92.77 186.57,92.76 186.32,92.76 186.32,92.51 186.32,92.5 186.26,92.25 186.32,91.99 186.32,90.99 186.26,90.73 186.32,90.47 186.32,90.09 189.88,90.09 189.88,85.27 186.83,85.27 186.83,84.95 186.26,84.38 186.83,83.81 186.83,83.43 186.38,83.21 186.25,82.64 186.17,82.6 178.19,82.6 178.19,118.44 186.83,118.44
VCCINT_FPGA on BOTTOM (solid shape): outline of 194 points within 178.19,82.6 189.88,118.44
VCCINT_FPGA on TOP: outline of 84 points within 77.53,49.08 159.87,100.27
VCCINT_FPGA on TOP: 194.14,73.78 197.28,73.78 197.28,76.78 194.07,76.78 193.84,76.56 193.84,74.08
VCCINT_FPGA on 09_PWR1: 128.42,119.74 170.45,119.74 173.87,123.15 184.33,123.15 197.33,110.15 197.33,62.13 196.8,61.59 180.64,61.59 175.56,56.52 118.24,56.52 117.22,55.5 115.93,55.5 115.27,54.84 115.27,53.16 114.91,52.81 82.63,52.81 81.59,53.85 81.59,84.87 79.8,86.66 79.8,89.35 81.59,91.13 81.59,103.28 82.19,103.89 99.31,103.89 103.05,107.62 103.05,124.28 101.91,125.42 83.93,125.42 83.41,125.94 83.41,140.53 84.1,141.22 106.93,141.22
VCCINT_FPGA on 10_GND: 128.42,119.74 170.45,119.74 173.87,123.15 184.33,123.15 197.33,110.15 197.33,62.13 196.12,60.92 179.97,60.92 175.56,56.52 118.24,56.52 117.22,55.5 115.93,55.5 115.27,54.84 115.27,53.75 114.32,52.81 82.63,52.81 81.59,53.85 81.59,84.87 79.8,86.66 79.8,89.35 81.59,91.13 81.59,103.28 82.19,103.89 99.31,103.89 103.05,107.62 103.05,123.83 101.45,125.42 84.48,125.42 84.14,125.76 84.14,132.97 87.39,136.22 111.93,136.22
VCCINT_FPGA on 18_SIG6: 184.15,123.49 174.5,123.49 173.74,122.73 173.74,98.88 170,95.15 165.89,95.15 165.84,95.2 165.13,95.2 164.59,94.67 157.1,94.67 154.74,92.31 154.74,71.11 161.37,64.49 176.76,64.49 177.95,63.3 177.95,61.39 174.42,57.86 159.33,57.86 157.66,56.18 157.66,53.37 158.6,52.43 177.44,52.43 177.44,33.25 190.88,19.81 190.91,19.81 191.72,19 199.75,19 200.58,19.84 200.58,25.15 195.2,30.53 195.2,112.45
VCCINT_SLAVE_1V8 on BOTTOM (solid shape): 237.16,95.5 239.36,95.5 239.36,93.41 239.09,93.14 235.16,93.14 234.14,92.13 231.27,92.13 231.01,92.38 231.01,95.72 236.94,95.72
VCCINT_SLAVE_1V8 on 14_SIG4: 211.18,119.94 238.3,119.94 239.5,118.74 239.5,95.2 225.02,80.72 210.49,80.72 208.41,82.8 208.41,117.17
VCCINT_VX1 on TOP (solid shape): 213.67,119.76 213.75,119.73 213.77,119.65 213.78,119.53 213.83,119.42 213.83,118.83 213.77,118.62 213.83,118.42 213.83,117.83 213.77,117.62 213.83,117.42 213.83,116.83 213.77,116.62 213.83,116.42 213.83,116.05 213.42,116.05 213.27,116.03 213.13,115.95 212.88,115.95 212.75,116.03 212.6,116.05 211.53,116.05 211.53,115.95 208.87,115.95 208.87,115.75 207.78,115.75 207.78,114.55 203.54,114.55 200.16,114.55 200.16,119.76
VCCINT_VX2 on TOP (solid shape): 213.83,108.42 213.77,108.21 213.83,108 213.83,107.42 213.77,107.21 213.83,107 213.83,106.42 213.77,106.21 213.83,106 213.83,105.64 213.42,105.64 213.27,105.61 213.13,105.53 212.88,105.53 212.75,105.61 212.6,105.64 211.53,105.64 211.53,105.53 203.54,105.53 200.16,105.53 200.16,108.96 213.83,108.96
VCCINT_VX3 on TOP (solid shape): 209.13,98.8 213.77,98.8 213.78,98.76 213.79,98.67 213.83,98.59 213.83,98 213.77,97.8 213.83,97.59 213.83,97 213.77,96.8 213.83,96.59 213.83,96 213.77,95.8 213.83,95.59 213.83,95.23 213.42,95.23 213.27,95.2 213.13,95.12 212.88,95.12 212.75,95.2 212.6,95.23 211.53,95.23 211.53,95.12 204.94,95.12 204.94,96.65 200.16,96.65 200.16,100.07 209.13,100.07
VCCINT_VX4 on TOP (solid shape): 208.82,90.93 208.95,90.87 209.08,90.84 209.13,90.83 209.13,88.39 213.77,88.39 213.78,88.34 213.79,88.26 213.83,88.17 213.83,87.59 213.77,87.38 213.83,87.17 213.83,86.59 213.77,86.38 213.83,86.17 213.83,85.59 213.77,85.38 213.83,85.17 213.83,84.81 213.42,84.81 213.27,84.79 213.14,84.71 212.88,84.71 212.75,84.79 212.6,84.81 211.53,84.81 211.53,84.71 210.85,84.71 210.85,84.8 209.71,84.8 209.71,84.71 204.94,84.71 204.94,87.63 200.16,87.63 200.16,90.93
VCCINTIO_BRAM on TOP (solid shape): 206.77,57.4 210.1,57.4 210.23,57.28 210.23,51.78 209.93,51.49 204.35,51.49 204.11,51.73 204.11,53.63 203.34,54.4 200.61,54.4 200.16,54.85 200.16,57.03 203.71,57.03 203.72,56.98 203.73,56.92 203.75,56.87 203.77,56.82 203.81,56.78 203.85,56.74 203.89,56.71 203.94,56.68 204,56.66 204.05,56.65 204.11,56.65 204.16,56.66 204.22,56.67 204.27,56.69 204.31,56.72 204.36,56.76 204.39,56.8 204.43,56.85 204.45,56.9 204.47,56.95 204.47,57 204.47,57.06 204.47,57.12 204.45,57.17 204.43,57.22 204.39,57.27 204.36,57.31 204.31,57.34 204.27,57.37 204.22,57.39 204.16,57.41 204.11,57.41 204.05,57.41 204,57.4 203.94,57.38 203.89,57.36 203.85,57.33 203.81,57.29 203.77,57.24 203.75,57.19 203.73,57.14 203.72,57.09 203.71,57.03 200.16,57.03 200.16,58.01 200.25,58.09 206.09,58.09
VCCINTIO_BRAM_FET_SWITCH on TOP (solid shape): 200.37,63.17 202.53,63.17 203.29,62.41 203.29,60.4 202.76,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.37,65.83
VCCINTIO_BRAM_FET_SWITCH on BOTTOM (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FET_SWITCH on 03_SIG1 (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FET_SWITCH on 05_SIG2 (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FET_SWITCH on 07_SIG3 (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FET_SWITCH on 14_SIG4 (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FET_SWITCH on 16_SIG5 (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FET_SWITCH on 18_SIG6 (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FET_SWITCH on 20_SIG7 (solid shape): 200.37,65.71 200.37,63.17 202.53,63.17 203.37,62.33 203.98,62.33 205.02,61.29 205.02,59.87 198.12,59.87 197.58,60.41 197.58,65.83 200.25,65.83
VCCINTIO_BRAM_FPGA on TOP (solid shape): outline of 92 points within 190.75,51.56 203.35,59.36
VCCINTIO_BRAM_FPGA on BOTTOM (solid shape): 199.36,56.78 199.36,54.97 200.79,53.54 200.79,51.79 200.57,51.58 196.15,51.58 195.85,51.88 195.85,57.19 196.22,57.56 198.58,57.56
VCCINTIO_BRAM_FPGA on TOP: 187.13,42.41 186.74,42.01 184.63,42.01 184.3,42.34 184.3,44.22 184.51,44.42 187.1,44.42 187.13,44.39
VCCINTIO_BRAM_FPGA on 03_SIG1: 110.87,73.48 124.13,73.48 125.91,71.7 125.91,70.71 124.94,69.75 124.94,66.73 126.9,64.77 126.9,54.43 126.24,53.77 117.22,53.77 116.51,54.48 116.51,55.42 117.14,56.06 117.86,56.06 118.36,56.57 118.36,61.14 118.07,61.43 117.01,61.43 113.11,65.33 113.11,67.31 110.52,69.9 110.52,73.13
VCCINTIO_BRAM_FPGA on 09_PWR1: 116.66,55.17 117.83,55.17 118.82,56.16 175.79,56.16 180.85,61.21 201.52,61.21 202.9,59.84 202.9,51.33 193.42,41.86 184.61,41.86 182.91,43.56 116.94,43.56 115.65,44.86 115.65,54.15
VCCPLL on BOTTOM (solid shape): outline of 1500 points within 15.85,135.25 21.72,143.11
(no net) on TOP: 140.5,104.95 138.17,104.95 138.17,102.82 138.11,102.76 138.11,101.44 137.21,100.54 137.21,98.48 141.54,98.48 141.98,98.91 141.98,100.9 141.64,101.23 141.16,101.23 140.93,101.46 140.51,101.46 140.33,101.64 140.33,103.28 140.5,103.45
(no net) on TOP: 149.97,145.49 149.97,139.65 147.68,139.65 147.68,143.84 145.53,143.84 145.53,145.49
(no net) on TOP: 167,108.28 167,106.22 170.59,106.22 170.94,106.58 170.94,119.14 170.92,120.02 170.92,126.64 170.56,127 162.71,127 161.47,125.76 160.27,125.76 160.27,123.19 160.38,123.09 161.42,123.09 162.97,124.64 168.96,124.64 169.24,124.36 169.24,120.58 167.74,119.08 167.74,109.02
(no net) on TOP: 6.76,124.48 6.76,127.4 6.61,127.55 5.5,127.55 5.21,127.25 5.21,124.42 5.26,124.37 6.64,124.37
(no net) on TOP: 157.4,105.97 157.4,108.56 161.8,108.56 161.8,106.35 160.91,105.46 157.91,105.46
(no net) on TOP: 20.4,146.03 12.93,146.03 12.93,143.73 13.14,143.52 19.84,143.52 20.4,144.07
(no net) on TOP: 62.62,123.29 66.14,123.29 68.45,125.6 68.45,127.3 67.34,128.42 65.48,128.42 65.24,128.66 62.71,128.66 62.62,128.57
(no net) on TOP: 195.07,153.7 195.07,152.2 195.45,151.82 197.92,151.82 197.92,153.77 197.61,154.08 195.45,154.08
(no net) on TOP: 190.66,66 190.66,64.2 190.15,63.69 186.6,63.69 186.34,63.94 186.34,65.47 186.47,65.59 186.47,67.5 188.43,69.45 188.43,72.87 191.28,72.87 191.47,72.69 191.47,66.8
(no net) on TOP: 17.82,125.49 14.62,125.49 14.62,122.03 15.63,122.03 15.75,122.15 15.75,122.37 16,122.62 16.41,122.62 16.49,122.54 17.77,122.54 18.01,122.79 18.01,125.29
(no net) on TOP: 143.48,134.79 143.48,131.49 146.66,131.49 146.66,134.79
(no net) on TOP: 138.16,109.26 140.5,109.26 140.5,110.79 141.35,111.65 141.35,113.08 141.13,113.3 139.88,113.3 139.88,112.15 139.27,111.54 138.83,111.54 138.16,110.87
(no net) on TOP: 139.38,113.32 139.37,113.33 136.32,113.33 136.08,113.09 136.08,112.31 136.75,112.31 137.13,111.93 137.37,111.93 137.37,111.93 139.15,111.93 139.38,112.17
(no net) on TOP: 173.23,50.63 169.54,50.63 169.42,50.75 169.42,52 169.59,52.16 173.61,52.16 173.78,51.99 173.78,51.72 173.96,51.53 174.79,51.53 175.19,51.13 175.19,50.41 175.47,50.12 176.28,50.12 176.28,49.19 176.18,49.08 174.79,49.08
(no net) on TOP: 132.09,133.73 134.21,133.73 137.62,137.15 140.65,137.15 142.74,135.06 142.74,131.3 132.2,131.3 132.09,131.41
(no net) on TOP: 3.27,124.56 3.27,127.36 3.08,127.55 1.95,127.55 1.77,127.37 1.77,124.57 1.87,124.47 3.18,124.47
(no net) on TOP: 192.57,60.77 186.72,60.77 186.72,63.05 190.92,63.05 190.92,65.21 192.57,65.21
(no net) on TOP: 41.08,115.13 40.06,116.15 34.98,116.15 34.98,119.68 37.06,121.77 37.06,126.85 37.18,126.97 38.53,126.97 38.53,125.4 39.07,124.87 40.41,124.87 41.73,126.19 48.05,126.19 48.17,126.07 48.17,123.97 50.4,121.74 50.4,117.24 47.89,114.74 45.9,114.74 45.32,114.17 45.32,113.84 44.76,113.27 44.76,111.48 44.51,111.24 42.72,111.24 42.71,111.24 42.71,112.84 42.76,112.89 42.94,112.89 43.09,113.04 43.09,113.97 43.53,114.4 43.53,114.7 43.1,115.13 ; 2 cut-outs
(no net) on TOP: 213.83,115.95 208.87,115.95 208.87,114.55 200.16,114.55 200.16,119.76 213.83,119.76
(no net) on TOP: 210.97,39.84 207.36,39.84 206.79,39.28 206.79,36.27 212.06,36.27 212.92,35.42 228.66,35.42 230.23,36.99 230.23,38.42 230.25,38.45 230.25,44.96 229.87,45.34 227.74,45.34 227.74,45.34 227.15,45.34 227.03,45.47 227.03,45.54 227.05,45.57 227.05,46.41 227.05,46.41 224.82,46.41 224.36,45.94 224.36,44.78 224.79,44.35 226.06,44.35 226.54,43.87 226.54,38.02 226.13,37.62 221.39,37.62 219.52,39.49 211.32,39.49
(no net) on TOP: 223.8,158.2 225.45,158.2 226.42,159.17 226.44,159.17 227.42,160.15 230.76,160.15 231.6,159.31 231.6,156.57 230.81,155.78 228.18,155.78 226.82,157.13 225.76,157.13 225.22,156.6 223.8,156.6
(no net) on TOP: 163.13,133.77 161.73,132.38 161.73,129.01 161.65,128.93 160.5,128.93 160.46,128.97 160.46,131.73 160.57,131.84 160.78,131.84 161.09,132.14 161.09,133.22 161.26,133.39 161.65,133.39 161.92,133.66 161.92,134.31 162.24,134.63 162.24,135.42 163.13,135.42
(no net) on TOP: 40.32,111.24 42.39,111.24 42.39,112.85 42.22,113.03 42.22,113.98 42.13,114.07 41.66,114.07 41.66,114.35 40.23,115.77 35.39,115.77 34.34,116.81 34.34,120.4 36.17,122.22 36.17,129.84 33.22,129.84 33.22,128.91 32.26,127.94 32.26,121.41 32.54,121.13 32.54,116.81 33.02,116.33 33.02,114.27 34.14,113.16 38.4,113.16
(no net) on TOP: 160.48,133.27 160.59,133.15 160.59,132.41 160.42,132.25 160.42,132.25 160.24,132.08 160.18,132.08 159.94,131.84 159.94,128.98 159.89,128.93 158.8,128.93 158.68,129.05 158.68,133.01 158.94,133.27
(no net) on TOP: outline of 84 points within 213.26,81.66 228.93,133.2
(no net) on TOP: 178.19,82.6 178.19,118.44 186.83,118.44 186.83,111.19 188.34,111.19 189.43,110.1 189.43,103.62 189.88,103.17 189.88,98.04 186.37,98.04 186.37,95.6 189.88,95.6 189.88,92.76 186.32,92.76 186.32,90.09 189.88,90.09 189.88,85.27 186.83,85.27 186.83,82.65 186.78,82.6
(no net) on TOP: 201.98,44.91 202.62,44.27 202.62,41.81 202.21,41.4 202.21,35.99 204.22,35.99 205.47,37.24 205.47,40 206.5,41.03 206.5,44.34 205.31,45.54 205.31,49.78 204.76,50.32 198.04,50.32 198.04,44.91
(no net) on TOP: 223.73,112.14 223.73,119.25 226.15,119.25 226.15,112.14
(no net) on TOP: 63.41,51.05 65.76,51.05 66.01,51.29 66.01,52.79 65.88,52.92 63.51,52.92 63.2,52.61 63.2,51.25
(no net) on TOP: 179.43,73.4 172.02,73.4 171.7,73.71 171.7,78.03 172.29,78.61 178.66,78.61 179.43,77.85
(no net) on TOP: 214.08,106.05 216.24,106.05 216.24,107.95 217.23,107.95 217.23,111.12 215.86,111.12 215.86,111.76 211.54,111.76 211.54,109.6 214.08,109.6
(no net) on TOP: 214.08,95.63 216.24,95.63 216.24,97.53 217.1,97.53 217.1,100.71 215.86,100.71 215.86,101.34 211.54,101.34 211.54,99.18 214.08,99.18
(no net) on TOP: 145.6,127.37 147.15,127.37 147.21,127.43 147.21,129.12 147.1,129.23 145.22,129.23 144.86,129.59 144.86,130.68 144.55,130.99 143.36,130.99 143.1,130.73 143.1,127.84 142.85,127.58 138.04,127.58 137.15,128.47 135.9,128.47 135.45,128.03 135.45,124.58 135.86,124.17 144.14,124.17 144.96,124.99 144.96,126.05 144.79,126.23 144.54,126.23 144.32,126.44 144.32,127.63 144.62,127.93 145.04,127.93
(no net) on TOP: 209.84,49.46 209.84,45.11 206.44,45.11 205.77,45.77 205.77,49.2 206.03,49.46
(no net) on TOP: 200.31,41.25 200.31,36.12 199.39,35.2 199.39,21.88 195.7,18.19 185.83,18.19 184.96,17.32 182.8,17.32 182.68,17.45 182.68,22.58 183.66,23.56 183.66,35.78 185.28,35.78 185.84,35.22 193.91,35.22 194.52,35.83 194.52,41.12 195.98,41.12 196.19,41.32 196.19,42.47 195.22,43.44 195.22,44.25 195.47,44.5 201.68,44.5 202.14,44.04 202.14,43.09
(no net) on TOP: 48.97,100.58 48.36,101.19 48.36,103.43 47.72,104.07 45.7,104.07 45.47,104.29 45.47,106.93 45.97,107.43 48.39,107.43 49.09,108.13 50.73,108.13 50.74,108.12 50.74,106.15 51.72,105.16 51.72,101.08 51.23,100.58
(no net) on TOP: 85.14,32.46 87.58,32.46 88.02,32.03 88.02,30.19 87.96,30.14 84.89,30.14 84.69,30.33 84.69,32.01
(no net) on TOP: 37.77,102.26 37.77,104.97 37.51,105.23 35.42,105.23 35.25,105.06 35.25,102.46 35.46,102.26
(no net) on TOP: 205.84,34.98 209.48,34.98 209.68,34.78 209.68,31.8 209.4,31.52 204.7,31.52 203.96,30.78 201.04,30.78 200.62,31.21 200.62,33.37 201.59,34.34 204.27,34.34 204.38,34.23 205.1,34.23 205.78,34.91 205.78,34.91
(no net) on TOP: 147.12,143.39 147.42,143.1 147.42,140.31 147.42,140.3 147.42,139.41 147.27,139.25 145.31,139.25 145.08,139.48 145.08,140.22 144.44,140.87 143.18,140.87 141.86,139.55 137.64,139.55 137.46,139.73 137.46,142.69 138.17,143.39
(no net) on TOP: 213.83,105.53 200.16,105.53 200.16,108.96 213.83,108.96
(no net) on TOP: 64.75,117.28 64.75,119.31 61.83,119.31 61.83,117.28
(no net) on TOP: 16.44,87.98 16.61,87.8 18.01,87.8 18.01,74.09 14.48,74.09 14.1,74.47 14.1,87.42 14.66,87.98
(no net) on TOP: 193.84,144.98 193.84,147.28 193.18,147.94 192.53,147.94 192.15,148.32 192.15,150.27 192.32,150.44 198.43,150.44 199.64,149.22 199.64,142.06 199.09,141.5 196.85,141.5 196.24,142.11 196.24,144.22 195.83,144.63 194.19,144.63
(no net) on TOP: 21.36,92.96 18.42,92.96 18.42,86.71 21.36,86.71
(no net) on TOP: 187.06,51.5 182.24,51.5 182,51.26 182,49.2 182.12,49.07 186.86,49.07 187.06,49.27
(no net) on TOP: 193.3,143.94 186.77,143.94 186.64,143.81 182.79,143.81 182.71,143.89 182.71,150.33 183.43,151.05 190.65,151.05 191.37,150.34 191.37,148.13 192.17,147.33 193.1,147.33 193.3,147.14
(no net) on TOP: 203.23,68.62 203.23,74.47 204.77,74.47 206.94,72.31 216.98,72.31 217.34,71.96 217.34,70.43 217.09,70.18 216.25,70.18 216.12,70.05 216.12,66.47 216.1,66.45 216.1,62.08 215.55,61.53 213.45,61.53 211.22,59.31 207.54,59.31 207.54,59.68 204.46,62.76 203.98,62.76 203.07,63.68 200.74,63.68 200.74,65.58 202.28,65.58 202.28,65.2 203.48,65.2 203.68,65 204.01,65 204.18,65.17 204.18,65.2 204.18,67.67 ; 1 cut-out
(no net) on TOP: 61.96,90.56 61.78,90.75 61.78,94.34 61.78,94.35 61.78,95.17 62.97,96.36 62.97,104.11 63.24,104.38 63.24,106.85 63.47,107.08 69.07,107.08 69.46,107.47 85.92,107.47 87.1,106.3 87.1,105.19 65.45,105.19 65.24,104.98 65.24,103.64 65.53,103.36 87.1,103.36 87.1,101.96 87,101.86 86.04,101.86 85.96,101.78 65.68,101.78 65.58,101.68 65.58,98.2 66.22,97.56 66.22,91.41 65.37,90.56
(no net) on TOP: 65.68,30.02 65.86,29.84 65.86,28.47 65.79,28.4 63.4,28.4 63.39,28.41 62.97,28.41 62.83,28.55 62.83,29.81 63.05,30.02
(no net) on TOP: 230.59,54.66 228.7,54.66 228.33,55.03 228.33,57.61 228.1,57.84 227.66,57.84 227.46,58.04 227.46,59.87 228.49,60.9 232.17,60.9 233.13,59.95 233.13,55.78 234.27,54.64 234.27,52.6 233.64,51.97 231.38,51.97 231.14,52.21 231.14,54.11
(no net) on TOP: 223.73,91.31 223.73,98.42 226.15,98.42 226.15,91.31
(no net) on TOP: 52.02,118.06 52.02,120.29 54.99,120.29 55.75,119.53 55.75,108.79 53.31,106.35 51.54,106.35 51.51,106.38 51.51,110.59 50.72,111.38 50.72,114.08 51.29,114.64 51.29,115.41 51.01,115.69 51.01,117.05
(no net) on TOP: 22.84,144.78 25.81,144.78 25.9,144.87 25.9,146.45 25.88,146.47 21.21,146.47 20.95,146.21 20.95,144.7 21.21,144.45 22.5,144.45
(no net) on TOP: 203.15,53.77 203.35,53.57 203.35,51.66 203.25,51.56 196.24,51.56 195.86,51.95 195.86,56.03 195.71,56.18 191.52,56.18 190.75,56.95 190.75,58.72 191.39,59.36 193.12,59.36 193.55,58.93 197.66,58.93 199.57,57.02 199.57,54.76 200.56,53.77
(no net) on TOP: 136.46,98.48 134.59,98.48 134.11,98.96 134.11,99.97 134.55,100.41 136.46,100.41
(no net) on TOP: 191.6,44.14 191.6,36.66 190.93,35.99 185.95,35.99 185.25,36.7 185.25,40.05 185.27,40.07 187.26,40.07 187.57,40.37 187.57,48.58 187.81,48.82 187.81,50.11 188.01,50.32 191.03,50.32 191.04,50.31 191.04,44.7
(no net) on TOP: 174.02,82.15 174.02,86.23 171.97,86.23 171.97,92.84 174.02,92.84 174.02,99.19 171.97,99.19 171.97,105.51 174.02,105.51 174.02,111.48 171.97,111.48 171.97,115.07 176.73,115.07 176.73,82.15
(no net) on TOP: 223.93,44.73 224.64,44.02 224.64,38.02 222.35,38.02 220.19,40.18 211.26,40.18 210.9,40.54 210.9,42.06 211.16,42.32 212.4,42.32 212.55,42.47 212.55,44.6 212.12,45.03 212.12,46.03 212.15,46.05 212.15,50.42 212.69,50.96 214.79,50.96 217.2,53.37 220.22,53.37 220.45,53.14 220.45,52.81 222.71,50.55 222.71,49.38 223.47,48.62 226.85,48.62 227.03,48.44 227.03,46.66 224.79,46.66 224.79,47.04 223.93,47.04 ; 1 cut-out
(no net) on TOP: 180.91,68.04 181.08,67.87 185.14,67.87 186.02,68.75 186.02,74.5 184.61,75.91 181.01,75.91 180.91,75.81
(no net) on TOP: 233.05,134.92 233.05,142.09 231.75,143.38 228.63,143.38 227.48,142.24 227.48,139.55 227.13,139.19 222.45,139.19 221.51,140.13 221.51,142.93 221.26,143.18 219.96,143.18 219.96,141.58 218.82,140.45 218.82,138.43 212.57,132.18 212.57,129.95 213.8,128.72 216.38,128.72 219.42,131.75 221.72,131.75 222.02,132.05 222.02,132.89 222.71,133.58 231.7,133.58
(no net) on TOP: 213.83,95.12 204.94,95.12 204.94,96.65 200.16,96.65 200.16,100.07 209.13,100.07 209.13,98.8 213.83,98.8
(no net) on TOP: 217.34,72.59 220.75,72.59 220.98,72.82 220.98,75.97 220.73,76.22 206.38,76.22 205.11,77.49 199.74,77.49 199.18,76.93 199.18,67.91 199.94,67.16 200.5,67.16 200.72,66.93 200.72,65.97 200.77,65.93 202.32,65.93 202.34,65.95 202.34,66.09 203.42,66.09 203.55,66.22 203.55,67.74 202.85,68.44 201.68,68.44 201.57,68.54 201.57,74.75 201.7,74.88 205.16,74.88 207.03,73.01 216.92,73.01
(no net) on TOP: 189.84,128.45 188.32,128.45 186.66,130.1 175.87,130.1 175.6,130.37 175.6,131.6 175.85,131.85 176.69,131.85 176.82,131.98 176.82,135.56 176.84,135.59 176.84,139.95 177.39,140.5 179.49,140.5 181.71,142.72 186.22,142.72 186.22,141.53 189.39,138.36 191.93,138.36 191.93,136.58 190.66,136.58 190.66,136.83 189.53,136.83 189.31,137.05 188.84,137.05 188.76,136.97 188.76,134.37 188.83,134.29 189.76,134.29 189.84,134.21 ; 2 cut-outs
(no net) on TOP: 64.63,120.84 64.63,122.87 61.93,122.87 61.93,120.84
(no net) on TOP: 193.68,17.55 193.33,17.21 193.33,14.37 193.75,13.96 197.16,13.96 197.31,14.11 197.31,16.8 196.55,17.55
(no net) on TOP: 227.13,54.58 221.98,54.58 221.55,55.02 217.78,55.02 217.78,60.35 218.22,60.79 225.79,60.79 226.67,59.92 226.67,57.68 226.89,57.45 227.66,57.45 228,57.12 228,55.46
(no net) on TOP: 125.78,135.36 125.55,135.59 125.55,137.59 125.78,137.82 127.71,137.82 128.78,138.89 128.78,141.96 129.11,142.29 133.73,142.29 133.96,142.06 133.96,135.36
(no net) on TOP: 48.84,139.2 48.15,138.51 46.69,138.51 46.69,140.87 46.91,141.1 48.01,141.1 48.01,142.04 48.13,142.16 48.64,142.16 48.84,141.96
(no net) on TOP: 131.01,130.96 129.27,130.96 129.03,131.2 129.03,132.66 129.26,132.89 130.71,132.89 131.17,132.44 131.17,131.11
(no net) on TOP: 168.83,122.71 168.83,121.2 166.38,118.74 166.38,109.91 166.09,109.62 164.79,109.62 164.54,109.88 164.54,110.72 164.41,110.84 160.83,110.84 160.81,110.87 156.44,110.87 155.9,111.41 155.9,113.51 153.67,115.74 153.67,120.24 154.86,120.24 156.51,121.89 156.64,121.89 158.04,123.29 158.04,125.73 159.94,125.73 159.94,124.16 159.56,124.16 159.56,122.78 160.12,122.78 160.2,122.71 ; 2 cut-outs
(no net) on TOP: 184.23,37.56 184.23,41.12 183.76,41.59 179.58,41.59 179.45,41.46 179.45,36.37 178.15,35.07 178.15,31.9 177.5,31.25 177.5,18.46 177.95,18.01 177.95,14.71 178.9,13.76 187.27,13.76 188.06,14.55 188.06,17.04 185.42,17.04 185.42,17.04 185.13,17.04 185.12,17.04 182.43,17.04 181.82,17.65 181.82,29.99 182.3,30.48 182.3,35.63
(no net) on TOP: 213.83,84.71 204.94,84.71 204.94,87.63 200.16,87.63 200.16,90.93 209.13,90.93 209.13,88.39 213.83,88.39
(no net) on TOP: 194.94,128.32 194.94,133.77 193.61,135.11 192.4,135.11 192.23,135.28 192.23,136.07 192.18,136.12 190.68,136.12 190.5,135.94 189.52,135.94 189.39,135.82 189.39,134.82 189.54,134.67 189.99,134.67 190.32,134.34 191.72,134.34 191.74,134.32 191.74,128.44 191.31,128.01 188.19,128.01 186.51,129.69 175.41,129.69 174.5,130.61 171.96,130.61 171.65,130.3 171.65,127.63 172.95,126.34 179.5,126.34 180.21,127.05 186.13,127.05 187.75,125.43 191.33,125.43 193.02,127.12 193.75,127.12
(no net) on TOP: 90.6,31.45 88.54,31.45 88.52,31.43 88.52,27.75 88.66,27.61 90.57,27.61 90.87,27.91 90.87,31.17
(no net) on TOP: 65.68,35.43 62.79,35.43 62.66,35.56 62.66,36.83 62.81,36.98 65.54,36.98 66.04,36.47 66.04,35.8
(no net) on TOP: 157.23,142.59 157.23,137.46 157.49,137.21 160.03,137.21 160.28,137.46 160.28,142.59
(no net) on TOP: 45.35,131.21 44.97,131.6 42.37,131.6 41.45,130.68 41.45,128.57 41.61,128.42 44.93,128.42 45.35,128.84
(no net) on TOP: 48.88,136.61 48.5,136.24 47.25,136.24 47.24,136.23 47.24,135.15 47.41,134.99 47.41,134.04 47.66,133.78 50.67,133.78 51.18,134.29 53.21,134.29 53.72,134.8 53.72,136.88 53.34,137.26 51.38,137.26 50.74,136.61
(no net) on TOP: 126.26,8.31 126.26,9.69 126.14,9.81 126.02,9.83 125.97,9.72 125.98,9.61 125.99,9.5 125.99,8.31 59.2,8.31 57.15,9.68 55.1,8.31 46.28,8.31 46.28,10.92 43.18,14.02 40.08,10.92 40.08,5.77 34.62,5.77 34.62,14 13.74,14 13.74,5.74 1.27,5.74 1.27,174.68 53.77,174.68 53.77,154.71 111.71,154.71 111.71,174.68 124.76,174.68 124.76,174.22 124.82,174.22 124.82,156.41 179.45,156.41 179.45,154.79 181.31,154.79 181.31,156.41 182.52,156.41 182.52,174.47 182.47,174.47 182.47,174.68 240.03,174.68 240.03,14 128.04,14 128.04,8.31 ; 177 cut-outs
(no net) on TOP: 214.25,149.51 214.25,145.03 214.45,144.83 217.71,144.83 218.52,144.02 221.26,144.02 221.95,143.33 221.95,140.92 223.27,139.6 225.96,139.6 227.08,140.72 227.08,142.39 228.45,143.76 232.23,143.76 232.89,144.43 232.89,148.61 232.11,149.4 226.52,149.4 225.76,150.16 223.47,150.16 222.2,148.9 222.2,147.28 221.96,147.04 218.63,147.04 218.31,147.36 218.31,149.01 217.55,149.77 214.5,149.77
(no net) on TOP: 63.76,54.14 65.85,54.14 66.01,54.29 66.01,55.1 65.51,55.6 63.78,55.6 63.48,55.3 63.48,54.42
(no net) on TOP: 65.86,62.15 65.72,62.29 63.46,62.29 63.16,62 63.16,58.35 63.4,58.12 65.74,58.12 65.86,58.24
(no net) on TOP: 200.25,58.09 206.09,58.09 206.77,57.4 210.1,57.4 210.23,57.28 210.23,51.78 209.93,51.49 204.35,51.49 204.11,51.73 204.11,53.63 203.34,54.4 200.61,54.4 200.16,54.85 200.16,58.01
(no net) on TOP: 193.04,55.17 193.04,53.95 193.26,53.73 195.31,53.73 195.47,53.9 195.47,55.17 195.34,55.3 193.17,55.3
(no net) on TOP: 174.7,52.03 174.05,52.03 174.02,52.06 174.02,52.41 173.78,52.65 169.83,52.65 169.72,52.76 169.72,53.75 169.91,53.93 173.8,53.93 173.95,53.78 173.95,53.05 174.04,52.96 174.58,52.96 174.7,52.84 174.7,52.03
(no net) on TOP: 156.04,143.66 156.04,137.31 156.02,137.31 156.02,134.39 155.47,133.85 155.47,132.61 155.14,132.28 151.89,132.28 151.89,134.85 152.27,135.23 153.47,135.23 153.87,135.64 153.87,136.14 153.5,136.52 153.5,138.61 153.27,138.83 151.79,138.83 151.53,139.09 150.37,139.09 149.69,138.42 147.84,138.42 147.58,138.67 146.87,138.67 146.74,138.8 146.74,139.06 146.89,139.21 147.59,139.21 147.64,139.26 150.31,139.26 150.46,139.42 150.46,141.13 150.7,141.37 151.59,141.37 152.23,142.01 153.5,142.01 153.5,143.68 153.82,144 155.7,144
(no net) on TOP: 152.27,126.61 152.27,120.7 151.76,120.19 151.76,116.86 151.64,116.74 150.37,116.74 147.1,120.01 147.1,124.27 146.63,124.74 145.61,124.74 145.43,124.92 145.43,126.61
(no net) on TOP: 26.04,150.42 21.21,150.42 20.95,150.16 20.95,148.64 21.21,148.39 25.91,148.39 26.16,148.64 26.16,150.29
(no net) on TOP: 181.16,64.18 177.86,64.18 177.86,61 181.16,61
(no net) on TOP: 214.08,85.21 216.24,85.21 216.24,87.12 217.1,87.12 217.1,90.29 215.86,90.29 215.86,90.93 211.54,90.93 211.54,88.77 214.08,88.77
(no net) on TOP: 218.41,63.04 218.41,67.39 221.8,67.39 222,67.2 222,63.42 221.62,63.04
(no net) on TOP: 61.11,128.61 59.06,128.61 58.42,127.97 58.42,123.07 59.19,122.31 59.19,122.06 59.44,121.8 59.82,121.8 60.07,122.06 60.07,122.44 60.33,122.69 60.71,122.69 61.11,123.09
(no net) on TOP: 12.93,125.79 8.64,125.79 6.72,123.88 4.35,123.88 4.22,123.75 4.22,121.14 6.38,121.14 6.51,121.27 12.74,121.27 13.44,121.97 13.44,125.28
(no net) on TOP: 174.53,139.81 174.53,136.37 174.08,135.91 171.48,135.91 170.69,136.7 170.69,139.75 171.2,140.26 174.08,140.26
(no net) on TOP: 184.95,56.96 184.95,60.77 185.07,60.89 185.33,60.89 185.58,61.15 185.58,63.05 185.71,63.18 186.17,63.18 186.36,62.99 186.36,62.58 186.39,62.57 186.47,62.55 186.47,60.26 186.98,59.75 186.98,58.86 187.61,58.23 187.61,56.96 188.97,56.96 189.99,55.93 189.99,53.92 188.6,52.53 184.2,52.53 184.15,52.58 181.79,52.58 181.79,52.58 178.59,52.58 178.11,53.06 178.11,55.44 178.38,55.71 180.99,55.71 182.24,56.96
(no net) on TOP: 25.76,135.47 28.1,135.47 28.19,135.56 28.19,137.21 27.94,137.46 27.36,137.46 27.36,137.69 27.18,137.87 26.12,137.87 25.76,137.52
(no net) on TOP: 63.42,31.27 65.66,31.27 65.86,31.47 65.86,34.04 65.72,34.18 63.46,34.18 63.16,33.89 63.16,31.54
(no net) on TOP: 223.73,80.9 223.73,88.01 226.15,88.01 226.15,80.9
(no net) on TOP: 205.31,136.7 210.44,141.83 210.44,144.7 210.79,145.06 212.13,145.06 212.86,144.32 217.5,144.32 218.49,143.33 219.37,143.33 219.46,143.24 219.46,142.04 218.31,140.89 218.31,138.46 211.76,131.9 211.76,130.35 211.05,129.64 206.73,129.64 205.31,131.06
(no net) on TOP: 214.08,116.46 216.24,116.46 216.24,118.36 217.1,118.36 217.1,122.17 211.29,122.17 211.29,120.39 214.08,120.39
(no net) on TOP: 223.73,101.72 223.73,108.84 226.15,108.84 226.15,101.72
(no net) on TOP: 213.67,149.54 214.28,150.15 217.53,150.15 218.69,148.98 221.59,148.98 221.79,149.18 221.79,151.77 221.51,152.05 213.44,152.05 212.27,150.89 212.27,148.3 210.74,146.77 210.74,145.68 210.86,145.57 213.22,145.57 213.67,146.01
(no net) on TOP: 88.01,29.51 86.52,29.51 86.32,29.71 84.92,29.71 84.85,29.64 84.85,27.25 84.91,27.2 85.4,27.2 85.83,27.63 87.74,27.63 88.01,27.9
