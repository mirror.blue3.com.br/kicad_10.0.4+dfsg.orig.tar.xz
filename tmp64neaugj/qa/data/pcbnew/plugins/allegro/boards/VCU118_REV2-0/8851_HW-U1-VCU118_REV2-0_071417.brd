# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYSCTLR_QSPI_IO3: length 51.1
  TOP w0.152: U111.A9 v5(21.9,133.37)
  03_SIG1 w0.113: v5(21.9,133.37) 21.5,132.97 21.5,131.61 21.74,131.37 22.56,131.37
  03_SIG1 w0.173: J110.1 23.21,130.72 22.56,131.37
  05_SIG2 w0.113: 13.91,127.95 14.18,128.22 14.3,128.34 14.3,130.34 14.54,130.57 17.27,130.57 17.5,130.8 17.5,131.14 17.74,131.37 18.09,131.37 18.3,131.58 18.3,131.96 18.52,132.17 18.87,132.17 19.1,132.4 19.1,132.74 19.34,132.97 21.5,132.97 v5(21.9,133.37)
  05_SIG2 w0.173: 13.91,127.95 13.59,127.63 13.59,126.62 13.42,126.45 11.78,126.45 11.61,126.27 11.61,125.97 11.78,125.8 13.37,125.8 13.59,125.58 13.59,125.28 13.42,125.11 11.78,125.11 11.61,124.93 11.61,124.59 11.83,124.37 13.42,124.37 13.59,124.2 13.59,123.86 13.42,123.68 12.5,123.68 12.33,123.51 12.33,123.16 12.5,122.99 13.42,122.99 13.59,122.82 13.59,117.93 13.84,117.68 13.84,116 v1(13.46,115.62)
  14_SIG4 w0.089: v1(24.26,137.11) 23.62,136.47 22.53,136.47 22.24,136.18 21.72,136.18 21.5,135.97 21.5,134.52 21.9,134.12 v5(21.9,133.37)
  BOTTOM w0.152: v1(24.26,137.11) 23.81,136.66 R776.2 ; v1(13.46,115.62) 13.59,115.75 13.84,115.75 14.16,115.43 U114.1
SYSCTLR_QSPI_SCLK: length 39.2
  TOP w0.152: U111.A10 v5(21.9,132.57)
  03_SIG1 w0.173: v5(21.9,132.57) 22.38,133.04 22.38,134.96 22.59,135.18 v5(22.7,135.18)
  05_SIG2 w0.113: 14.8,127.71 14.8,128.1 15.1,128.4 15.1,128.46 15.1,129.54 15.34,129.77 17.27,129.77 17.5,130 17.5,130.35 17.72,130.57 18.07,130.57 18.3,130.8 18.3,131.14 18.53,131.37 18.87,131.37 19.1,131.6 19.1,131.94 19.34,132.17 21.27,132.17 21.27,132.17 21.51,132.17 v5(21.9,132.57)
  05_SIG2 w0.173: 14.8,127.71 14.8,121.2 14.36,120.76 14.36,119.53 14.7,119.19 14.7,116.96 15.05,116.61 15.05,114.52 14.78,114.25 14.78,107.95 v1(15.49,107.24)
  BOTTOM w0.152: R775.1 v5(22.7,135.18) ; v1(15.49,107.24) 15.11,106.86 14.35,106.86 14.16,106.67 U114.16
SYSCTLR_QSPI_SS_B: length 41.9
  TOP w0.152: U111.A5 v5(21.9,137.37)
  05_SIG2 w0.173: v1(21.78,112.95) 21.78,109.75 22.05,109.48 22.59,109.48 22.94,109.83 22.94,113.97 23.94,114.97 23.94,119.14 25.98,121.19 25.98,122.66 26.77,123.44 27.81,123.44 28.78,124.41 28.78,125.37 28.04,126.11 28.04,131.32 27.23,132.13 27.23,134.57 25.71,136.09 24.36,136.09 23.67,136.78 22.49,136.78 v5(21.9,137.37)
  BOTTOM w0.152: U114.7 v1(21.78,112.95)
SYSCTLR_STAT_LED: length 23.1
  TOP w0.152: Q34.1 R97.1 1.94,135.25 2.29,134.9 3.28,134.9 3.71,134.47 v1(3.71,132.82) ; U111.H12 v5(15.5,130.97)
  03_SIG1 w0.173: v1(3.71,132.82) 5.21,134.31 5.99,134.31 6.48,134.8 6.48,135.11 6.81,135.43 7.91,135.43 9.47,133.86 15.75,133.86 16.12,133.49 16.12,131.59 v5(15.5,130.97)
SYSCTLR_TCK: length 32.6
  TOP w0.152: R857.2 J82.3 ; U111.G9 v5(17.1,133.37)
  07_SIG3 w0.173: v5(17.1,133.37) 16.58,132.85 16.58,127.05 15.43,125.9 15.43,120.67 15.82,120.28 15.82,119.04 14.86,118.08 14.86,109.63 12.37,107.13 J82.3
SYSCTLR_TDI: length 34.8
  TOP w0.152: U111.L7 v5(13.1,135.77) ; R855.2 J82.5
  07_SIG3 w0.113: v5(13.1,135.77) 12.7,135.37 12.7,134.82 11.71,133.83 11.38,133.83 11.1,133.56 11.1,132.36 10.91,132.17 9.3,132.17
  07_SIG3 w0.173: J82.5 9.57,112.21 5.17,116.62 5.17,124.85 7.18,126.86 7.18,127.47 6.53,128.12 6.53,129.74 8.95,132.17 9.3,132.17
SYSCTLR_TDO: length 30.4
  TOP w0.152: U111.L8 v5(13.1,134.97) ; R854.2 J82.6
  07_SIG3 w0.113: v5(13.1,134.97) 13.1,134.72 11.9,133.52 11.9,131.54 11.74,131.37 9.32,131.37
  07_SIG3 w0.173: J82.6 8.92,114.75 6.63,117.04 6.63,120.27 8,121.64 8,130.43 8.94,131.37 9.32,131.37
SYSCTLR_TMS: length 31.3
  TOP w0.152: R856.2 J82.4 ; U111.L9 v5(13.1,133.37)
  07_SIG3 w0.113: v5(13.1,133.37) 13.5,132.97 13.5,129.1 13.35,128.94
  07_SIG3 w0.173: J82.4 12.52,109.67 13.31,110.47 13.31,114.32 10.79,116.84 10.79,119.02 11.61,119.84 12.5,119.84 13.41,120.75 13.41,128.09 13.23,128.27 13.23,128.83 13.35,128.94
SYSCTLR_UART_RX: length 75.2
  TOP w0.152: U111.B15 v5(21.1,128.57)
  07_SIG3 w0.173: v1(20.81,63.57) 20.81,65.01 21.42,65.62 21.42,76.33 23.17,78.08 23.57,78.48 23.57,85.15 21.64,87.07 19.68,87.07 18.26,88.49 18.26,89.57 18.61,89.92 18.61,93.59 18.8,93.78 19.86,93.78 20.07,93.98 20.07,94.69 19.81,94.95 19.38,94.95 19.1,95.23 19.1,115.47 20.65,117.02 20.65,118.87 20.04,119.48 20.04,120.77 20.6,121.33 20.6,125.5 22.02,126.92 22.02,127.87 21.72,128.17 21.5,128.17 v5(21.1,128.57)
  BOTTOM w0.152: Q56.2 v1(20.81,63.57)
SYSCTLR_UART_TX: length 75.3
  TOP w0.152: U111.C12 v5(20.3,130.97)
  07_SIG3 w0.113: 19.92,128.19 19.91,128.2 19.91,130.57 v5(20.3,130.97)
  07_SIG3 w0.173: v1(18.78,63.06) 18.78,63.94 20.74,65.91 20.74,76.62 22.89,78.76 22.89,81.64 22.39,82.13 21.55,82.13 20.49,83.19 20.49,85.18 16.91,88.77 16.91,91.79 17.3,92.18 17.3,116.9 18.4,118 18.4,120.09 19.92,121.61 19.92,128.19
  BOTTOM w0.152: Q57.2 v1(18.78,63.06)
SYSCTLR_VREF: length 19.8
  TOP w0.381: U111.H7 v5(15.5,135.77)
  07_SIG3 w0.381: v1(27.32,141.15) v1(26.4,141.15) 26.4,141.18 25.24,142.34 16.66,142.34 16.2,141.88 16.2,136.47 v5(15.5,135.77)
  BOTTOM w0.381: v5(15.5,135.77) 15.9,135.38 C1567.1
SYSMON_AGND: length 2.5
  TOP w0.381: v2(116.24,58.84) 116.74,59.34 U1.AB17
  BOTTOM w0.254: v2(116.24,58.84) 116.72,58.36 C2.2
SYSMON_SCL: length 286.9
  TOP w0.152: v2(129.24,59.84) U1.AP18
  14_SIG4 w0.089: v2(129.24,59.84) 129.84,59.24 129.84,47.43 129.81,47.39 129.81,45.11 129.84,45.07 129.84,42.16 128.04,40.36 127.86,40.36 122.65,35.15 122.65,33.56 116.86,27.76 116.86,21.93 117.66,21.13 117.66,19.36 115.04,16.74 110.8,16.74 108.7,14.64 105.5,14.64 105.18,14.96 101.24,14.96 100.86,14.58 100.48,14.58 100.47,14.59 92.9,14.59 92.03,15.46 88.71,15.46 87.67,14.41 84.16,14.41 82.77,15.8 80.35,15.8 79.68,15.13 67.11,15.13 66.27,15.96 53.18,15.96 51.67,14.45 46.71,14.45 43.45,17.71 43.45,19.46 39.58,23.34 39.58,32.69 39.87,32.98 39.87,32.98 40.1,33.22 40.1,35.11 39.23,35.99 39.23,38.84 v1(38.43,39.64)
  18_SIG6 w0.089: v1(38.43,39.64) 39.06,39.64 39.15,39.55 39.15,39.12 39.04,39.02 36.16,39.02 35.93,39.24 35.93,40.52 36.13,40.71 36.91,40.71 37.05,40.85 37.05,41.37 36.87,41.55 36.1,41.55 35.93,41.72 35.93,56.17 32.43,59.67 32.43,68.26 31.81,68.88 31.8,68.88 31.5,69.18 31.5,69.19 30.76,69.94 30.76,86.13 37.85,93.22 38.6,93.22 44.92,99.54 51.05,99.54 52.6,101.09 52.6,127.02 54.83,129.24 54.83,130.65 55.39,131.22 55.39,140.86 58.18,143.64 58.53,143.64 58.71,143.46 v1(59.85,143.46)
  BOTTOM w0.152: R618.2 v1(59.85,143.46) 58.93,143.46 57.8,144.59 U28.18
SYSMON_SDA: length 286.1
  TOP w0.152: U1.AP17 v2(129.24,58.84)
  14_SIG4 w0.089: v1(40.91,39.55) 40.28,39.55 39.73,39 39.73,36.2 40.61,35.32 40.61,33.01 40.08,32.48 40.08,23.52 43.94,19.66 43.94,17.91 46.93,14.92 51.47,14.92 52.98,16.43 66.46,16.43 67.3,15.6 79.48,15.6 80.16,16.27 82.97,16.27 84.35,14.88 87.48,14.88 88.52,15.93 92.23,15.93 93.09,15.06 100.67,15.06 101.07,15.47 105.36,15.47 105.71,15.11 108.51,15.11 110.61,17.21 114.85,17.21 117.19,19.56 117.19,20.93 116.29,21.84 116.29,27.91 122.15,33.77 122.15,35.38 127.55,40.79 128.06,40.79 129.67,42.39 129.67,45 129.63,45.03 129.63,47.47 129.67,47.5 129.67,58.88 129.53,59.02 129.42,59.02 v2(129.24,58.84)
  18_SIG6 w0.089: v1(40.91,39.55) 40.3,39.55 39.3,38.55 35.96,38.55 35.46,39.05 35.46,55.98 31.96,59.48 31.96,68.05 30.29,69.73 30.29,86.33 37.65,93.69 38.41,93.69 44.73,100.01 50.86,100.01 52.13,101.29 52.13,127.21 54.36,129.44 54.36,130.85 54.92,131.41 54.92,141.06 57.98,144.11 58.54,144.11 59.01,144.58 v1(59.85,144.58)
  BOTTOM w0.152: U28.17 58.34,145.24 59,144.58 v1(59.85,144.58) R617.2
SYSMON_VCCADC: length 7.3
  TOP w0.381: U111.F7 v5(17.9,135.77) ; v1(28.58,138.4) 28.42,138.24 27.26,138.24 U155.1 ; v1(28.93,132.42) 28.93,133.28 28.66,133.55 L60.2 27.99,133.07 v1(27.99,132.41)
  BOTTOM w0.381: v1(28.58,138.4) 28.4,138.23 C1579.1
SYSMON_VN: length 44.8
  TOP w0.104: v2(119.24,58.84) 118.74,59.34 U1.AD17
  07_SIG3 w0.094: 126.87,41.41 126.87,41.43 126.82,41.48 126.82,42.48 126.81,42.49 126.81,57.22 126.59,57.44 118.8,57.44 118.21,58.03 118.21,59.49 118.34,59.65 118.58,59.69 119.03,59.46 v2(119.24,58.84)
  07_SIG3 w0.135: v1(125.65,37.16) 126.22,37.16 126.3,37.08 126.72,37.08 127.5,37.86 127.5,39.26 126.87,39.89 126.87,41.41
  BOTTOM w0.104: v1(125.65,37.16) 125.68,37.19 129.77,37.19 132.03,34.93 132.03,32.63 R560.1
SYSMON_VP: length 44.5
  TOP w0.104: v2(117.24,59.84) U1.AC18
  07_SIG3 w0.094: 126.59,41.41 126.59,41.43 126.64,41.48 126.64,42.4 126.63,42.41 126.63,57.14 126.52,57.26 118.73,57.26 118.03,57.96 118.03,59.05 v2(117.24,59.84)
  07_SIG3 w0.135: v2(126.31,37.82) 126.31,37.46 126.41,37.36 126.6,37.36 127.22,37.98 127.22,39.14 126.59,39.77 126.59,41.41
  BOTTOM w0.104: R547.2 R548.1 132.26,32.63 132.26,35.03 129.87,37.42 126.29,37.42 126.19,37.52 126.19,37.7 v2(126.31,37.82)
USB_FLTR: length 12.8
  TOP w0.254: U34.7 14.91,65 v1(15.04,64.87) 15.41,65.23 U34.8
  TOP w0.381: C891.1 9.19,66.12 v1(8.79,66.52) ; C346.1 16.06,64.42 15.62,64.87 v1(15.04,64.87) ; L34.1 v1(8.71,73.33)
  BOTTOM w0.381: U131.1 9.02,66.76 v1(8.79,66.52) ; L34.1 v1(8.71,73.33) 8.71,74.55 8.33,74.93 C57.1 ; v1(9.07,68.73) 9.07,68.33 9.34,68.06 U131.3
USB_JTAG_DATA_N: length 109.3
  TOP w0.132: v1(5.88,84.32) 5.61,84.05 5.21,84.05 5,84.27 J106.2 ; U115.12 24.15,159.85 22.53,161.47 20.83,161.47 v1(20.57,161.72)
  14_SIG4 w0.102: v1(5.88,84.32) 5.88,84.11 6.1,83.89 6.32,83.89 6.51,84.08 6.74,84.08 6.93,83.89 7.08,83.89 7.33,84.14 7.53,84.14 7.78,83.89 8.9,83.89 9.98,84.97 9.98,87.81 3.69,94.1 3.69,126.34 5.09,127.75 5.09,140.72 8.54,144.17 8.54,150.09 10.56,152.11 20.64,152.11 21.9,153.38 21.9,162.22 21.71,162.41 20.68,162.41 20.57,162.31 v1(20.57,161.72)
  BOTTOM w0.132: X7.2 7.23,83.58 7.14,83.49 6.94,83.49 6.46,83.97 6.01,83.97 5.88,84.1 v1(5.88,84.32)
USB_JTAG_DATA_P: length 109.4
  TOP w0.132: U115.13 24.15,164.36 22.66,162.86 v1(20.32,162.86) ; v1(5.82,83.49) 5.82,83.59 5.61,83.79 5.16,83.79 4.98,83.62 J106.3
  14_SIG4 w0.102: v1(5.82,83.49) 5.99,83.66 9,83.66 10.21,84.88 10.21,87.9 3.92,94.2 3.92,126.24 5.32,127.65 5.32,140.63 8.76,144.07 8.76,150 10.65,151.89 20.73,151.89 22.13,153.28 22.13,162.31 21.8,162.64 20.54,162.64 v1(20.32,162.86)
  BOTTOM w0.132: X7.1 7.26,83.08 7.11,83.24 6.83,83.24 6.35,83.72 5.95,83.72 5.82,83.59 v1(5.82,83.49)
USB_JTAG_FLTR: length 4.6
  TOP w0.381: L93.1 v1(8.71,86.16)
  BOTTOM w0.381: C1583.1 8.33,87.76 8.71,87.38 v1(8.71,86.16) L93.1
USB_JTAG_GND: length 4.8
  TOP w0.305: J106.5 v1(5.21,82.32) 5.44,82.09 5.94,82.09 L94.2
  BOTTOM w0.381: C1582.2 3.48,82.73 3.67,82.54 4.99,82.54 v1(5.21,82.32)
USB_JTAG_VBUS: length 10.5
  TOP w0.305: L93.2 6.06,85.39 5.76,85.08 v1(5.39,85.08) 5.22,84.92 J106.1
  BOTTOM w0.254: 8.38,82.85 X7.6
  BOTTOM w0.381: 4.62,84.32 C1582.1 ; 4.62,84.32 v1(5.39,85.08) ; 4.62,84.32 4.62,83.79 6.07,82.33 7.86,82.33 8.38,82.85
USB_POWERED_VIO: length 10.2
  TOP w0.203: v1(13.39,66.62) 13.36,66.62 13.36,66.75 13.66,67.04 U34.5
  TOP w0.381: C892.1 11.76,65.53 v1(11.68,65.46)
  BOTTOM w0.381: v1(12.22,69.34) 11.92,69.65 R860.1 ; v1(11.68,65.46) 11.68,66.19 11.8,66.31 U131.5 12.65,66.76 12.78,66.62 v1(13.39,66.62) 13.39,66.93 13.73,67.28 C543.1 ; R498.2 14.9,64.07 v1(14.2,64.77) ; v1(10.04,72.98) R858.2
USB_UART_CTS: length 209.4
  TOP w0.152: U1.BB22 v2(137.24,63.84)
  05_SIG2 w0.173: v1(20.14,66.58) 20.75,66.58 20.94,66.78 20.94,70.46 20.62,70.79 19.01,70.79 18.8,71 18.8,71.54 19.08,71.82 22.7,71.82 22.87,71.65 22.87,70.46 23.04,70.29 23.56,70.29 23.73,70.46 23.73,71.65 23.91,71.82 24.42,71.82 24.6,71.65 24.6,70.46 24.77,70.29 25.29,70.29 25.46,70.46 25.46,71.65 25.63,71.82 26.15,71.82 26.32,71.65 26.32,70.46 26.5,70.29 27.01,70.29 27.19,70.46 27.19,71.65 27.36,71.82 27.88,71.82 28.05,71.65 28.05,70.46 28.22,70.29 28.74,70.29 28.91,70.46 28.91,71.65 29.09,71.82 29.6,71.82 29.78,71.65 29.78,69.72 29.49,69.43 22.1,69.43 21.9,69.23 21.9,68.74 22.08,68.56 30.11,68.56 30.29,68.39 30.29,66.91 30.46,66.74 30.98,66.74 31.15,66.91 31.15,68.39 31.32,68.56 31.84,68.56 32.01,68.39 32.01,66.91 32.19,66.74 32.7,66.74 32.88,66.91 32.88,68.39 33.05,68.56 34.94,68.56 35.31,68.93 35.31,70.78 35.6,71.08 37.21,71.08 39.04,72.9 39.04,73.24 39.68,73.88 41.72,73.88 43.03,72.57 44.1,72.57 44.27,72.74 44.27,73.71 44.45,73.88 44.96,73.88 45.14,73.71 45.14,72.45 45.32,72.27 45.82,72.27 46,72.45 46,73.71 46.17,73.88 46.69,73.88 46.86,73.71 46.86,71.43 47.11,71.19 47.47,71.19 47.67,71.39 47.67,72.27 47.97,72.57 49.9,72.57 50.77,71.7 50.77,69.55 50.97,69.35 51.46,69.35 51.63,69.52 51.63,71.97 51.81,72.15 52.33,72.15 52.5,71.97 52.5,69.08 52.67,68.91 53.19,68.91 53.36,69.08 53.36,71.97 53.53,72.15 54.05,72.15 54.23,71.97 54.23,69.08 54.4,68.91 54.92,68.91 55.09,69.08 55.09,70.07 55.26,70.24 56.91,70.24 57.08,70.41 57.08,70.93 56.91,71.11 55.26,71.11 55.09,71.28 55.09,71.97 55.26,72.15 56.12,72.15 57.55,73.57 62.72,73.57 65.21,76.06 v1(65.89,76.06)
  BOTTOM w0.113: 133.55,62.34 133.65,62.24 134.64,62.24 134.84,62.44 135.4,62.44 135.64,62.68 135.64,63.1 135.98,63.44 136.84,63.44 v2(137.24,63.84)
  BOTTOM w0.152: v1(20.14,66.58) Q54.2 ; v1(65.89,76.06) 68.62,73.33 80.61,73.33 82.14,71.8 83.45,71.8 83.87,71.38 83.87,68.55 84.77,67.65 85.82,67.65 86.9,68.73 91.64,68.73 93.98,66.4 112.55,66.4 112.75,66.6 112.75,67.08 113,67.34 113.43,67.34 113.74,67.65 113.74,68.05 114.03,68.33 117.57,68.33 118.06,67.84 118.06,67.36 119.02,66.4 128.37,66.4 129.02,65.75 129.53,65.75 129.97,65.31 130.51,65.31 130.72,65.1 130.72,64.6 130.96,64.36 131.45,64.36 131.72,64.08 131.72,63.66 132.04,63.34 132.44,63.34 132.74,63.04 132.74,62.64 133.04,62.34 133.55,62.34
USB_UART_DATA_N: length 17.8
  TOP w0.132: v1(12.95,67.4) 13.21,67.67 13.5,67.67 13.62,67.54 U34.4 ; v1(5.88,71.49) 5.78,71.49 5.54,71.25 5.19,71.25 5,71.44 J4.2
  07_SIG3 w0.137: v1(12.95,67.4) 12.67,67.68 11.35,67.68 10.87,68.16 10.87,69.72 10.21,70.38 7.92,70.38 7.27,69.73 5.66,69.73 4.96,70.43 4.96,70.95 5.23,71.22 5.42,71.22 5.56,71.21 v1(5.88,71.49)
  BOTTOM w0.132: X1.2 7.23,70.76 7.11,70.63 6.97,70.63 6.4,71.2 6.17,71.2 v1(5.88,71.49)
USB_UART_DATA_P: length 17.8
  TOP w0.132: U34.3 13.62,68.04 13.5,67.92 13.21,67.92 v1(12.95,68.18) ; v1(5.82,70.66) 5.48,70.99 5.2,70.99 5,70.79 J4.3
  07_SIG3 w0.137: v1(5.82,70.66) 5.54,70.99 5.41,71 5.32,71 5.18,70.86 5.18,70.53 5.76,69.95 7.17,69.95 7.83,70.61 10.3,70.61 11.1,69.81 11.1,68.25 11.44,67.91 11.65,67.91 11.77,68.03 11.77,68.31 11.89,68.43 12.06,68.43 12.18,68.31 12.18,68.05 12.33,67.91 12.67,67.91 v1(12.95,68.18)
  BOTTOM w0.132: v1(5.82,70.66) 6.1,70.94 6.3,70.94 6.86,70.38 7.09,70.38 7.21,70.26 X1.1
USB_UART_RTS: length 207.2
  TOP w0.152: v2(135.24,67.84) 134.74,67.34 U1.AY25
  03_SIG1 w0.173: v1(17.67,72.79) 19.23,74.35 24.46,74.35 30.56,68.25 30.56,44.45 31.6,43.41 31.6,32.11 46.74,16.97 47.73,16.97 48.26,17.5 51.1,17.5 v1(51.66,16.94)
  16_SIG5 w0.089: v1(100.68,22.61) 101.53,23.45 102.76,23.45 104.45,25.14 108.08,25.14 109.39,26.45 109.39,35.95 113.74,40.29 113.74,59.07 114.02,59.35 114.45,59.35 114.74,59.64 114.74,65.05 116.03,66.34 116.44,66.34 116.74,66.64 116.74,67.05 117.03,67.34 118.03,67.34 119.03,68.34 130.22,68.34 130.22,68.34 130.44,68.34 130.74,68.64 130.74,69.07 130.91,69.24 133.57,69.24 133.74,69.08 133.74,68.58 133.97,68.34 134.74,68.34 v2(135.24,67.84)
  20_SIG7 w0.089: v1(100.68,22.61) 93.42,22.61 90.96,20.14 80.66,20.14 79.21,18.7 58.12,18.7 56.74,17.32 52.04,17.32 v1(51.66,16.94)
  BOTTOM w0.152: Q55.2 v1(17.67,72.79)
USB_UART_RX: length 207.8
  TOP w0.152: U1.BB21 v2(137.24,62.84)
  05_SIG2 w0.173: v1(66.24,74.88) 66.56,75.19 66.56,76.35 66.13,76.78 64.98,76.78 62.46,74.26 57.11,74.26 55.6,72.76 50.76,72.76 49.02,74.49 42.12,74.49 41.6,75.02 39.39,75.02 38.31,73.94 29.93,73.94 29.75,74.11 29.75,74.63 29.93,74.8 36.56,74.8 36.73,74.97 36.73,75.4 36.47,75.66 29.93,75.66 29.75,75.84 29.75,76.36 29.93,76.53 36.95,76.53 37.12,76.7 37.12,77.22 36.95,77.39 29.93,77.39 29.75,77.56 29.75,78.08 29.93,78.26 39.52,78.26 39.69,78.43 39.69,78.95 39.52,79.12 29.06,79.12 28.89,78.95 28.89,74.11 28.72,73.94 22.38,73.94 22.2,74.11 22.2,75.49 22.03,75.66 20.17,75.66 19.99,75.49 19.99,74.97 20.17,74.8 21.17,74.8 21.34,74.63 21.34,74.11 21.17,73.94 16.12,73.94 15.77,73.59 v1(15.77,72.79)
  BOTTOM w0.113: 134.41,61.34 134.75,61.68 134.75,62.02 134.97,62.24 135.49,62.24 135.84,62.59 135.84,63.02 136.06,63.24 136.84,63.24 v2(137.24,62.84)
  BOTTOM w0.152: 134.41,61.34 132.94,61.34 132.74,61.55 132.74,62.04 132.45,62.33 132.05,62.33 131.74,62.64 131.74,63.04 131.44,63.34 131.04,63.34 130.74,63.64 130.74,64.03 130.42,64.34 130.04,64.34 129.73,64.65 129.73,65.07 129.39,65.41 128.86,65.41 128.25,66.01 118.77,66.01 117.45,67.34 114.03,67.34 113.74,67.05 113.74,66.62 113,65.89 93.42,65.89 89.65,62.12 86.55,62.12 86.03,62.64 85.06,62.64 84.66,63.04 84.66,66.88 83.41,68.14 83.41,69.88 81.38,71.91 69.22,71.91 v1(66.24,74.88) ; Q52.2 v1(15.77,72.79)
USB_UART_TX: length 184.3
  TOP w0.152: U1.AW25 133.74,67.34 v2(134.24,67.84)
  05_SIG2 w0.173: v1(33.18,70.74) 32.13,70.74 30.07,72.8 18.91,72.8 18.14,72.03 14.62,72.03 v1(13.86,72.79)
  14_SIG4 w0.089: v2(121.24,41.84) 119.31,41.84 118.68,42.47 118.68,44 119.03,44.34 119.48,44.34 119.74,44.59 119.74,46.06 120.02,46.35 120.45,46.35 120.74,46.64 120.74,51.05 121.03,51.34 121.04,51.34 121.05,51.34 122.49,51.34 122.74,51.59 122.74,52.06 123.01,52.33 123.03,52.33 123.03,52.33 123.57,52.33 123.74,52.51 123.74,62.02 123.75,62.02 123.75,62.05 124.03,62.33 124.44,62.33 124.44,62.33 124.54,62.33 124.74,62.54 124.74,63.12 124.97,63.35 125.48,63.35 125.73,63.6 125.73,64.11 125.96,64.34 126.47,64.34 126.74,64.61 126.74,65.12 126.97,65.35 127.2,65.35 127.74,65.9 127.74,68.06 128.03,68.35 133.73,68.35 v2(134.24,67.84)
  BOTTOM w0.152: v2(121.24,41.84) 85.49,41.84 82.68,39.04 37.88,39.04 36.58,40.33 36.58,61.79 33.99,64.38 33.99,66.09 31.32,68.76 31.32,70.08 31.98,70.74 v1(33.18,70.74) ; Q53.2 v1(13.86,72.79)
USB_VBUS: length 10.5
  TOP w0.305: L34.2 6.06,72.56 5.76,72.26 v1(5.39,72.26)
  TOP w0.381: J4.1 5.22,72.09 v1(5.39,72.26)
  BOTTOM w0.254: X1.6 8.38,70.02
  BOTTOM w0.381: 4.62,71.49 4.66,71.49 4.66,70.9 6.06,69.51 7.86,69.51 8.38,70.02 ; 4.62,71.49 C55.1 ; 4.62,71.49 v1(5.39,72.26)
USB_VBUS_GND: length 4.8
  TOP w0.381: L35.2 5.68,68.99 v1(5.19,69.47) 5.17,69.49 J4.5
  BOTTOM w0.381: C55.2 3.48,69.95 3.76,69.67 4.99,69.67 v1(5.19,69.47)
USER_SI570_0_CLOCK_SCL: length 377.7
  18_SIG6 w0.089: v1(59.52,145.54) 59.53,145.54 59.81,145.82 60.43,145.82 61.12,146.51 61.12,146.9 61.11,149.18 58.05,152.24 52.92,152.24 52.08,151.39 52.08,149.34 50.13,147.39 48.68,147.39 47.56,146.27 44.84,146.27 43.76,145.19 43.76,133.25 44.48,132.54 44.48,130.66 43.03,129.21 39.55,129.21 34.48,124.14 34.48,122.17 29.71,117.4 29.71,114.8 28.46,113.55 23.76,113.55 13.46,103.24 13.46,89.31 14.43,88.34 14.43,75.01 15.79,73.65 18.73,73.65 20.72,71.66 20.72,67.03 20.72,66.3 23,64.01 25.07,64.01 27.88,61.21 27.88,24.58 32.83,19.63 42.95,19.63 43.47,19.12 43.47,17.22 46.46,14.23 51.67,14.23 52.81,15.37 73.5,15.37 74.1,14.77 78.44,14.77 80.11,16.45 92.23,16.45 92.61,16.83 111,16.83 113.19,14.63 116.8,14.63 117.08,14.9 120.59,14.9 120.72,14.78 125.83,14.78 127.15,16.09 129.77,16.09 130.04,16.36 130.68,17 135.77,17 138,19.23 139.32,19.23 140.33,18.23 140.33,15.75 142.04,14.05 152.14,14.05 153.44,15.35 160.53,15.35 162.44,17.26 169.94,17.26 174.12,21.44 180.35,21.44 184.91,16.88 197.19,16.88 197.5,16.57 198.89,16.57 199.44,16.03 200,16.03 200.9,16.93 203.37,16.93 204.64,18.2 v1(205.31,18.2)
  BOTTOM w0.152: U28.16 59.17,145.89 v1(59.52,145.54) 59.69,145.71 R614.2 ; U18.8 v1(205.31,18.2)
USER_SI570_0_CLOCK_SDA: length 376.6
  18_SIG6 w0.089: v1(59.85,146.82) 59.85,146.38 59.94,146.29 60.24,146.29 60.64,146.7 60.64,148.98 57.86,151.77 53.12,151.77 52.55,151.2 52.55,149.14 50.32,146.92 48.88,146.92 47.75,145.8 45.64,145.8 45.06,145.21 45.06,144.73 44.32,143.99 44.32,133.36 44.95,132.73 44.95,130.46 43.22,128.74 39.74,128.74 34.95,123.95 34.95,121.97 30.18,117.2 30.18,114.6 28.65,113.08 23.96,113.08 13.93,103.05 13.93,89.5 14.9,88.54 14.9,75.2 15.98,74.12 18.93,74.12 21.19,71.86 21.19,66.49 23.2,64.48 25.28,64.48 28.35,61.41 28.35,24.78 33.03,20.1 43.15,20.1 43.94,19.31 43.94,17.41 46.65,14.7 51.47,14.7 52.62,15.84 73.69,15.84 74.3,15.24 78.21,15.24 79.88,16.92 92.03,16.92 92.41,17.3 111.19,17.3 113.39,15.1 116.61,15.1 116.88,15.37 120.79,15.37 120.91,15.25 125.64,15.25 126.95,16.56 129.57,16.56 130.48,17.47 135.57,17.47 137.53,19.43 137.81,19.7 139.52,19.7 140.8,18.42 140.8,15.95 142.23,14.52 151.95,14.52 153.25,15.82 160.33,15.82 162.24,17.73 169.59,17.73 173.81,21.95 180.51,21.95 185.11,17.35 197.41,17.35 197.71,17.04 198.98,17.04 199.34,17.4 203.17,17.4 204.04,18.27 204.04,19.35 203.62,19.77 202.8,19.77 202.42,19.4 v1(202.42,18.2)
  BOTTOM w0.152: U18.7 v1(202.42,18.2) ; U28.15 59.57,146.54 v1(59.85,146.82) R613.2
USER_SI570_1_CLOCK_SCL: length 233.5
  TOP w0.152: v1(113.97,29.52) 114.49,29 U32.8 ; R604.2 51.52,144.27 v1(52.37,143.41)
  07_SIG3 w0.173: v1(52.37,143.41) 52.27,143.31 51.18,143.31 50.35,142.47 50.35,141.06 49.7,140.4 49.7,134.66 51.44,132.92 51.44,128.32 52.33,127.43 52.33,114.91 52.68,114.55 52.68,93.3 44.67,85.29 43.21,85.29 37.41,79.49 35.95,79.49 30.15,73.7 30.15,68.36 32.15,66.36 32.15,56.21 43.67,44.68 43.67,41.41 43.37,41.12 43.37,39.89 v1(43.28,39.8)
  14_SIG4 w0.089: v1(113.97,29.52) 115.58,27.91 115.58,23.41 111.56,19.39 111.28,19.39 111.28,19.39 110.89,19.39 110.1,19.39 107.45,16.74 101.39,16.74 100.95,17.18 92.85,17.18 92.22,16.55 88.46,16.55 88.27,16.74 79.64,16.74 79.35,17.03 74.74,17.03 74.11,16.4 67.17,16.4 66.66,16.9 53.1,16.9 52.37,17.63 48.8,17.63 47.82,16.65 45.91,16.65 44.42,18.13 44.42,19.99 43.36,21.06 43.36,33.68 43.38,33.71 43.38,34.34 43.36,34.37 43.36,36.63 43.4,36.67 43.4,39.69 v1(43.28,39.8)
  BOTTOM w0.152: v1(52.37,143.41) 52.26,143.29 U28.5
USER_SI570_1_CLOCK_SDA: length 232.7
  TOP w0.152: v1(52.35,142.67) 52.15,142.87 R603.2 ; U32.7 114.49,23.94 v1(114.22,24.21)
  07_SIG3 w0.173: v1(52.35,142.67) 52.27,142.75 51.41,142.75 50.95,142.29 50.95,140.81 50.25,140.11 50.25,134.89 51.99,133.15 51.99,128.55 52.88,127.66 52.88,115.14 53.23,114.78 53.23,93.07 44.9,84.74 43.5,84.74 37.66,78.9 36.19,78.9 30.75,73.45 30.75,68.54 32.7,66.59 32.7,56.44 44.22,44.91 44.22,41.19 43.93,40.89 43.93,40.12 v1(44.22,39.83)
  14_SIG4 w0.089: v1(44.22,39.83) 44.03,39.64 44.03,39.3 44.12,39.21 45.14,39.21 45.23,39.12 45.23,38.95 45.14,38.86 44.12,38.86 44.03,38.77 44.03,38.59 44.12,38.5 45.02,38.5 45.11,38.42 45.11,38.24 45.02,38.15 44.12,38.15 44.03,38.06 44.03,37.88 44.12,37.79 44.86,37.79 44.95,37.7 44.95,37.52 44.86,37.43 44.12,37.43 44.03,37.35 44.03,37.17 44.12,37.08 44.86,37.08 44.95,36.99 44.95,36.81 44.86,36.72 44.12,36.72 44.03,36.63 44.03,36.63 43.89,36.49 43.89,36.47 43.84,36.42 43.84,34.57 43.87,34.54 43.87,33.5 43.84,33.48 43.84,21.27 44.91,20.2 44.91,18.34 46.13,17.12 47.62,17.12 48.65,18.14 52.53,18.14 53.3,17.37 66.85,17.37 67.36,16.87 73.91,16.87 74.55,17.5 79.54,17.5 79.83,17.21 88.48,17.21 88.67,17.02 92.02,17.02 92.66,17.65 101.14,17.65 101.58,17.21 107.26,17.21 109.91,19.86 111.37,19.86 114.83,23.32 114.83,23.89 114.51,24.21 v1(114.22,24.21)
  BOTTOM w0.152: U28.4 52.32,142.64 v1(52.35,142.67)
USER_SI570_2_CLOCK_SCL: length 148.1
  TOP w0.152: U80.16 134.87,121.52 v1(134.61,121.26) ; U38.8 v1(95.52,24.85)
  07_SIG3 w0.173: v1(134.61,121.26) 134.8,121.45 135.05,121.45 135.81,120.69 135.81,118.96 136.25,118.52 136.25,114.01 136.14,113.9 136.14,110.26 138.43,107.97 140.87,107.97 v1(141,107.85)
  14_SIG4 w0.089: v1(141,107.85) 141.37,107.85 141.55,108.03 141.55,108.92 141,109.47 138.93,109.47 136.97,107.51 136.97,106.99 136.97,106.99 136.97,94.98 133.14,91.15 133.14,91.05 131.47,89.38 131.1,89.38 130.85,89.12 130.85,88.57 130.65,88.38 130.01,88.38 129.66,88.03 129.66,87.61 129.37,87.32 129.02,87.32 128.74,87.04 128.74,86.54 128.57,86.37 128.11,86.37 127.81,86.06 127.81,84.6 127.64,84.42 127.64,81.48 127.88,81.24 128.4,81.24 128.64,81.01 128.64,80.48 128.88,80.24 129.4,80.24 129.64,80.01 129.64,79.58 129.98,79.24 130.4,79.24 130.64,79.01 130.64,78.58 130.98,78.24 131.4,78.24 131.64,78.01 131.64,75.53 131.47,75.36 131.04,75.36 130.74,75.06 130.74,73.6 130.48,73.34 126.03,73.34 125.74,73.05 125.74,72.64 125.44,72.34 125.03,72.34 124.74,72.05 124.74,71.64 124.44,71.34 124.03,71.34 123.74,71.05 123.74,67.64 123.44,67.34 122.99,67.34 122.74,67.09 122.74,66.64 121.59,65.49 121.15,65.49 120.74,65.09 120.74,64.64 120.44,64.34 119.99,64.34 119.74,64.09 119.74,63.64 119.44,63.34 118.99,63.34 118.68,63.03 118.68,62.71 118.09,62.12 118.09,58.63 117.81,58.34 117.03,58.34 116.74,58.05 116.74,57.64 116.44,57.34 116.03,57.34 115.74,57.05 115.74,56.61 115.47,56.34 115.03,56.34 114.74,56.05 114.74,52.64 114.44,52.34 114.03,52.34 113.74,52.05 113.74,52.01 113.74,52 113.74,49.65 113.43,49.34 113.03,49.34 112.74,49.05 112.74,47.53 112.55,47.34 112.11,47.34 111.74,46.97 111.74,46.69 111.39,46.34 111.04,46.34 110.74,46.05 110.74,44.73 110.35,44.34 110,44.34 109.74,44.08 109.74,42.6 100.2,33.06 100.2,31.74 98.58,30.13 98.58,28.8 95.62,25.83 95.62,24.94 v1(95.52,24.85)
  BOTTOM w0.152: R190.2 135.61,123.26 135.12,122.77 133.38,122.77 133.16,122.54 133.16,120.95 133.38,120.73 133.73,120.73 133.96,120.95 133.96,121.19 134.04,121.26 v1(134.61,121.26)
USER_SI570_2_CLOCK_SDA: length 147.5
  TOP w0.152: U80.15 v1(134.59,122.17) ; U38.7 v1(96.35,24.85)
  07_SIG3 w0.173: v1(140.92,108.66) 140.8,108.54 138.72,108.54 136.74,110.52 136.74,113.69 136.8,113.76 136.8,118.76 136.42,119.15 136.42,120.9 135.23,122.08 135.23,122.8 135.09,122.94 134.55,122.94 134.42,122.81 134.42,122.35 v1(134.59,122.17)
  14_SIG4 w0.089: v1(96.35,24.85) 96.25,24.95 96.25,25.57 99.21,28.54 99.21,30.02 101.34,32.15 101.34,33.47 110.03,42.17 110.4,42.17 110.74,42.51 110.74,43.96 110.74,43.96 110.74,44.05 111.04,44.34 111.44,44.34 111.73,44.64 111.73,44.67 111.74,44.68 111.74,45.97 111.74,45.97 111.74,46.05 112.03,46.34 112.46,46.34 112.73,46.62 112.73,47.11 112.97,47.34 113.49,47.34 113.73,47.59 113.73,49.19 113.89,49.35 114.56,49.35 114.74,49.52 114.74,52.16 114.93,52.35 115.45,52.35 115.74,52.63 115.74,56.15 115.93,56.34 116.51,56.34 116.74,56.57 116.74,56.68 116.74,57.1 116.98,57.34 117.6,57.34 118.47,58.21 118.47,62.04 118.77,62.34 119.48,62.34 119.74,62.6 119.74,63.12 119.96,63.34 120.41,63.34 120.74,63.67 120.74,64.2 120.88,64.34 121.45,64.34 121.74,64.63 121.74,65.15 122.84,66.25 123.37,66.25 123.74,66.62 123.74,67.12 123.96,67.34 124.42,67.34 124.74,67.66 124.74,71.05 125.03,71.34 125.44,71.34 125.74,71.64 125.74,72.05 126.03,72.34 130.53,72.34 130.76,72.57 130.76,73.21 130.87,73.33 131.54,73.33 131.74,73.53 131.74,75.26 131.84,75.36 131.84,78.09 131.49,78.44 131.07,78.44 130.84,78.68 130.84,79.09 130.49,79.44 130.07,79.44 129.84,79.68 129.84,80.09 129.49,80.44 129.07,80.44 128.84,80.68 128.84,81.09 128.49,81.44 128.07,81.44 127.84,81.68 127.84,84.01 128.07,84.24 128.07,84.24 128.49,84.24 128.71,84.47 128.71,86.12 129.01,86.42 129.52,86.42 129.69,86.59 129.69,87.06 129.93,87.3 130.64,87.3 130.83,87.49 130.83,88.05 131.09,88.32 131.57,88.32 131.73,88.48 131.73,89.08 137.6,94.95 137.6,104.59 137.68,104.66 139.1,104.66 139.23,104.8 139.23,105.12 139.02,105.33 137.72,105.33 137.6,105.46 137.6,105.83 137.72,105.96 138.97,105.96 139.09,106.08 139.09,106.46 138.97,106.58 137.72,106.58 137.6,106.7 137.6,107.25 139.19,108.84 140.74,108.84 v1(140.92,108.66)
  BOTTOM w0.152: v1(134.59,122.17) 134.77,121.99 R189.2
USER_SI570_CLOCK1_N: length 110.5
  TOP w0.104: v1(172.84,14.62) 173.19,14.27 173.19,14.03 173.42,13.79 174.46,13.79 174.86,14.19 U157.14 ; U1.AW22 v2(134.24,63.84)
  16_SIG5 w0.076: 141.81,48.19 141.79,48.19 141.75,48.23 137.94,48.23 137.65,48.52 137.65,49.02 137.42,49.24 134.98,49.24 134.63,49.59 134.63,50.04 134.43,50.24 133.97,50.24 133.64,50.57 133.64,54.21 133.88,54.45 134.47,54.45 134.63,54.6 134.63,64.18 134.56,64.24 134.31,64.24 134.24,64.17 v2(134.24,63.84)
  16_SIG5 w0.089: 141.81,48.19 141.96,48.19 142.5,47.64 142.5,41.5 145.81,38.2 148.72,38.2 151.98,34.93 151.98,30.92 153.86,29.04 167.13,29.04 172.99,23.18 172.99,14.78 v1(172.84,14.62)
  BOTTOM w0.104: R174.1 R182.2 R184.1 v1(150.5,56.08) 150.11,56.47 149.87,56.47 143.6,62.74 143.6,63.99 141.96,65.63 136.37,65.63 135.85,65.11 135.85,64.53 135.55,64.23 134.34,64.23 134.24,64.12 v2(134.24,63.84)
USER_SI570_CLOCK1_P: length 110.4
  TOP w0.104: U157.13 174.36,14.41 174.5,14.27 174.5,14.15 174.37,14.02 173.52,14.02 173.41,14.12 173.41,14.27 v1(173.76,14.62) ; U1.AW23 v2(134.24,64.84)
  16_SIG5 w0.076: 141.81,48.47 141.79,48.47 141.75,48.42 138.02,48.42 137.84,48.6 137.84,49.1 137.51,49.44 135.07,49.44 134.83,49.67 134.83,50.12 134.51,50.44 134.05,50.44 133.84,50.65 133.84,54.13 133.97,54.25 134.56,54.25 134.83,54.52 134.83,64.26 134.64,64.44 134.31,64.44 134.24,64.52 v2(134.24,64.84)
  16_SIG5 w0.089: 141.81,48.47 142.08,48.47 142.78,47.76 142.78,41.61 145.92,38.48 148.83,38.48 152.26,35.05 152.26,31.03 153.98,29.32 167.24,29.32 173.27,23.29 173.27,14.89 173.54,14.62 v1(173.76,14.62)
  BOTTOM w0.104: v2(134.24,64.84) 134.24,64.63 134.41,64.46 135.45,64.46 135.62,64.62 135.62,65.2 136.28,65.86 142.06,65.86 143.83,64.09 143.83,62.83 149.97,56.69 150.12,56.69 v1(150.5,57.08) R183.1 R181.2 R174.2
USER_SI570_CLOCK_N: length 84.3
  TOP w0.104: U104.10 106.64,26.28 v1(106.53,26.39) ; R88.1 R178.2 R180.1 85.33,74.71 v1(85.34,74.73) ; v2(101.24,74.84) U1.G32
  16_SIG5 w0.076: v2(101.24,74.84) 101.63,74.45 101.63,72.55 101.94,72.24 112.48,72.24 112.64,72.08 112.64,61.64 112.44,61.44 111.93,61.44 111.64,61.15 111.64,49.42 111.62,49.4 111.62,47.22 111.66,47.18 111.66,44.36 111.62,44.33 111.62,42.33 111.58,42.29 111.58,42.27
  16_SIG5 w0.089: 111.58,42.27 111.58,40.49 108.48,37.4 106.85,35.76 106.85,30.85 106.17,30.16 106.17,28.43 106.78,27.81 106.78,26.64 v1(106.53,26.39)
  BOTTOM w0.104: v2(101.24,74.84) 100.93,74.84 100.39,75.37 94.96,75.37 94.62,75.71 88.66,75.71 88.2,75.25 85.45,75.25 85.34,75.14 v1(85.34,74.73)
USER_SI570_CLOCK_P: length 86.4
  TOP w0.104: v1(85.34,76) 85.06,75.71 R179.1 R177.2 R88.2 ; v2(102.24,74.84) U1.H32 ; U104.9 107.14,26.22 v1(107.31,26.39)
  16_SIG5 w0.076: 111.86,42.27 111.86,42.29 111.82,42.33 111.82,44.24 111.85,44.28 111.85,47.26 111.82,47.3 111.82,49.32 111.84,49.34 111.84,61.07 112.01,61.24 112.52,61.24 112.84,61.56 112.84,72.17 112.56,72.44 102.02,72.44 101.83,72.63 101.83,74.75 101.92,74.84 v2(102.24,74.84)
  16_SIG5 w0.089: 111.86,42.27 111.86,40.37 107.13,35.65 107.13,30.73 106.45,30.05 106.45,28.54 107.06,27.93 107.06,26.64 v1(107.31,26.39)
  BOTTOM w0.104: v1(85.34,76) 85.34,75.58 85.45,75.48 88.1,75.48 88.57,75.94 94.48,75.94 94.88,76.34 100.56,76.34 100.76,76.14 100.76,75.67 101.12,75.31 101.43,75.31 101.89,74.84 v2(102.24,74.84)
USER_SMA_CLOCK_N: length 102.4
  TOP w0.104: J35.1 R8.2 77.45,130.89 v8(77.37,130.81) ; U1.P32 v2(108.24,74.84)
  03_SIG1 w0.109: v2(108.24,74.84) 108.53,74.84 108.64,74.73 108.64,74.47 108.87,74.24 109.59,74.24 109.84,74.49 109.84,80.09 109.49,80.44 106.07,80.44 105.84,80.68 105.84,89.25 105.88,89.29 105.88,89.32
  03_SIG1 w0.135: v8(77.37,130.81) 77.74,131.17 77.74,131.73 79.11,133.1 87.93,133.1 88.44,132.59 91.25,132.59 91.89,131.94 99.93,131.94 101.93,129.95 101.93,128.37 102.51,127.79 104.57,127.79 106.94,125.42 106.94,112.36 106.54,111.97 106.54,106.29 103.44,103.2 103.44,101.46 103.58,101.33 103.58,99.13 102.68,98.23 102.68,92.89 105.88,89.69 105.88,89.32
USER_SMA_CLOCK_P: length 102.4
  TOP w0.104: J34.1 R8.1 78.45,130.87 v8(78.39,130.81) ; U1.R32 v2(109.24,74.84)
  03_SIG1 w0.109: v2(109.24,74.84) 108.95,74.84 108.84,74.73 108.84,74.56 108.95,74.44 109.5,74.44 109.64,74.58 109.64,80.01 109.4,80.24 105.99,80.24 105.64,80.59 105.64,89.25 105.6,89.29 105.6,89.32
  03_SIG1 w0.135: v8(78.39,130.81) 78.02,131.17 78.02,131.61 79.22,132.82 80.56,132.82 80.7,132.68 80.7,132.34 80.83,132.21 81.1,132.21 81.24,132.34 81.24,132.68 81.37,132.82 81.64,132.82 81.77,132.68 81.77,132.34 81.91,132.21 82.18,132.21 82.31,132.34 82.31,132.68 82.45,132.82 87.82,132.82 88.33,132.31 91.14,132.31 91.78,131.66 99.82,131.66 101.65,129.83 101.65,128.25 102.4,127.51 104.46,127.51 106.66,125.31 106.66,112.48 106.26,112.08 106.26,106.41 103.16,103.31 103.16,101.35 103.3,101.21 103.3,99.25 102.4,98.35 102.4,92.77 105.6,89.57 105.6,89.32
UTIL_1V35: length 68.6
  TOP w0.381: J97.1 51.2,105.35 ; J97.1 51.2,103.74 ; J97.1 50.39,105.61 ; J97.1 49.59,105.35 ; J97.1 49.33,104.54 ; J97.1 49.59,103.74 ; J97.1 51.46,104.54 ; J97.1 50.39,103.48 ; U142.H9 v2(74.32,114.17) ; U142.C1 v2(80.32,123.17) ; U141.F3 v2(89.23,118.32) ; U142.A11 v2(82.32,112.17) ; U142.H2 v2(74.32,122.17) ; U141.L1 v2(87.23,112.32) ; U142.L13 v2(71.32,110.17) ; U141.H9 v2(96.23,115.32) ; U141.H12 v2(99.23,115.32) ; U141.H2 v2(88.23,115.32) ; v2(101.25,112.32) 101.5,112.07 102.34,112.07 C1424.1 ; U142.L1 v2(71.32,123.17) ; U141.N3 v2(89.23,110.32) ; U141.A11 v2(98.23,123.32) ; U142.F3 v2(77.32,121.17) ; U141.N11 v2(98.23,110.32) ; U141.L13 v2(100.23,112.32) ; U142.A3 v2(82.32,121.17) ; v1(68.14,110.98) 67.72,111.4 67.04,111.4 C1427.1 67.06,112.39 67.6,112.39 v1(68.17,111.83) ; v2(91.23,115.32) U141.H5 ; U141.C13 v2(100.23,121.32) ; U142.H12 v2(74.32,111.17) ; U141.C1 v2(87.23,121.32) ; U142.N11 v2(69.32,112.17) ; U142.H5 v2(74.32,119.17) ; U141.A3 v2(89.23,123.32) ; v1(68.33,120.14) 68.2,120.27 67.24,120.27 C1426.1 66.83,119.55 67.07,119.31 v1(68.25,119.31) ; U142.F11 v2(77.32,112.17) ; U142.C13 v2(80.32,110.17) ; U142.N3 v2(69.32,121.17) ; U141.F11 v2(98.23,118.32)
  11_PWR2 w0.381: J97.1 51.2,105.35 ; J97.1 49.59,105.35 ; J97.1 49.33,104.54 ; J97.1 50.39,105.61 ; J97.1 51.46,104.54 ; J97.1 49.59,103.74 ; J97.1 50.39,103.48
  BOTTOM w0.191: Z91.2 104.23,115.76 104.23,114.49 104.97,113.76 104.97,113 104.35,112.38 103.08,112.38 102.62,112.83 101.63,112.83 101.6,112.81 100.71,112.81 v2(100.23,112.32)
  BOTTOM w0.381: C1284.1 74.59,111.43 v2(74.32,111.17) ; C1291.1 88.41,115.51 v2(88.23,115.32) ; v2(89.23,110.32) 88.18,109.27 C1290.1 ; v2(91.23,115.32) 91.46,115.56 C1277.1 ; v2(74.32,119.17) 74.57,118.92 C1392.1 ; v2(74.32,114.17) 74.51,114.35 C1283.1 ; v1(91.41,124.65) 91.41,125.53 C1425.1 90.42,125.55 v1(90.42,124.66) ; v2(96.23,115.32) 95.79,115.75 C1282.1 ; v2(74.32,122.17) 74.5,121.99 C1271.1 ; C1269.1 98.46,123.56 v2(98.23,123.32) ; v2(77.32,109.17) 77.34,109.15 C1296.1
  vias: v1(45.97,106.86) v1(45.97,105.71) v1(45.97,104.57) v1(47.24,106.86) v1(47.24,105.71) v1(47.24,104.57) v1(48.51,106.86) v1(48.51,105.71) v1(48.51,104.57) v3(49.74,102.7) v3(49.74,100.92) v3(50.98,102.13) v3(51.01,100.92)
UTIL_1V35_DH_R: length 22.3
  TOP w0.381: Q39.1 41.9,110.67 v1(41.27,110.67)
  20_SIG7 w0.381: v1(41.27,110.67) 41.27,114.73 43.75,117.21 46.95,117.21 47.36,116.8 47.36,116.05 48.09,115.32 49.46,115.32 50.75,116.61 50.75,120.03 v1(51.49,120.77)
  BOTTOM w0.508: R1022.2 v1(51.49,120.77)
UTIL_1V35_DL: length 8.1
  TOP w0.254: Q39.7 42.65,114.12 42.98,114.45 v1(43.11,114.45)
  16_SIG5 w0.381: v1(43.11,114.45) 44.57,115.91 44.57,116.83 v1(46.33,118.59)
  BOTTOM w0.254: v1(46.33,118.59) 46.33,118.82 45.94,119.21 U150.19
UTIL_1V35_FET_SWITCH: length 25.3
  TOP w0.152: L66.1 49.19,112.84 49.49,112.53 49.49,109.69 v1(49.2,109.4)
  TOP w0.381: v1(51.62,121.92) 52.62,121.92 R1029.1
  BOTTOM w0.152: R1079.2 49.28,109.47 v1(49.2,109.4)
  BOTTOM w0.254: U150.16 48.54,120.55 49.13,119.96 50.45,119.96 50.77,119.64
  BOTTOM w0.305: 50.77,119.64 C1325.2
  BOTTOM w0.381: R1076.2 v1(51.62,121.92) 52.22,121.32 52.22,119.83 51.51,119.12 C1325.2 50.77,118.41 49.61,117.25 48.51,117.25 47.52,116.26 47.52,114.07
  vias: v1(44.12,109.5) v1(44.73,108.68) v1(44.88,110) v1(45.75,108.56) v1(46.05,109.58) v1(46.89,108.56) v1(47.27,109.58) v1(47.91,108.56)
UTIL_1V35_PGOOD: length 224.6
  TOP w0.381: v1(201.99,163.92) 202.08,164.01 R1288.2 ; D35.1 v1(205.31,171.56)
  05_SIG2 w0.381: v1(46.86,156.82) 45.7,155.66 45.7,149.02 47.7,147.02 47.7,141.5 46.53,140.34 46.53,139.47 45.35,138.29 44.51,138.29 42.98,136.75 42.98,134.54 40.84,132.41 40.84,129.9 39.98,129.03 39.98,125.88 41.15,124.71 v1(42.01,124.71)
  07_SIG3 w0.381: v1(205.31,171.56) 204.34,170.59 204.34,168.66 201.99,166.31 v1(201.99,163.92)
  20_SIG7 w0.381: v1(46.86,156.82) 46.9,156.86 46.9,167.32 50.98,171.39 54.58,171.39 57.28,174.09 194.98,174.09 196.2,172.87 203.99,172.87 v1(205.31,171.56)
  BOTTOM w0.254: v1(42.01,124.71) 42.01,124.58 42.55,124.05 U150.32
  BOTTOM w0.381: Q58.1 v1(201.99,163.92)
UTIL_1V35_SNS_N: length 92.6
  05_SIG2 w0.135: v1(66.52,129.39) 66.2,129.71 64.98,129.71 54.94,119.67 44.55,119.67 42.28,121.95 39.76,121.95 v1(39.4,121.59)
  BOTTOM w0.104: C1318.1 C1329.2 ; C1329.2 40.37,121.89 39.7,121.89 v1(39.4,121.59) ; C1329.2 41.03,121.91 41.34,121.91 42.2,121.05 U150.26 ; v1(66.52,129.39) 66.87,129.74 67.39,129.74 68.84,131.19 71.57,131.19 72.35,131.96 84.22,131.96 85.09,131.09 88.22,131.09 88.43,130.88 103.32,130.88 106.05,128.15 106.05,116.68 105.94,116.57 105.12,116.57 Z92.1
UTIL_1V35_SNS_P: length 91.5
  05_SIG2 w0.135: v1(39.8,122.7) 40.28,122.22 42.39,122.22 44.66,119.95 54.83,119.95 64.86,129.99 66.2,129.99 v1(66.52,130.32)
  BOTTOM w0.104: v1(66.52,130.32) 66.87,129.97 67.3,129.97 68.75,131.41 71.48,131.41 72.26,132.19 84.32,132.19 85.19,131.32 88.32,131.32 88.53,131.1 103.42,131.1 106.27,128.25 106.27,116.58 106.03,116.34 105.4,116.34 Z91.1 ; U150.27 42.03,121.55 41.35,122.22 41.35,122.43 41.21,122.57 C1329.1 40.53,122.4 40.11,122.4 v1(39.8,122.7)
UTIL_1V35_TEMPX: length 22.3
  BOTTOM w0.254: Q40.2 51.56,113.71 Q40.1 53.1,113.71 53.53,114.14 53.53,123.33 49.69,127.17 48.48,127.17 C1330.1 48.24,126.51 47.83,126.11 47.34,126.11 46.44,125.2 U150.7
UTIL_3V3: length 375.6
  TOP w0.152: R153.1 203.15,34.64 203.46,34.95 204.71,34.95 v1(204.89,34.77)
  TOP w0.254: U29.6 226.34,67.2 226.74,66.81 v1(226.77,66.81) ; U36.6 174.33,69.5 v1(174.58,69.75) ; v1(134.59,128.53) U37.6 ; v1(108.81,22.63) 108.32,23.12 U104.5
  TOP w0.305: 47.04,139.57 46.89,139.42 U10.3 ; v1(222.07,150.96) 221.74,151.3 R499.1 ; v1(59.92,86.74) 60.18,86.74 60.47,87.03 U24.10 ; U166.27 162.79,134.75 v1(162.69,134.65) ; v1(176.15,38.28) 176.22,38.35 R213.1 R192.1 ; U157.5 175.86,18.63 v1(175.76,18.73) ; v1(60.56,122.14) 60.56,121.73 U151.A3
  TOP w0.381: J2.C39 v1(128.68,160.78) ; R163.1 47.73,140.36 v1(47.88,140.51) ; v1(59.92,86.74) 59.72,86.54 C356.1 ; v1(62.67,147.95) 62.46,147.74 U19.24 ; v1(49.62,142.49) 50,142.87 R603.1 ; v1(120.36,117.43) U39.15 ; R422.1 176.01,38.41 v1(176.15,38.28) ; v1(211.68,167.11) 211.69,167.1 DS3.3 ; R1288.1 v1(203.95,162.86) ; R106.1 203.44,160.57 v1(204.18,161.32) ; J22.D38 v1(59.94,162.05) ; v1(58.93,133.53) 58.83,133.43 R1009.1 ; v1(205.47,146.84) 205.45,146.86 C550.1 ; v1(128.12,147.52) 128.99,147.52 129.6,146.91 C957.1 128.94,145.8 v1(128.19,145.8) ; v1(201.25,14.57) 201.13,14.7 C81.1 ; R217.1 173.24,41.06 v1(173.35,40.94) ; v1(97.83,29.23) 97.65,29.41 R86.1 ; v1(57.18,119.71) 57.46,119.42 C1342.1 ; U19.23 62.59,147.09 v1(62.61,147.07) ; C551.1 208.49,146.86 v1(208.54,146.81) ; J22.D40 v1(57.4,162.05) ; R604.1 49.88,144.27 49.75,144.14 v1(49.37,144.14) ; J103.1 202.1,31.59 ; J103.1 201.29,31.85 ; J103.1 202.36,30.78 ; R399.1 147.46,115.63 R125.1 147.46,117.85 147.78,118.17 v1(147.78,118.47) ; R107.1 v1(175.39,35.48) ; v1(123.11,145.75) 122.29,145.75 C956.1 121.48,147.02 122.21,147.75 v1(123.14,147.75) ; v1(141.4,105.53) 142.47,104.46 142.47,103.58 143.47,102.58 143.47,101.9 144.5,100.86 144.88,100.86 v1(145.29,101.27) 145.11,101.45 144.85,101.45 144.41,101.9 C1164.1 ; C324.1 110.37,21.65 110.62,21.89 110.62,23.03 v1(110.77,23.18) 111.68,23.18 U32.6 ; U124.A3 14.4,118.72 v1(14.16,118.97) ; U39.10 v1(123.05,117.43) ; R640.1 v1(224.92,154.46) ; R28.1 201.1,21.65 v1(201.61,22.15) ; v1(63.15,24.93) 63.81,25.59 L71.1 66.27,25.59 v1(66.42,25.45) ; v1(175.91,41.12) 176.29,41.5 R208.1 ; R1008.1 55.91,131.15 C1273.1 55.63,130.87 v1(55.63,129.78) ; U38.6 99.32,21.92 v1(100.08,21.92) ; J2.D40 v1(127.41,162.05) ; J2.D36 v1(132.49,162.05) ; v1(229.54,171.86) 229.21,171.52 DS34.2 ; v1(226.77,66.81) 226.95,66.98 C120.1 ; DS2.3 v1(226.44,171.88) ; U39.22 120.03,112.88 v1(120.36,113.2) 120.03,113.53 U39.21 ; v1(144.27,114.22) 144.26,114.22 C53.1 ; R388.1 R389.1 v1(57.4,87.68) ; U25.5 v1(127.32,138.76) ; C92.1 145.2,122.6 v1(145.02,122.78) ; C527.1 v1(206.74,145.33) ; J2.D38 v1(129.95,162.05) ; v1(196.02,60.56) 195.96,60.62 C128.1 ; R823.1 17.5,118.54 v1(17.84,118.2) ; R131.1 v1(226.83,71.05) ; U53.1 133.23,14.91 v1(133.24,14.92) ; J2.D32 v1(137.57,162.05) ; U39.4 123.39,113.53 123.03,113.18 v1(123.03,113.16) 123.32,112.88 U39.3 ; C905.1 v1(41.71,103.58) ; R786.1 4.06,141.15 v1(3.86,140.94) ; C71.1 v1(226.83,72.45) ; R82.1 v1(47.55,151.31) ; U40.8 v1(119.99,120.6) ; J22.Z40 v1(57.4,156.97) ; Z115.2 v1(40.39,100.63) ; R81.1 v1(27.12,152.21) ; J22.C39 v1(58.67,160.78) ; J22.D32 v1(67.56,162.05) ; J22.D36 v1(62.48,162.05)
  09_PWR1 w0.381: 63.66,24.2 J9.1 ; J9.1 65.27,24.2 ; J9.1 63.66,22.59 ; J9.1 65.53,23.39 ; J9.1 64.47,24.46 ; J9.1 64.47,22.33 ; J9.1 65.27,22.59 ; J9.1 63.4,23.39 ; J53.11 236.82,79.72 ; J53.11 236.02,77.85 ; J53.11 235.21,79.72 ; J53.11 234.95,78.92 ; J53.11 237.08,78.92 ; J53.11 235.21,78.11 ; J53.11 236.82,78.11 ; J53.11 236.02,79.98 ; J52.11 229.72,62.45 ; J52.11 227.85,61.64 ; J52.11 227.85,63.26 ; J52.11 229.46,63.26 ; J52.11 227.58,62.45 ; J52.11 229.46,61.64 ; J52.11 228.65,63.52 ; J52.11 228.65,61.38 ; J53.12 239.62,78.92 ; J53.12 238.56,79.98 ; J53.12 237.49,78.92 ; J53.12 237.75,79.72 ; J53.12 239.36,79.72 ; J53.12 237.75,78.11 ; J53.12 239.36,78.11 ; J53.12 238.56,77.85 ; 231.19,61.38 J52.12 ; J52.12 230.39,63.26 ; J52.12 231.19,63.52 ; J52.12 230.12,62.45 ; J52.12 230.39,61.64 ; J52.12 232.26,62.45 ; J52.12 232,63.26 ; J52.12 232,61.64 ; 201.29,29.72 J103.1 ; J103.1 202.1,29.98 ; J103.1 202.36,30.78 ; J103.1 201.29,31.85 ; J103.1 200.49,31.59 ; J103.1 200.23,30.78 ; J103.1 200.49,29.98 ; J103.1 202.1,31.59 ; J8.1 201.72,27.14 ; J8.1 200.11,25.53 ; J8.1 199.85,26.34 ; J8.1 200.91,27.41 ; J8.1 200.91,25.27 ; J8.1 201.98,26.34 ; J8.1 200.11,27.14 ; J8.1 201.72,25.53
  16_SIG5 w0.381: 230.39,63.26 J52.12 ; J52.12 231.19,63.52 ; J52.12 230.39,61.64 ; J52.12 232,63.26 ; J52.12 232,61.64 ; J52.12 232.26,62.45 ; J52.12 230.12,62.45 ; J52.12 231.19,61.38 ; J52.11 228.65,63.52 ; J52.11 229.72,62.45 ; J52.11 229.46,61.64 ; J52.11 227.85,63.26 ; J52.11 227.58,62.45 ; J52.11 227.85,61.64 ; J52.11 229.46,63.26 ; J52.11 228.65,61.38
  BOTTOM w0.178: U13.10 33.77,69.02 33.66,69.14 33.66,69.6 v1(33.73,69.67)
  BOTTOM w0.203: v1(34.28,70.29) 34.28,70.21 34.78,69.7 U13.1 ; U22.1 50.85,80.39 v1(50.53,80.72) ; v1(34.19,67.5) 34.64,67.5 34.78,67.64 U13.7 ; U22.10 49.82,79.57 49.53,79.86 v1(49.53,80.31) ; U22.7 50.85,77.58 v1(50.8,77.52) ; U33.7 54.28,77.72 v1(54.1,77.54)
  BOTTOM w0.254: U134.10 145.59,101.74 145.29,101.44 v1(145.29,101.27) ; 42.26,106.17 R824.1 ; 41.68,106.43 41.42,106.17 U125.3 ; v1(55.63,129.78) 56.17,130.32 U143.10 ; v3(232.28,104.92) 233.17,105.81 U164.27 ; U23.6 v1(145.02,122.78) ; U8.6 v1(196.02,60.56)
  BOTTOM w0.305: U35.6 v1(189.5,120.41) ; v1(205.47,146.84) U51.1 ; U27.6 190.67,153.17 v1(190.45,152.94) ; U31.16 173.29,40.88 v1(173.35,40.94) ; U31.5 176.21,38.34 v1(176.15,38.28)
  BOTTOM w0.381: C1361.1 5.13,161.82 5.51,162.2 v1(5.82,162.2) 6.06,162.45 U154.16 ; R928.1 144.14,98.98 143.65,99.48 143.65,101.89 143.38,102.16 143.38,103.45 144.22,104.29 144.22,105.79 143.84,106.17 142.04,106.17 v1(141.4,105.53) ; v1(48.43,73.49) R85.1 C96.1 ; C204.1 98.59,22.24 98.91,21.92 v1(100.08,21.92) ; v1(62.23,121.79) 62.47,121.55 62.98,121.55 63.06,121.47 R1192.1 ; C1646.1 v1(49.81,154.55) ; R221.1 169.04,38.18 169.43,37.8 v1(169.62,37.8) ; R1183.1 v1(218.03,166.78) ; v1(174.58,69.75) 174.89,69.44 C157.1 ; R327.1 v1(224.67,33.71) ; C15.1 119.97,120.58 v1(119.99,120.6) ; U51.24 208.63,146.84 208.59,146.81 v1(208.54,146.81) ; v1(16.73,118.24) 16.82,118.33 16.82,119.08 C866.1 v1(14.98,119.7) ; R1100.1 60.48,122.05 v1(60.56,122.14) ; R89.1 59.63,50.31 59.38,50.06 C1551.1 59.92,49.63 v1(60.11,49.83) ; v1(32,86.16) 32,86.4 R126.1 ; v1(60.46,24.06) C1344.1 59.38,24.59 59.63,24.83 R90.1 ; C1441.1 175.55,18.94 v1(175.76,18.73) ; C640.1 127.29,138.78 v1(127.32,138.76) ; R33.1 v1(43.12,146.61) ; v1(185.5,143.26) 185.92,143.67 C98.1 ; v1(134.59,128.53) 134.57,128.54 C162.1 ; v1(21.88,63.63) 21.61,63.89 Q56.1 ; C290.1 C1645.1 v1(56.41,154.55) ; C1396.1 v1(220.79,54.14) ; R640.1 v1(224.92,154.46) ; C154.1 v1(192.24,121.57) ; v1(55.98,14.86) 55.63,15.21 R11.1 ; R93.1 R94.1 62.61,141.42 v1(62.79,141.6) ; Q55.1 v1(16.87,72.79) ; C76.1 v1(38.08,77.2) 37.7,77.2 37.32,77.58 U21.8 v1(37.32,80.52) ; R888.1 v1(180.79,168.03) ; v1(153.03,119.53) 153.03,119.98 C1395.1 ; v1(110.81,159.59) 110.78,159.62 R934.1 ; v1(224.67,31.17) R501.1 R502.1 ; RP3.3 199.07,154.25 v1(198.67,154.65) 199.07,155.05 199.72,155.05 RP3.4 ; C73.1 232.15,90.6 v1(232.79,90.6) 233.17,90.22 R132.1 ; C40.1 34.82,70.78 34.33,70.29 v1(34.28,70.29) ; C63.1 v1(50.8,77.52) ; R784.1 v1(5.94,132.89) 5.87,132.82 R787.1 ; R144.1 v1(210.06,168.75) ; R13.1 32.38,116.5 v1(32.38,116.87) ; R1.1 R2.1 59.9,48.39 60.12,48.16 v1(60.12,47.82) ; J83.4 v1(17.2,168.91) ; v1(145.29,101.27) 144.79,100.77 R929.1 ; C123.1 v1(61.53,25.02) ; U18.6 v1(201.25,14.57) ; RP2.4 199.72,151.49 199.07,151.49 v1(198.67,151.09) 199.07,150.69 RP2.3 ; v1(46.26,146.94) R91.1 R92.1 ; R220.1 169.04,42.49 v1(169.47,42.91) ; v1(62.64,45.54) 62.57,45.47 C65.1 60.77,45.47 60.67,45.57 C69.1 ; C1626.1 v1(51.46,154.55) ; Q57.1 v1(19.58,63.06) ; C501.1 173.35,41.34 v1(173.35,40.94) ; R608.1 R607.1 47.17,144.57 46.21,144.57 v1(46,144.78) ; C1628.1 v1(121.45,157.11) ; v1(67.41,152.05) U26.5 ; R612.1 61.93,149.06 R611.1 ; R612.1 v1(62.67,147.95) ; R612.1 R613.1 ; v1(12.05,120.69) 12.07,120.71 C864.1 ; R147.1 v1(215.9,168.75) ; R614.1 R613.1 ; R613.1 62.37,146.82 v1(62.61,147.07) ; R151.1 v1(220.85,168.75) ; v1(211.88,168.1) 211.71,168.27 R145.1 ; Q52.1 v1(14.97,72.79) ; R1013.1 v1(214.06,162.22) ; R19.1 v1(110.8,170.55) ; RP3.1 199.07,152.65 v1(198.67,153.05) 199.07,153.45 RP3.2 ; R148.1 v1(217.55,168.75) ; C774.1 27.44,115.63 v1(26.92,115.11) 26.66,115.11 R142.1 ; v1(118.38,25.04) 117.95,25.04 R77.1 ; v1(3.86,140.94) 3.86,140.44 4.21,140.09 R785.1 ; 140.02,124.56 R628.1 ; C1652.1 v1(129.71,157.11) ; C70.1 32.47,82.61 v1(32.51,82.57) U14.6 ; v1(61.22,23.03) 61,22.81 R1095.1 R1094.1 ; v1(22.02,67.51) 22.02,67 Q54.1 ; C236.1 120.68,117.11 v1(120.36,117.43) ; C1586.1 232.14,104.78 v3(232.28,104.92) ; U20.8 55.31,43.94 v1(55.15,44.1) ; v1(211.2,147.88) 210.82,147.49 U51.23 ; R218.1 v1(178.95,41.44) ; R323.1 v1(200.17,147.26) ; RP2.2 199.07,149.89 v1(198.67,149.49) 199.07,149.09 RP2.1 ; C239.1 v1(54.1,77.54) ; R331.2 v1(127.99,141.44) ; v1(7.21,161.97) 6.93,161.97 6.53,161.57 C1362.1 ; R128.1 174.67,64.16 v1(175.26,63.57) ; C125.1 v1(206.67,59.06) ; v1(108.81,22.63) 108.81,22.66 C701.1 ; C1013.1 v1(128.06,157.11) ; R127.1 v1(207.77,162.22) ; R945.1 v1(209.74,162.22) ; R308.1 v1(110.8,167.75) ; C1647.1 v1(53.11,154.55) ; C633.1 133.11,15.04 v1(133.24,14.92) ; R890.1 v1(180.79,165.24) ; R492.1 v1(211.9,162.22) ; v1(130.33,129.53) R130.1 ; C1653.1 v1(123.1,157.11) ; Q53.1 v1(13.06,72.79) ; v1(174.39,66.45) R129.1 ; U132.5 v1(138.99,151.72) ; C1655.1 v1(126.41,157.11) ; v1(144.27,114.22) 143.9,113.86 U12.8 ; R143.1 v1(208.41,168.75) ; C893.1 C894.1 v1(50.73,150.1) ; R828.1 v1(14.16,118.97) ; R500.1 v1(224.67,34.98) ; R149.1 v1(219.2,168.75) ; R818.1 v1(32.28,105.31) ; C1644.1 v1(54.76,154.55) ; C1654.1 v1(124.75,157.11) ; R146.1 v1(213.49,168.75)
  vias: v1(20.09,154.41) v1(21.18,154.41) v1(41.99,107.24) v1(42.62,106.78) v1(43.38,106.81) v1(43.7,96.01) v1(43.7,94.99) v1(44.75,93.27) v1(44.75,92.25) v1(45.43,46.55) v1(45.43,45.78) v1(45.47,21.09) v1(45.47,20.32) v1(45.77,93.27) v1(45.77,92.25) v1(46.79,93.27) v1(46.79,92.25) v1(47.7,139.78) v1(47.8,92.25) v1(48.51,140.13) v1(48.96,94.02) v1(49.16,95.28) v1(49.98,94.02) v1(50.99,94.02) v1(62.23,122.56) v1(63.02,149.93) v1(63.53,149.37) v1(63.57,32.44) v1(63.89,51.71) v1(64.22,148.96) v1(64.69,60.83) v1(64.94,32.45) v1(65.33,60.33) v1(65.32,51.69) v1(86.11,32.14) v1(87.11,32.14) v1(137.52,26.8) v1(138.26,125.8) v1(138.26,124.53) v1(138.26,123.26) v1(138.26,121.99) v1(138.26,116.91) v1(138.28,26.8) v1(139.04,26.8) v1(139.28,125.8) v1(139.28,124.53) v1(139.28,123.26) v1(139.28,121.99) v1(139.28,120.72) v1(139.28,119.45) v1(139.28,116.91) v1(139.38,111.06) v1(140.14,111.9) v1(140.14,111.06) v1(141.03,111.9) v1(162.28,133.99) v1(170.56,51.49) v1(173.99,50.6) v1(174.62,49.96) v1(175.39,49.58) v1(192.4,171.47) v1(192.4,170.59) v1(192.4,169.7) v1(193.17,171.47) v1(193.17,170.59) v1(203.58,31.8) v1(204.72,33.2) v1(204.72,31.93) v1(205.87,34.47) v1(205.87,33.2) v1(205.87,31.93) v1(207.01,34.47) v1(207.01,33.2) v1(207.01,31.93) v1(208.15,34.47) v1(208.15,33.2) v1(208.15,31.93) v1(209.3,34.47) v1(209.3,33.2) v1(209.3,31.93) v1(227.08,98.86) v1(227.08,97.97) v1(228.09,98.86) v1(228.09,97.97) v1(229.11,98.86) v1(229.11,97.97) v1(230.12,98.86) v1(230.12,97.97)
UTIL_3V3_DH_R: length 17.9
  TOP w0.635: Q47.4 v1(186.95,40.99)
  03_SIG1 w0.381: v1(186.95,40.99) 185.16,40.99 184.58,40.41 184.58,36.4 185.62,35.36 190.98,35.36 191.85,34.49 v1(191.85,33.12)
  BOTTOM w0.381: R1147.2 v1(191.85,33.12)
UTIL_3V3_DL: length 17
  TOP w0.635: Q45.4 194.46,40.48 194.14,40.8 v1(194.14,41.22)
  03_SIG1 w0.381: v1(192.61,28.21) 192.61,32.35 194.14,33.88 v1(194.14,41.22)
  BOTTOM w0.305: v1(192.61,28.21) 191.91,27.52 U156.19
UTIL_3V3_EN: length 3.5
  BOTTOM w0.152: R756.1 R333.2 188.42,30.96 U156.12
UTIL_3V3_FET_SWITCH: length 26.8
  TOP w0.152: L75.1 193.73,47.62 194.45,48.34 194.45,51.23 v3(194.07,51.61)
  BOTTOM w0.152: R1135.2 193.03,52.24 193.37,52.58 194.18,52.58 194.46,52.3 194.46,52 v3(194.07,51.61)
  BOTTOM w0.254: C1526.2 193.12,32.35 192.5,31.73 192.5,30.97 191.58,30.06 190.87,30.06 190.43,29.61 U156.16
  BOTTOM w0.381: C1526.2 193.12,33.43 ; 190.58,32.74 R1165.2
  BOTTOM w0.762: 189.41,36.75 189.41,35.46 190.58,34.29 190.58,32.74 ; 193.12,33.43 193.12,34.51 190.91,36.72
  vias: v3(188.85,43) v3(190.12,43)
UTIL_3V3_PGOOD: length 194.8
  TOP w0.381: D13.1 v1(200.33,171.56)
  03_SIG1 w0.381: v1(205.96,153.09) 205.96,153.93 205.52,154.36 204.43,154.36 203.96,154.83 203.96,156.62 203.84,156.74 203.84,158.14 200.53,161.44 200.53,168 202.04,169.51 202.04,170.87 201.35,171.56 v1(200.33,171.56)
  05_SIG2 w0.381: v1(205.96,153.09) 206.21,153.09 207.26,154.14 208.73,154.14 209.37,153.5 209.37,143.33 204.65,138.61 204.65,130.53 205.89,129.29 205.89,79.33 213.14,72.08 213.14,69.86 212.04,68.76 198.75,68.76 196.72,66.73 196.72,59.97 199.59,57.11 199.59,47.06 195.35,42.82 195.35,33.2 191.13,28.98 191.13,25.64 188.9,23.42 v1(186.18,23.42)
  BOTTOM w0.254: v1(186.18,23.42) 186.41,23.65 186.61,23.65 186.93,23.96 U156.32 ; U51.10 203.07,152.69 202.87,152.89 202.87,154.51 202.34,155.05 201.32,155.05 RP3.5
  BOTTOM w0.381: U51.10 205.56,152.69 v1(205.96,153.09)
