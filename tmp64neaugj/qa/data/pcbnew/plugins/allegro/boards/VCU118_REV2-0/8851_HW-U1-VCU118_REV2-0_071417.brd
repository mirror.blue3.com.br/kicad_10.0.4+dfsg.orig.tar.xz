# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RLD3_C3_72B_A14: length 162.8
  TOP w0.152: U142.H3 v2(74.32,121.17) ; U1.E29 v2(99.24,71.84) ; U141.H3 v2(89.23,115.32)
  TOP w0.241: v2(85.23,111.31) 84.55,111.99 R958.2
  03_SIG1 w0.173: v2(74.32,121.17) 74.32,121.48 73.82,121.97 73.82,123.54 73.71,123.66 72.98,123.66 72.82,123.5 72.82,121.86 73.02,121.67 73.58,121.67 73.82,121.43 73.82,120.88 73.6,120.67 73.09,120.67 72.82,120.39 72.82,116.87 72.64,116.69 72.35,116.69 72.19,116.52 72.19,115.85 72.33,115.71 72.63,115.71 72.82,115.52 72.82,114.96 73.12,114.67 74.62,114.67 74.83,114.88 74.83,115.08 74.94,115.19 75.14,115.19 75.24,115.09 75.24,114.69 75.36,114.58 75.5,114.58 75.62,114.7 75.62,115.21 76.1,115.7 76.46,115.7 76.74,115.98 77.15,115.98 77.43,115.7 77.85,115.7 78.12,115.98 78.54,115.98 78.82,115.7 79.23,115.7 79.51,115.98 79.92,115.98 80.2,115.7 80.61,115.7 80.89,115.98 81.3,115.98 81.58,115.7 81.99,115.7 82.27,115.98 82.68,115.98 82.96,115.7 83.69,115.7 83.87,115.52 83.87,115.29 84,115.16 84.56,115.16 84.68,115.29 84.68,115.42 84.56,115.54 84.38,115.54 84.23,115.7 84.23,116.17 84.44,116.38 84.65,116.38 84.74,116.3 84.74,115.94 84.83,115.85 85.01,115.85 85.12,115.95 85.12,116.1 85.19,116.18 85.45,116.18 85.55,116.08 85.55,115.77 85.66,115.65 85.81,115.65 85.93,115.77 85.93,116.09 86.02,116.18 86.22,116.18 86.31,116.1 86.31,115.17 86.43,115.05 86.57,115.05 86.69,115.17 86.69,115.98 86.79,116.08 87.16,116.08 87.43,115.81 87.73,115.51 87.73,115.12 88.03,114.82 89.43,114.82 89.61,115 89.61,115.23 89.52,115.32 v2(89.23,115.32)
  05_SIG2 w0.173: 94.39,71.17 94.54,71.17 94.71,71.34 98.5,71.34 99,71.84 v2(99.24,71.84) ; v2(74.32,121.17) 74.88,121.17 75.03,121.31 75.03,121.6 75.12,121.69 75.45,121.69 75.54,121.78 75.54,121.96 75.45,122.04 75.12,122.04 75.03,122.13 75.03,122.37 75.12,122.46 75.31,122.46 75.4,122.55 75.4,122.72 75.31,122.81 75.12,122.81 75.03,122.9 75.03,123.08 75.12,123.17 75.31,123.17 75.4,123.26 75.4,123.43 75.31,123.52 75.12,123.52 75.03,123.61 75.03,123.82 74.94,123.91 74.39,123.91 74.31,123.99 74.31,124.19 74.4,124.29 74.94,124.29 75.06,124.41 75.06,124.82
  05_SIG2 w0.262: v2(85.23,111.31) 86.74,112.82 87.43,112.82 87.73,113.12 87.73,113.53 88.02,113.82 88.43,113.82 88.73,114.12 88.73,114.55 89.23,115.05 v2(89.23,115.32)
  05_SIG2 w0.292: 75.06,124.82 75.29,125.04 76.81,125.04 77.17,125.4 77.17,126.7 76.68,127.18 75.97,127.18 75.71,126.92 75.71,126.44 75.45,126.19 75.09,126.19 74.83,126.44 74.83,126.92 74.58,127.18 68.08,127.18 67.71,127.54 66.31,127.54 65.77,127 64.89,127 63.59,125.69 63.59,107.76 66.05,105.3 69.41,105.3 70.24,106.12 71.95,106.12 73.63,104.44 74.22,104.44 74.68,103.99 74.68,103.5 75.63,102.55 77.71,102.55 77.87,102.71 77.87,103.2 78.04,103.37 78.8,103.37 78.98,103.19 78.98,102.73 79.21,102.49 81.83,102.49 82.85,101.47 83.29,101.47 84.12,100.63 84.12,100.02 85.53,98.62 88.92,98.62 90.96,96.58 90.96,93.68 90.52,93.24 90.52,74.87 94.22,71.17 94.39,71.17
RLD3_C3_72B_A15: length 160.4
  TOP w0.152: U1.F29 v2(100.24,71.84) ; U141.G2 v2(88.23,117.32) ; U142.G2 v2(76.32,122.17)
  TOP w0.241: R959.2 85.07,114.17 v2(85.23,114.32)
  05_SIG2 w0.173: v2(100.24,71.84) 99.85,71.84 99.32,71.32 99.01,71.32 98.76,71.07 98.76,70.52 98.58,70.34 94.39,70.34 ; v2(76.32,122.17) 75.82,122.67 75.82,123.8 76.05,124.03 77.52,124.03 78,124.51 78,124.82
  05_SIG2 w0.262: v2(88.23,117.32) 88.23,116.21 87.73,115.71 87.73,115.12 87.43,114.82 86.78,114.82 86.28,114.32 v2(85.23,114.32)
  05_SIG2 w0.292: 78,124.82 78,127.69 77.7,127.99 68.43,127.99 68.03,128.39 65.07,128.39 62.92,126.23 62.92,106.83 65.12,104.62 72.05,104.62 72.47,104.2 72.47,102.19 73,101.66 74.09,101.66 74.11,101.68 79.62,101.68 80.17,101.14 80.31,101.14 80.52,101.35 80.52,101.52 80.7,101.7 80.97,101.7 81.18,101.5 81.18,101.19 81.38,100.99 82.09,100.99 85.31,97.77 88.82,97.77 90.28,96.3 90.28,94.2 89.85,93.76 89.85,74.59 94.1,70.34 94.39,70.34
  07_SIG3 w0.173: 89.1,124.6 89.1,124.18 88.73,123.81 88.73,117.82 v2(88.23,117.32) ; v2(76.32,122.17) 76.07,122.17 75.64,121.74 75.44,121.74 75.3,121.87 75.3,122.62 75.37,122.69 75.71,122.69 75.79,122.76 75.79,123.13 75.69,123.22 75.41,123.22 75.31,123.33 75.31,123.62 75.42,123.73 77.72,123.73 77.81,123.83 77.81,124.13 77.72,124.23 75.49,124.23 75.16,124.56 75.16,124.82
  07_SIG3 w0.292: 75.16,124.82 75.16,127.05 78.03,129.92 79.4,129.92 80.64,131.17 83.74,131.17 84.68,130.23 84.68,128.78 85.5,127.97 88.6,127.97 89.1,127.46 89.1,124.6
RLD3_C3_72B_A16: length 160.2
  TOP w0.152: v2(90.23,115.32) U141.H4 ; U142.H4 v2(74.32,120.17) ; U1.D32 v2(98.24,74.84)
  TOP w0.241: v2(85.23,110.31) 84.55,110.99 R960.2
  05_SIG2 w0.262: v2(90.23,115.32) 89.73,114.82 89.73,114.12 89.43,113.82 89.02,113.82 88.73,113.53 88.73,113.12 88.43,112.82 88.02,112.82 87.73,112.53 87.73,112.12 87.43,111.82 86.74,111.82 v2(85.23,110.31)
  07_SIG3 w0.173: v2(90.23,115.32) 91.73,116.82 91.73,121.47 91.38,121.82 91.03,121.82 90.75,122.1 90.75,122.55 90.49,122.81 89.93,122.81 89.79,122.94 89.79,124.6 ; 74.44,124.82 74.44,124.24 74.78,123.9 74.78,120.62 v2(74.32,120.17)
  07_SIG3 w0.292: 74.44,124.82 74.44,127.35 76.02,128.93 76.02,130.1 75.62,130.51 75.62,131.34 76.12,131.85 84.84,131.85 85.5,131.19 87.2,131.19 87.99,130.4 87.99,129.72 89.79,127.91 89.79,124.6
  20_SIG7 w0.089: v2(74.32,120.17) 74.87,120.72 74.87,121.83 ; v2(98.24,74.84) 98.74,75.34 98.74,76.05 98.44,76.34 98.03,76.34 97.74,76.64 97.74,77.05 97.44,77.34 97.03,77.34 96.74,77.64 96.74,78.05 96.44,78.34 96.05,78.34 95.78,78.61 95.78,79.07 95.53,79.32 94.39,79.32
  20_SIG7 w0.157: 74.87,121.83 74.87,122.06 75.2,122.39 75.2,123.54 74.48,124.26 69.21,124.26 68.91,124.56 68.91,126.32 69.33,126.74 72.41,126.74 72.8,127.13 72.8,131.9 73.49,132.6 87.22,132.6 88.01,131.8 88.01,127.48 86.52,126 86.52,124.68 86.73,124.47 86.73,109.16 88.39,107.5 88.39,107.14 88.64,106.88 92.58,106.88 93.01,106.45 93.01,105.21 94.97,103.25 94.97,101.37 95.35,100.99 95.35,90.44 93.09,88.19 93.09,80.24 94.01,79.32 94.39,79.32
RLD3_C3_72B_A17: length 157.1
  TOP w0.152: v2(99.24,74.84) U1.E32 ; U142.H10 v2(74.32,113.17) ; U141.H10 v2(97.23,115.32)
  07_SIG3 w0.173: 68.91,114.67 69.66,114.67 69.83,114.5 69.83,113.95 70.11,113.67 73.58,113.67 74.08,113.17 v2(74.32,113.17) ; 79.82,108.81 79.82,109.4 79.57,109.65 79.07,109.65 78.82,109.9 78.82,111.37 78.53,111.67 77.06,111.67 76.81,111.92 76.81,112.38 76.52,112.67 76.05,112.67 75.77,112.39 74.79,112.39 74.52,112.67 68.99,112.67 68.91,112.75 ; 94.39,81.56 94.6,81.34 95.44,81.34 95.74,81.05 95.74,80.64 96.03,80.34 96.44,80.34 96.74,80.05 96.74,79.64 97.03,79.34 97.44,79.34 97.74,79.05 97.74,77.6 97.99,77.34 98.42,77.34 98.74,77.03 98.74,75.63 99.24,75.13 v2(99.24,74.84)
  07_SIG3 w0.292: 79.82,108.81 79.82,108.7 79.98,108.53 80.66,108.53 81.1,108.1 81.1,107.67 81.32,107.46 81.32,107.21 81.2,107.1 81.2,106.86 81.38,106.69 81.62,106.69 81.73,106.8 81.97,106.8 82.68,106.1 82.68,105.86 82.51,105.69 82.51,105.45 82.68,105.28 82.92,105.28 83.09,105.44 83.33,105.44 83.72,105.05 83.72,103.68 83.92,103.48 84.13,103.48 84.43,103.19 84.43,102.84 84.25,102.66 84.25,102.44 84.77,101.91 85.39,101.91 86.53,100.77 86.53,97.77 86.87,97.43 87.11,97.43 87.45,97.78 87.45,98.86 87.3,99.01 87.3,99.47 87.66,99.82 88.75,99.82 88.85,99.92 88.85,100.26 88.69,100.41 88.37,100.41 88.21,100.57 88.21,100.86 88.4,101.04 88.69,101.04 88.85,101.2 88.85,101.3 89.12,101.56 89.52,101.56 89.63,101.45 89.63,100.82 89.81,100.64 90.19,100.64 90.35,100.48 90.35,100.16 90.19,100.01 89.81,100.01 89.66,99.85 89.66,99.6 89.78,99.47 89.78,99.04 89.47,98.73 89.46,98.73 89.38,98.65 88.42,98.65 88.13,98.36 88.13,97.85 88.42,97.56 89.03,97.56 89.76,98.3 89.99,98.3 90.27,98.02 90.27,97.74 89.7,97.17 89.7,96.9 90.31,96.28 90.31,96.02 93.16,93.18 93.16,82.79 94.39,81.56 ; 68.91,112.75 68.68,112.98 68.68,113.16 66.61,115.24 66.61,117.4 66.31,117.69 65,117.69 64.71,117.98 64.71,118.57 65,118.86 66.31,118.86 66.61,119.15 66.61,119.74 66.31,120.03 65,120.03 64.71,120.32 64.71,120.9 65,121.2 66.31,121.2 66.61,121.49 66.61,122.51 66.9,122.8 68.35,122.8 68.56,122.59 68.56,121.43 68.32,121.2 67.99,121.2 67.63,120.84 67.63,115.45 68.4,114.67 68.91,114.67
  14_SIG4 w0.089: v2(97.23,115.32) 97.56,115.32 97.63,115.38 97.63,115.58 96.38,116.82 91.59,116.82 91.17,116.41 87.13,116.41 86.75,116.79 86.75,117.54 86.46,117.83 85.93,117.83 85.63,117.53 85.31,117.53 84.45,118.39 84.45,118.57 84.78,118.89 84.78,119.08 84.59,119.26 84.45,119.26 84.1,118.92 83.92,118.92 83.83,119.02 83.83,119.38 83.55,119.67 81.09,119.67 80.81,119.39 80.81,118.97 80.51,118.67 79.13,118.67 78.84,118.37 78.84,117.96 78.54,117.66 78.02,117.66 77.82,117.47 77.82,116.88 77.57,116.64 75.79,116.64 75.06,115.9 73.59,115.9 73.49,116 73.49,116.61 73.42,116.68 73.11,116.68 73,116.57 73,116.07 72.89,115.96 72.74,115.96 72.63,116.07 72.63,116.54 72.51,116.66 72.27,116.66 72.16,116.55 72.16,115.75 72.25,115.65 72.52,115.65 72.83,115.34 72.83,113.94 73.11,113.67 73.53,113.67 74.03,113.17 v2(74.32,113.17)
  BOTTOM w0.241: R961.2 101.57,114.66 v2(101.23,114.32) 100.74,114.81 99.03,114.81 99.03,114.81 97.74,114.81 v2(97.23,115.32)
RLD3_C3_72B_A18: length 157.8
  TOP w0.152: U1.D31 v2(98.24,73.84) ; U142.G12 v2(76.32,111.17) ; U141.G12 v2(99.23,117.32)
  03_SIG1 w0.173: 79.83,108.81 79.82,108.82 79.82,109.38 79.54,109.67 77.05,109.67 76.83,109.89 76.83,110.36 76.32,110.86 v2(76.32,111.17) ; v2(99.23,117.32) 99.23,116.09 98.73,115.59 98.73,114.1 99.01,113.81 99.47,113.81 99.72,113.56 99.72,111.1 99.44,110.82 98.99,110.82 98.73,110.56 98.73,109.85 98.83,109.75 99.2,109.75 99.28,109.66 99.28,109.48 99.2,109.39 98.83,109.39 98.74,109.31 98.74,108.84 98.36,108.46
  03_SIG1 w0.292: 98.36,108.46 95.66,105.75 93.26,105.75 93.02,105.99 93.02,106.33 92.69,106.67 92.34,106.67 92.04,106.36 92.04,106.02 91.77,105.75 91.3,105.75 91.03,106.03 91.03,106.37 90.73,106.67 90.32,106.67 90.01,106.37 90.01,106.02 89.74,105.75 89.4,105.75 89.13,106.03 89.13,106.37 88.82,106.68 88.45,106.68 88.15,106.37 88.15,106.03 87.87,105.75 87.54,105.75 87.24,106.05 87.24,106.39 86.95,106.68 86.64,106.68 86.35,106.39 86.35,106.05 86.06,105.75 85.71,105.75 82.96,108.51 80.13,108.51 79.83,108.81
  07_SIG3 w0.173: 68.91,109.67 74.63,109.67 74.87,109.9 75.41,109.9 75.59,110.09 75.59,110.97 75.78,111.17 v2(76.32,111.17) ; 94.39,79.55 94.64,79.3 95.45,79.3 95.73,79.02 95.73,77.55 95.91,77.37 96.5,77.37 96.74,77.13 96.74,75.64 97.03,75.34 97.48,75.34 97.74,75.08 97.74,74.58 98.24,74.08 v2(98.24,73.84)
  07_SIG3 w0.292: 68.91,109.67 68.61,109.67 68.55,109.72 67.1,109.72 66.7,109.32 66.7,108.97 66.86,108.81 67.38,108.81 67.54,108.65 67.54,108.36 67.36,108.18 66.86,108.18 66.7,108.02 66.7,107.58 66.99,107.29 68.05,107.29 68.59,106.74 68.82,106.74 69.04,106.96 69.04,108.6 69.23,108.79 69.54,108.79 69.67,108.67 69.67,107.55 69.82,107.4 70.13,107.4 70.34,107.61 70.34,108.53 70.44,108.63 70.9,108.63 70.99,108.54 70.99,107.66 71.16,107.49 72.03,107.49 72.9,106.63 76.78,106.63 77.29,106.12 78.46,106.12 80.11,104.47 80.87,104.47 81.2,104.14 81.2,102.57 81.04,102.4 79.34,102.4 79.12,102.18 79.12,101.83 79.25,101.7 81.98,101.7 82.61,101.07 83.68,101.07 84.12,100.64 84.12,99.89 83.79,99.57 83.79,94.45 83.44,94.09 82.77,94.09 82.48,93.8 82.48,93.34 82.64,93.17 83.8,93.17 84.3,93.67 84.3,98.86 84.45,99.02 84.68,99.02 84.91,98.78 84.91,93.33 85.07,93.17 86.56,93.17 86.74,92.99 86.74,92.7 86.58,92.54 85.86,92.54 85.69,92.37 85.69,91.89 85.52,91.72 85.28,91.72 85.11,91.89 85.11,92.37 84.93,92.54 84.69,92.54 84.52,92.37 84.52,91.89 84.35,91.72 84.11,91.72 83.94,91.89 83.94,92.37 83.77,92.54 82.69,92.54 82.45,92.3 82.45,91.72 82.63,91.53 83.29,91.53 83.64,91.19 86.26,91.19 86.77,90.68 86.99,90.68 87.34,91.03 87.56,91.03 87.78,90.8 87.78,90.58 87.44,90.23 87.44,90.01 87.66,89.79 87.88,89.79 88.23,90.13 88.45,90.13 88.68,89.91 88.68,89.69 88.33,89.34 88.33,89.12 88.55,88.89 88.77,88.89 89.12,89.24 89.34,89.24 89.57,89.02 89.57,88.8 89.22,88.45 89.22,88.23 89.44,88 89.66,88 90.01,88.35 90.23,88.35 90.46,88.13 90.46,87.91 90.11,87.56 90.11,87.34 90.33,87.11 90.55,87.11 90.9,87.46 91.13,87.46 91.35,87.24 91.35,87.02 91,86.67 91,86.44 91.66,85.78 91.66,82.28 94.39,79.55
  BOTTOM w0.241: v2(99.23,117.32) 99.75,116.8 100.97,116.8 100.97,116.81 101.7,116.81 R962.2
RLD3_C3_72B_A19: length 155.4
  TOP w0.152: U141.H1 v2(87.23,115.32) ; U142.H1 v2(74.32,123.17) ; v2(99.24,73.84) U1.E31
  TOP w0.241: v2(87.23,115.32) 86.67,115.88 84.72,115.88 84.55,115.71 R963.2
  03_SIG1 w0.173: v2(87.23,115.32) 87.23,115.11 87.73,114.61 87.73,114.1 88,113.82 89.42,113.82 89.73,114.13 89.73,114.51 90.04,114.82 93.56,114.82 93.7,114.97 93.7,117.08 94.06,117.44 94.06,118.36 93.6,118.82 92.97,118.82 92.73,119.07 92.73,119.61 92.52,119.81 91.96,119.81 91.72,120.05 91.72,120.58 91.49,120.81 91,120.81 90.74,121.07 90.74,121.51 90.43,121.82 89.99,121.82 89.74,122.07 89.74,122.53 89.44,122.82 88.92,122.82 88.73,123.02 88.73,123.59 88.49,123.83 87.62,123.83 87.43,123.63 87.43,123.47 87.28,123.32 86.96,123.32 86.79,123.5 86.79,123.75 86.62,123.93 86.27,123.93 86.1,123.75 86.1,123.5 85.93,123.32 85.26,123.32 84.94,123.65 84.94,123.87 84.76,124.05 82.65,124.05 82.56,124.14 82.56,124.28 82.47,124.37 82.29,124.37 82.2,124.28 82.2,124.14 82.11,124.05 81.94,124.05 81.85,124.14 81.85,124.28 81.76,124.37 81.58,124.37 81.49,124.28 81.49,124.14 81.4,124.05 81.22,124.05 81.14,124.14 81.14,124.28 81.05,124.37 80.87,124.37 80.78,124.28 80.78,124.14 80.69,124.05 80.51,124.05 80.42,124.14 80.42,124.28 80.34,124.37 80.16,124.37 80.07,124.28 80.07,124.14 79.98,124.05 79.66,124.05 79.57,124.14 79.57,124.26 79.46,124.37 79.21,124.37 79.1,124.26 79.1,124.14 79.01,124.05 78.79,124.05 78.66,124.17 78.66,124.23 78.54,124.36 78.25,124.36 78.12,124.23 78.12,124.2 77.97,124.05 77.72,124.05 77.6,124.17 77.6,124.23 77.45,124.38 77.18,124.38 77.06,124.26 77.06,124.18 76.93,124.05 76.68,124.05 76.53,124.2 76.53,124.26 76.4,124.38 76.15,124.38 76.02,124.26 76.02,124.18 75.89,124.05 75.6,124.05 75.49,124.16 75.49,124.26 75.37,124.38 75.06,124.38 74.97,124.29 74.97,124.1 74.88,124.01 74.63,124.01 74.54,124.1 74.54,124.29 74.45,124.38 73.99,124.38 73.85,124.24 73.85,124.07 73.97,123.94 74.15,123.94 74.5,123.59 74.5,123.35 v2(74.32,123.17)
  20_SIG7 w0.089: v2(99.24,73.84) 99.74,74.34 99.74,76.05 99.44,76.34 99.03,76.34 98.74,76.64 98.74,77.05 98.44,77.34 98.03,77.34 97.74,77.64 97.74,78.05 97.44,78.34 97.03,78.34 96.74,78.64 96.74,79.05 96.44,79.34 96.03,79.34 95.74,79.64 95.74,80.07 95.46,80.34 94.75,80.34 94.39,80.7 ; 87.66,124.6 87.66,123.77 87.73,123.7 87.73,112.12 88.02,111.82 90.48,111.82 90.73,111.58 90.73,109.07 91.34,108.46
  20_SIG7 w0.157: 94.39,80.7 93.77,81.32 93.77,88.09 96.26,90.58 96.26,96.99 95.92,97.32 95.92,101.1 96.14,101.32 96.14,102.23 95.51,102.86 95.51,103.55 93.78,105.28 93.78,107.44 93.12,108.1 91.69,108.1 91.34,108.46 ; v2(74.32,123.17) 74.32,123.49 74.07,123.74 68.8,123.74 68.31,124.23 68.31,126.99 68.96,127.65 70.24,127.65 71,128.41 71,132.55 71.6,133.14 89.59,133.14 89.79,132.94 89.79,132.38 89.18,131.78 89.18,126.59 87.66,125.07 87.66,124.6
RLD3_C3_72B_A20: length 162.2
  TOP w0.152: U141.F2 v2(88.23,118.32) ; U1.R28 109.74,70.34 v2(109.24,70.84) ; U142.F2 v2(77.32,122.17)
  14_SIG4 w0.089: v2(88.23,118.32) 88.63,118.32 88.75,118.44 88.75,118.65 88.59,118.81 87.99,118.81 87.71,119.09 87.71,119.55 88.01,119.85 88.45,119.85 88.75,119.56 88.75,119.07 89.01,118.8 89.43,118.8 89.72,118.51 89.72,117.96 89.85,117.83 90.57,117.83 90.75,118.01 90.75,118.59 90.97,118.81 92.45,118.81 92.71,119.07 92.71,119.64 92.52,119.83 90.87,119.83 90.74,119.69 90.74,119.16 90.41,118.84 89.98,118.84 89.71,119.11 89.71,119.7 89.6,119.8 88.99,119.8 88.71,120.08 88.71,120.61 88.48,120.84 87.87,120.84 87.73,120.7 87.73,120.09 87.44,119.8 86.9,119.8 86.67,120.03 86.67,120.72 86.55,120.84 85.98,120.84 85.32,121.49 84.42,121.49 84.3,121.61 84.3,121.85 84.38,121.93 86.08,121.93 86.19,122.03 86.19,122.26 86.1,122.35 85.58,122.35 85.49,122.44 85.49,122.93 85.4,123.01 85.22,123.01 85.13,122.93 85.13,122.44 85.04,122.35 84.87,122.35 84.78,122.44 84.78,123.22 84.67,123.33 84.51,123.33 84.42,123.24 84.42,122.44 84.11,122.12 83.07,122.12 82.95,122.24 82.95,123.15 82.84,123.26 82.65,123.26 82.57,123.18 82.57,122.8 82.44,122.67 82.3,122.67 82.21,122.76 82.21,123.2 82.12,123.29 81.95,123.29 81.86,123.2 81.86,122.76 81.77,122.67 79.97,122.67 79.81,122.5 79.81,121.92 79.57,121.68 79.14,121.68 78.82,122 78.82,122.58 78.73,122.67 77,122.67 76.8,122.47 76.8,122.29 76.93,122.17 v2(77.32,122.17)
  20_SIG7 w0.089: v2(109.24,70.84) 109.14,70.84 108.71,71.27 108.03,71.27 107.77,71.53 107.77,73.03 107.47,73.33 99.09,73.33 98.78,73.63 98.78,74.09 98.55,74.32 98.07,74.32 97.76,74.63 97.76,75.16 97.59,75.34 97.08,75.34 96.77,75.64 96.77,77.06 96.49,77.34 96.09,77.34 95.81,77.62 95.81,78 95.48,78.33 94.39,78.33
  20_SIG7 w0.157: v2(77.32,122.17) 76.83,122.65 76.83,124.73 76.58,124.99 75.49,124.99 75.29,125.2 75.29,125.93 75.13,126.09 74.55,126.09 74.42,125.96 74.42,125.3 74.12,124.99 69.85,124.99 69.62,125.22 69.62,125.63 69.82,125.83 73.2,125.83 73.48,126.11 73.48,127.41 73.74,127.66 74.96,127.66 76.1,128.8 76.1,130.28 75.82,130.56 75.82,131.55 76.24,131.97 84.28,131.97 84.71,131.55 84.71,125.55 86.11,124.16 86.11,122.91 85.72,122.53 85.72,108.33 87.73,106.32 90.73,106.32 93.62,103.43 93.62,99.23 94.74,98.11 94.74,90.69 92.34,88.29 92.34,79.95 93.95,78.33 94.39,78.33
  BOTTOM w0.241: R990.2 86.66,117.82 87.73,117.82 v2(88.23,118.32)
RLD3_C3_72B_BA0: length 162.3
  TOP w0.152: U141.G9 v2(96.23,117.32) ; U142.G9 v2(76.32,114.17) ; v2(99.24,75.84) 99.74,75.34
  03_SIG1 w0.173: v2(96.23,117.32) 96.23,117.03 95.53,116.33 94.95,116.33 94.75,116.14 94.75,113.96 94.9,113.81 95.48,113.81 95.73,113.57 95.73,111.97 95.58,111.82 95.01,111.82 94.01,110.82 86.41,110.82 85.41,111.82 84.52,111.82 83.68,112.67 76.01,112.67 75.35,112 75.35,110.81 75.21,110.67 74.98,110.67 74.85,110.79 74.85,111.49 74.68,111.67 71.1,111.67 70.82,111.94 70.82,112.51 70.98,112.67 74.82,112.67 v2(76.32,114.17)
  07_SIG3 w0.173: v2(76.32,114.17) 76.64,114.17 77.13,113.67 78.57,113.67 78.81,113.43 78.81,112.98 79.14,112.66 79.53,112.66 79.81,112.93 79.81,113.53 79.93,113.66 81.66,113.66 81.82,113.49 81.82,112.82 81.68,112.67 80.98,112.67 80.84,112.53 80.84,111.89 81.08,111.66 81.73,111.66 81.82,111.56 81.82,109.95 82.7,109.07 82.7,108.81 ; 94.51,88.63 94.44,88.56 94.44,83.79 94.89,83.34 95.44,83.34 95.74,83.05 95.74,82.64 96.03,82.34 96.44,82.34 96.74,82.05 96.74,81.64 97.03,81.34 97.44,81.34 97.74,81.05 97.74,80.64 98.03,80.34 98.57,80.34 98.79,80.12 98.79,79.61 99.05,79.35 99.54,79.35 99.69,79.51 99.69,80.17 99.87,80.34 100.53,80.34 100.69,80.19 100.69,79.55 100.95,79.29 101.44,79.29 101.67,79.52 101.67,80.16 101.85,80.34 102.63,80.34 102.8,80.17 102.8,79.46 102.98,79.28 103.64,79.28 103.75,79.39 103.75,80.26 103.89,80.4 104.47,80.4 104.67,80.19 104.67,78.55 104.47,78.35 102.89,78.35 102.71,78.52 102.71,79.07 102.44,79.34 101.97,79.34 101.75,79.12 101.75,78.56 101.54,78.35 100.89,78.35 100.72,78.52 100.72,79.06 100.46,79.32 100,79.32 99.81,79.13 99.81,77.66 100.08,77.38 101.56,77.38 101.74,77.56 101.74,78.02 102.03,78.31 102.46,78.31 102.67,78.09 102.67,77.6 102.89,77.38 105.46,77.38 105.68,77.16 105.68,76.53 105.45,76.3 102.9,76.3 102.7,76.51 102.7,77.06 102.43,77.33 102.04,77.33 101.68,76.96 101.68,75.56 101.47,75.36 99.72,75.36 v2(99.24,75.84)
  07_SIG3 w0.292: 82.7,108.81 82.7,108.06 86.37,104.39 88.22,104.39 88.3,104.31 88.54,104.31 88.71,104.48 88.71,105.01 88.88,105.18 89.12,105.18 89.29,105.01 89.29,104.04 89.49,103.85 89.72,103.85 89.88,104.01 89.88,105.01 90.05,105.18 90.29,105.18 90.46,105.01 90.46,103.98 90.64,103.81 90.88,103.81 91.05,103.97 91.05,105.01 91.22,105.18 91.46,105.18 91.63,105.01 91.63,104.48 91.8,104.31 92.04,104.31 92.21,104.48 92.21,105.01 92.38,105.18 92.63,105.18 92.8,105.01 92.8,104.48 92.97,104.31 93.21,104.31 93.38,104.48 93.38,105.01 93.55,105.18 94.36,105.18 94.58,104.95 94.58,104.36 93.26,103.04 92.85,103.04 92.23,103.65 91.71,103.65 91.34,103.28 91.34,102.87 91.63,102.58 92.03,102.58 92.33,102.28 92.33,97.69 91.94,97.31 91.94,96.95 92.13,96.77 92.48,96.77 93.16,97.44 93.36,97.44 94.51,96.3 94.51,88.63
  BOTTOM w0.241: R978.2 101.77,115.55 101.5,115.82 100.99,115.82 100.46,116.36 99.11,116.36 98.73,116.74 98.73,117.53 98.45,117.81 98.07,117.81 97.74,118.14 97.74,118.57 97.46,118.85 96.98,118.85 96.72,118.59 96.72,117.82 v2(96.23,117.32)
RLD3_C3_72B_BA1: length 163.3
  TOP w0.152: v2(100.24,75.84) 100.74,75.34 ; U142.G5 v2(76.32,119.17) ; U141.G5 v2(91.23,117.32)
  TOP w0.241: v2(90.23,109.32) 90.23,108.66 R977.2
  05_SIG2 w0.262: v2(91.23,117.32) 91.23,116.49 91.73,115.99 91.73,111.12 91.43,110.82 91.02,110.82 90.73,110.53 90.73,109.82 v2(90.23,109.32)
  07_SIG3 w0.173: v2(91.23,117.32) 91.23,116.94 90.62,116.33 86.49,116.33 84.2,118.62 84.2,118.87 84.29,118.96 84.57,118.96 84.67,119.05 84.67,119.34 84.6,119.41 84.31,119.41 84.21,119.51 84.21,119.75 84.29,119.84 84.63,119.84 84.72,119.93 84.72,120.18 84.63,120.27 84.29,120.27 84.2,120.35 84.2,120.61 84.11,120.69 82.97,120.69 82.88,120.78 82.88,120.98 82.99,121.08 84.11,121.08 84.22,121.2 84.22,122 83.95,122.28 83.18,122.28 83.05,122.42 83.05,123.3 83.11,123.37 84,123.37 84.1,123.46 84.1,123.69 84.01,123.78 83.16,123.78 83.07,123.86 83.07,124.09 83.15,124.17 83.97,124.17 84.06,124.26 84.06,124.46 83.95,124.58 83.1,124.58 83.06,124.62 83.06,124.71 83.01,124.76 82.75,124.76 82.66,124.68 82.66,122.75 82.57,122.66 82.39,122.66 82.26,122.79 82.26,124.66 82.16,124.76 81.53,124.76 81.38,124.62 81.38,123.94 81.48,123.85 81.75,123.85 81.82,123.78 81.82,121.86 81.63,121.67 80.98,121.67 80.82,121.51 80.82,119.92 80.57,119.66 80.03,119.66 79.82,119.87 79.82,120.53 79.69,120.67 77.97,120.67 77.82,120.52 77.82,119.94 77.55,119.67 76.82,119.67 v2(76.32,119.17) 75.68,119.81 75.34,119.81 75.11,119.58 75.11,118.8 74.98,118.67 73.1,118.67 72.82,118.95 72.82,119.5 72.64,119.68 72.12,119.68 71.84,119.97 71.84,120.42 72.07,120.65 72.66,120.65 72.82,120.81 72.82,122.4 72.54,122.68 69.96,122.68 69.84,122.55 69.84,121.82 69.97,121.68 71.52,121.68 71.81,121.39 71.81,120.97 71.51,120.67 70.09,120.67 69.82,120.4 69.82,119.91 70.05,119.68 71.53,119.68 71.81,119.41 71.81,118.95 71.53,118.67 70.03,118.67 69.82,118.47 69.82,117.86 70,117.68 70.61,117.68 70.81,117.48 70.81,116.69 70.63,116.52 69.82,116.52 69.65,116.35 69.65,116 69.82,115.83 70.63,115.83 70.81,115.66 70.81,114.86 71,114.67 71.53,114.67 71.78,114.92 71.78,114.94 71.81,114.97 71.81,115.68 71.98,115.85 72.19,115.85 72.36,116.02 72.36,116.37 72.19,116.54 71.98,116.54 71.81,116.71 71.81,118.39 72.09,118.67 72.57,118.67 72.81,118.43 72.81,116.48 72.98,116.3 73.87,116.3 74.07,116.1 74.07,115.85 73.9,115.68 73.05,115.68 72.81,115.44 72.81,114.89 73.03,114.67 73.54,114.67 73.82,114.39 73.82,113.94 74.08,113.67 74.68,113.67 74.85,113.5 74.85,112.93 74.99,112.79 75.58,112.79 75.83,113.04 75.83,113.58 75.91,113.67 76.59,113.67 76.83,113.42 76.83,112.93 77.09,112.67 78.53,112.67 78.82,112.37 78.82,111.96 79.12,111.67 80.51,111.67 80.81,111.37 80.81,110.79 80.67,110.65 79.96,110.65 79.82,110.51 79.82,109.91 80.07,109.67 81.58,109.67 81.87,109.38 81.87,108.81 ; v2(100.24,75.84) 99.7,76.38 99.7,77.09 99.45,77.34 99.03,77.34 98.7,77.67 98.7,79.17 98.53,79.34 97.97,79.34 97.74,79.58 97.74,80.05 97.44,80.34 97.03,80.34 96.74,80.64 96.74,81.05 96.44,81.34 95.95,81.34 95.74,81.55 95.74,82.05 95.44,82.34 94.57,82.34 94.39,82.53
  07_SIG3 w0.292: 81.87,108.81 81.87,107.92 85.8,103.99 85.8,102.5 86.2,102.11 86.35,102.11 86.97,102.73 87.21,102.73 87.38,102.56 87.38,102.32 86.84,101.78 86.84,101.46 87.11,101.19 87.53,101.19 87.99,101.65 87.99,102.97 88.21,103.2 89.09,103.2 89.26,103.03 89.26,102.41 89.43,102.24 89.67,102.24 89.89,102.46 90.67,102.46 91.01,102.12 91.01,101.16 91.3,100.86 91.49,100.86 91.64,100.71 91.64,100.42 91.46,100.23 91.27,100.23 91.06,100.03 91.06,98.76 91.48,98.33 91.48,97.97 90.73,97.22 90.73,96.85 91.03,96.55 91.03,96.27 93.83,93.47 93.83,83.08 94.39,82.53
RLD3_C3_72B_BA2: length 160.5
  TOP w0.152: v2(100.24,72.84) U1.F30 ; U142.H8 v2(74.32,115.17) ; U141.H8 v2(95.23,115.32)
  TOP w0.241: R976.2 95.92,108.63 v2(95.23,109.32)
  05_SIG2 w0.262: v2(95.23,115.32) 94.72,114.81 94.72,109.83 v2(95.23,109.32)
  07_SIG3 w0.173: v2(74.32,115.17) 75.47,115.17 75.97,114.67 82.59,114.67 82.83,114.43 82.83,109.95 83.4,109.39 83.4,108.81 ; v2(100.24,72.84) 100.24,73.14 99.71,73.67 99.71,74.2 99.89,74.37 101.42,74.37 101.73,74.68 101.73,75.05 101.99,75.31 107.42,75.31 107.72,75.01 107.72,74.65 108.07,74.31 110.48,74.31 110.71,74.08 110.71,72.54 110.88,72.36 111.53,72.36 111.72,72.55 111.72,74.12 111.91,74.32 112.47,74.32 112.69,74.1 112.69,72.54 112.87,72.36 115.56,72.36 115.73,72.54 115.73,73.19 115.56,73.36 113.9,73.36 113.73,73.54 113.73,74.17 113.93,74.37 115.59,74.37 115.73,74.51 115.73,75.14 115.51,75.36 107.99,75.36 107.68,75.68 107.68,76.18 107.53,76.33 106.97,76.33 106.7,76.6 106.7,77.11 106.46,77.35 106.02,77.35 105.77,77.6 105.77,81.14 105.56,81.34 99.88,81.34 99.72,81.18 99.72,80.64 99.44,80.37 98.96,80.37 98.7,80.62 98.7,81.19 98.55,81.34 98.03,81.34 97.74,81.64 97.74,82.05 97.44,82.34 97.03,82.34 96.74,82.64 96.74,83.05 96.44,83.34 96.03,83.34 95.66,83.72 95.66,84.02 95.4,84.28 95.1,84.28 94.79,84.58 94.79,88.01 95.22,88.44 95.22,90.96
  07_SIG3 w0.292: 95.22,90.96 95.22,96.6 94.34,97.49 94.34,97.51 93.8,98.05 93.8,102.61 95.26,104.07 95.26,105.66 95.05,105.87 87.76,105.87 87.56,105.67 87.56,105.46 87.36,105.26 87.08,105.26 86.89,105.46 86.89,105.67 86.69,105.87 85.86,105.87 83.4,108.33 83.4,108.81
  14_SIG4 w0.089: v2(95.23,115.32) 95.15,115.4 95.15,115.65 95.33,115.83 96.59,115.83 96.68,115.92 96.68,116.08 96.23,116.53 95.76,116.53 95.65,116.42 95.65,116.26 95.54,116.15 95.39,116.15 95.28,116.26 95.28,116.42 95.17,116.53 95.02,116.53 94.91,116.42 94.91,115.98 94.82,115.89 94.66,115.89 94.53,116.01 94.53,116.42 94.42,116.53 91.72,116.53 91.3,116.11 86.69,116.11 85.58,117.22 85.2,117.22 84.45,117.97 84.29,117.97 84.06,117.74 83.91,117.74 83.8,117.85 83.8,118 84.03,118.23 84.03,118.39 83.75,118.67 81.04,118.67 80.82,118.45 80.82,117.96 80.53,117.67 79.04,117.67 78.82,117.45 78.82,116.79 79,116.61 79.43,116.61 79.82,116.22 79.82,116.06 79.73,115.97 78.66,115.97 78.55,116.08 78.55,116.56 78.43,116.67 78.28,116.67 78.17,116.57 78.17,116.08 78.06,115.97 77.76,115.97 77.65,116.08 77.65,116.25 77.55,116.36 77.39,116.36 77.28,116.24 77.28,116.08 77.17,115.97 77.02,115.97 76.91,116.08 76.91,116.2 76.8,116.3 76.64,116.3 76.53,116.2 76.53,116.08 76.42,115.97 76.27,115.97 76.16,116.08 76.16,116.2 76.05,116.3 75.9,116.3 75.79,116.2 75.79,116.08 75.68,115.97 75.61,115.97 74.88,115.23 74.88,113.82 74.72,113.67 74.11,113.67 73.82,113.96 73.82,115.46 73.95,115.58 74.2,115.58 74.32,115.47 v2(74.32,115.17)
RLD3_C3_72B_BA3: length 162.7
  TOP w0.152: U141.H6 v2(92.23,115.32) ; v2(101.24,72.84) U1.G30 ; U142.H6 v2(74.32,118.17)
  TOP w0.241: v2(91.23,109.32) 91.23,108.66 R975.2
  05_SIG2 w0.262: v2(91.23,109.32) 91.73,109.82 91.73,110.53 92.02,110.82 92.43,110.82 92.73,111.12 92.73,114.82 v2(92.23,115.32)
  07_SIG3 w0.173: 84.35,108.81 83.87,109.29 83.87,115.43 83.46,115.84 74.86,115.84 73.82,116.89 73.82,117.66 v2(74.32,118.17) 75.49,118.17 75.99,118.67 81.58,118.67 81.82,118.91 81.82,119.48 82,119.65 82.68,119.65 82.83,119.5 82.83,118.86 83.02,118.67 83.52,118.67 86.31,115.87 88.38,115.87 88.73,115.53 88.73,115.12 89.02,114.82 93.86,114.82 94.03,115 94.03,115.72 93.94,115.8 93.3,115.8 93.19,115.91 93.19,116.12 93.27,116.2 94.04,116.2 94.13,116.29 94.13,116.51 94.03,116.61 93.62,116.61 93.54,116.7 93.54,116.86 93.96,117.28 93.96,122.6 93.74,122.82 92.94,122.82 92.74,122.62 92.74,119.12 92.74,119.12 92.74,118.53 92.74,118.52 92.74,118.12 92.74,118.12 92.74,117.53 92.74,117.52 92.74,117.12 92.74,117.12 92.74,115.83 v2(92.23,115.32) ; v2(101.24,72.84) 100.93,72.84 100.79,72.98 100.79,73.23 100.92,73.37 101.39,73.37 101.74,73.72 101.74,74.09 101.96,74.32 107.51,74.32 107.75,74.07 107.75,73.64 108.03,73.37 109.53,73.37 109.7,73.2 109.7,71.48 109.87,71.3 117.48,71.3 117.71,71.54 117.71,72.06 117.45,72.32 116.92,72.32 116.77,72.47 116.77,76.11 116.53,76.35 107.98,76.35 107.71,76.62 107.71,76.97 107.41,77.28 107.09,77.28 106.76,77.61 106.76,82.1 106.51,82.34 99.89,82.34 99.75,82.19 99.75,81.69 99.42,81.36 99.03,81.36 98.73,81.66 98.73,82.09 98.48,82.34 98.03,82.34 97.74,82.64 97.74,83.05 97.44,83.34 97.03,83.34 96.74,83.64 96.74,84.05 96.53,84.26 96.13,84.26 95.71,84.68 95.71,88.06 95.91,88.27 95.91,90.96
  07_SIG3 w0.292: 84.35,108.81 85.44,107.73 86.26,107.73 87.19,106.79 93.31,106.79 94.28,107.75 95.15,107.75 95.53,107.37 95.53,106.47 95.96,106.03 95.96,103.82 95.02,102.88 95.02,101.52 95.51,101.04 95.51,97.28 95.91,96.88 95.91,90.96
RLD3_C3_72B_CK_N: length 160.5
  TOP w0.145: v2(76.32,117.17) U142.G7 ; v2(93.23,117.32) U141.G7 ; v2(102.24,72.84) U1.H30
  03_SIG1 w0.137: 83.59,116.65 83.63,116.65 83.67,116.61 83.75,116.61 83.82,116.68 83.82,116.79 84.07,117.04 84.3,117.04 84.43,117.16 84.43,117.36 84.33,117.46 84.08,117.46 83.85,117.7 83.85,118.09 84.08,118.33 84.38,118.33 84.48,118.43 84.48,118.65 84.4,118.73 84.06,118.73 83.85,118.95 83.85,119.38 84.06,119.6 84.48,119.6 84.56,119.67 84.56,119.92 84.48,120 84.06,120 83.85,120.21 83.85,120.97 84.06,121.18 84.45,121.18 84.52,121.25 84.52,121.65 84.74,121.87 85.41,121.87 85.64,121.63 85.64,121.1 85.77,120.98 85.82,120.98 86.13,120.66 86.13,120.35 85.98,120.19 85.98,119.92 86.05,119.86 86.45,119.86 86.7,119.6 86.7,119.3 86.45,119.04 86.05,119.04 85.93,118.92 85.93,118.8 86.05,118.68 86.45,118.68 86.7,118.43 86.7,118.1 86.46,117.86 85.85,117.86 85.34,117.35 85.34,116.87 85.45,116.76 86.74,116.76 86.78,116.8 86.82,116.8
  03_SIG1 w0.178: v2(76.32,117.17) 75.56,117.17 75.39,116.99 75.39,116.69 75.06,116.36 73.33,116.36 73.23,116.26 73.23,116.05 73.3,115.98 75.43,115.98 76.1,116.65 83.59,116.65 ; 86.82,116.8 87.42,116.8 87.74,116.48 87.96,116.48 88.27,116.8 88.87,116.8 89.21,116.46 89.21,116.34 89.36,116.18 89.58,116.18 89.74,116.34 89.74,116.46 90.07,116.8 90.55,116.8 90.88,116.46 90.88,116.34 91.04,116.18 91.26,116.18 91.41,116.34 91.41,116.46 91.75,116.8 92.18,116.8 92.47,116.51 93.04,116.51 93.23,116.7 v2(93.23,117.32)
  07_SIG3 w0.127: 97.15,86.33 96.84,86.64 96.84,89.5 96.89,89.54 ; v2(102.24,72.84) 102.24,72.88 102.6,73.24 107.4,73.24 107.63,73.01 107.63,72.5 107.89,72.24 108.43,72.24 108.63,72.03 108.63,71.21 108.63,71.21 108.63,70.59 108.99,70.24 118.03,70.24 118.47,70.67 118.47,72.64 118.22,72.89 117.99,72.89 117.86,73.02 117.86,73.27 117.99,73.4 118.22,73.4 118.47,73.65 118.47,74.1 118.22,74.35 118.02,74.35 117.89,74.48 117.89,74.73 118.02,74.86 118.22,74.86 118.47,75.11 118.47,75.54 118.22,75.79 118.02,75.79 117.89,75.92 117.89,76.23 118.29,76.63 118.29,77.17 118.01,77.45 108.02,77.45 107.84,77.63 107.84,83.17 107.56,83.45 98.03,83.45 97.84,83.64 97.84,84.37 97.72,84.49
  07_SIG3 w0.178: v2(76.32,117.17) 75.78,117.71 75.29,117.71 75,117.41 75,116.92 75.35,116.57 83.59,116.57
  07_SIG3 w0.208: 83.59,116.57 84.09,116.57 84.7,115.96 84.7,109.94 85.88,108.75 98.42,108.75 98.94,108.24 98.94,107.69 98.55,107.3 98.33,107.3 98.12,107.09 98.12,106.68 98.33,106.47 98.55,106.47 98.94,106.08 98.94,105.47 97.81,104.34 97.81,103.53 96.96,102.68 96.73,102.68 96.45,102.4 96.45,98.12 96.89,97.68 96.89,89.54
  07_SIG3 w0.237: 97.15,86.33 97.44,86.33 97.72,86.05 97.72,84.49
  BOTTOM w0.145: v2(93.23,117.32) 93.1,117.45 92.93,117.45 92.76,117.28 92.76,117.09 92.5,116.83 R1292.1
RLD3_C3_72B_CK_P: length 160.4
  TOP w0.145: v2(93.23,115.32) U141.H7 ; U142.H7 v2(74.32,117.17) ; U1.H29 v2(102.24,71.84)
  03_SIG1 w0.137: 86.82,116.49 86.78,116.49 86.74,116.53 85.36,116.53 85.12,116.77 85.12,117.44 85.76,118.08 86.37,118.08 86.48,118.19 86.48,118.34 86.36,118.46 85.95,118.46 85.7,118.71 85.7,119.02 85.95,119.27 86.36,119.27 86.48,119.39 86.48,119.51 86.36,119.63 85.95,119.63 85.75,119.83 85.75,120.29 85.91,120.44 85.91,120.57 85.73,120.75 85.67,120.75 85.42,121.01 85.42,121.54 85.32,121.64 84.84,121.64 84.75,121.55 84.75,121.16 84.55,120.96 84.15,120.96 84.07,120.88 84.07,120.31 84.15,120.23 84.57,120.23 84.78,120.02 84.78,119.58 84.57,119.37 84.16,119.37 84.07,119.29 84.07,119.04 84.15,118.96 84.49,118.96 84.71,118.75 84.71,118.34 84.47,118.1 84.17,118.1 84.07,118 84.07,117.79 84.17,117.69 84.42,117.69 84.66,117.46 84.66,117.07 84.4,116.81 84.16,116.81 84.05,116.7 84.05,116.59 83.85,116.38 83.67,116.38 83.63,116.34 83.59,116.34
  03_SIG1 w0.178: v2(74.32,117.17) 74.91,117.17 75.08,116.99 75.08,116.81 74.93,116.66 73.2,116.66 72.92,116.38 72.92,115.93 73.18,115.67 75.55,115.67 76.23,116.34 83.59,116.34 ; v2(93.23,115.32) 92.06,116.49 91.88,116.49 91.72,116.34 91.72,116.21 91.38,115.87 90.91,115.87 90.58,116.21 90.58,116.34 90.42,116.49 90.2,116.49 90.04,116.34 90.04,116.21 89.71,115.87 89.24,115.87 88.9,116.21 88.9,116.34 88.74,116.49 88.4,116.49 88.08,116.18 87.61,116.18 87.3,116.49 86.82,116.49
  07_SIG3 w0.127: 97.43,84.32 97.63,84.12 97.63,83.55 97.94,83.24 107.48,83.24 107.63,83.09 107.63,77.54 107.93,77.24 117.92,77.24 118.08,77.08 118.08,76.72 117.68,76.32 117.68,75.83 117.93,75.58 118.13,75.58 118.25,75.45 118.25,75.2 118.13,75.07 117.93,75.07 117.68,74.82 117.68,74.39 117.93,74.14 118.13,74.14 118.25,74.02 118.25,73.73 118.13,73.61 117.9,73.61 117.65,73.36 117.65,72.93 117.9,72.68 118.13,72.68 118.25,72.55 118.25,70.76 117.94,70.45 109.08,70.45 108.84,70.68 108.84,71.21 108.84,71.21 108.84,72.12 108.51,72.45 107.98,72.45 107.84,72.59 107.84,73.09 107.48,73.45 102.09,73.45 101.75,73.11 101.75,72.59 102.24,72.11 v2(102.24,71.84) ; 96.63,86.41 96.63,89.5 96.59,89.54
  07_SIG3 w0.178: 83.59,116.27 75.22,116.27 v2(74.32,117.17)
  07_SIG3 w0.208: 96.59,89.54 96.59,97.55 96.14,98 96.14,102.52 96.6,102.98 96.83,102.98 97.5,103.65 97.5,104.46 98.64,105.59 98.64,105.96 98.43,106.17 98.21,106.17 97.82,106.56 97.82,107.22 98.21,107.61 98.43,107.61 98.64,107.82 98.64,108.11 98.3,108.45 85.76,108.45 84.4,109.81 84.4,115.84 83.96,116.27 83.59,116.27
  07_SIG3 w0.237: 97.43,84.32 97.01,84.32 96.77,84.56 96.77,86.27 96.63,86.41
  BOTTOM w0.145: v2(93.23,115.32) 93.95,115.32 R951.1
RLD3_C3_72B_CS_B: length 169.2
  TOP w0.152: U1.N29 107.74,71.34 v2(107.24,71.84) ; U141.E12 v2(99.23,119.32) ; U142.E12 v2(78.32,111.17)
  TOP w0.241: v2(101.23,121.32) 101.43,121.52 R952.2
  03_SIG1 w0.173: v2(78.32,111.17) 78.32,111.49 78.5,111.67 83.81,111.67 84.67,110.81 85.49,110.81 86.06,110.24 86.57,110.24 86.7,110.11 86.7,109.92 86.54,109.77 86.09,109.77 85.98,109.65 85.98,109.34 86.08,109.25 87.1,109.25 87.22,109.37 87.22,109.65 87.39,109.82 93.44,109.82 93.9,110.29 94.46,110.29 95,110.82 96.47,110.82 96.72,111.07 96.72,113.52 96.42,113.82 96.01,113.82 95.73,114.1 95.73,116.02 96.47,116.76 97.36,116.76 97.73,117.13 97.73,118.58 97.97,118.82 98.45,118.82 98.72,119.09 98.72,119.52 98.43,119.81 97.99,119.81 97.73,120.08 97.73,122.71 97.84,122.82 98.62,122.82 98.73,122.71 98.73,120.12 99.23,119.62 v2(99.23,119.32)
  07_SIG3 w0.173: v2(78.32,111.17) 77.82,110.67 77.04,110.67 76.81,110.44 76.81,109.8 76.95,109.67 77.63,109.67 77.9,109.4 77.9,108.93 77.86,108.89 77.86,108.85 77.83,108.81 ; 94.39,80.54 94.59,80.34 95.44,80.34 95.74,80.05 95.74,79.57 95.97,79.34 96.44,79.34 96.74,79.05 96.74,77.61 96.98,77.37 97.53,77.37 97.74,77.17 97.74,75.64 98.03,75.34 98.44,75.34 98.74,75.05 98.74,73.64 99.03,73.34 99.44,73.34 99.74,73.05 99.74,72.64 100.03,72.34 101.44,72.34 101.74,72.05 101.74,71.64 102.03,71.34 102.56,71.34 102.72,71.5 102.72,72.09 103.02,72.39 103.56,72.39 103.76,72.19 103.76,71.47 103.89,71.34 105.59,71.34 105.76,71.17 105.76,70.48 105.61,70.33 104.83,70.33 104.67,70.18 104.67,69.77 105.08,69.37 106.48,69.37 106.73,69.62 106.73,71.34 v2(107.24,71.84)
  07_SIG3 w0.292: 94.39,80.54 92.36,82.57 92.36,87.22 92.23,87.35 92.23,87.57 92.47,87.82 92.47,88.04 92.25,88.27 92.03,88.27 91.78,88.02 91.56,88.02 91.34,88.24 91.34,88.46 92.48,89.61 92.48,89.84 92.26,90.06 92.04,90.06 90.89,88.91 90.67,88.91 90.44,89.13 90.44,89.36 92.46,91.37 92.46,91.59 92.23,91.81 92.01,91.81 90,89.8 89.78,89.8 89.55,90.02 89.55,90.25 92.2,92.89 92.2,93.12 91.98,93.34 91.76,93.34 89.11,90.69 88.89,90.69 88.66,90.91 88.66,91.11 91.34,93.79 91.34,94.01 91.11,94.23 90.89,94.23 88.24,91.58 87.99,91.58 87.77,91.81 87.77,92.03 88.69,92.95 88.69,93.17 88.47,93.39 88.25,93.39 88.02,93.16 87.53,93.16 86.61,94.08 85.83,94.08 85.6,94.31 85.6,95.25 85.75,95.41 86.08,95.41 86.18,95.51 86.18,95.9 86.05,96.04 85.75,96.04 85.6,96.19 85.6,96.51 85.75,96.67 86.08,96.67 86.23,96.82 86.23,97.11 86.05,97.3 85.75,97.3 85.6,97.45 85.6,99.16 85.33,99.42 85.33,100.77 84.98,101.12 84.6,101.12 83.98,101.74 82.99,101.74 82.47,102.26 82.47,104.5 82.27,104.7 81.91,104.7 81.64,104.98 81.64,105.77 81.41,105.99 80.95,105.99 80.7,105.74 80.7,105.57 80.52,105.39 80.26,105.39 79.23,106.42 79.23,106.83 79.52,107.12 80.05,107.12 80.29,107.37 80.29,107.67 80.14,107.82 79.07,107.82 78.88,108.01 78.88,108.49 78.72,108.66 78.53,108.66 78.35,108.48 78.35,108.17 78.07,107.9 77.24,107.9 77.11,107.77 77.11,107.5 76.95,107.34 76.64,107.34 76.48,107.5 76.48,107.77 76.32,107.93 75.1,107.93 74.95,107.77 74.95,107.47 74.79,107.31 74.48,107.31 74.32,107.47 74.32,107.77 74.16,107.93 73.85,107.93 73.69,107.77 73.69,107.47 73.53,107.31 73.22,107.31 73.06,107.47 73.06,108.12 72.77,108.41 72.01,108.41 71.86,108.56 71.86,108.99 72.1,109.23 73.54,109.23 73.7,109.08 73.7,108.78 73.9,108.57 74.86,108.57 75.06,108.78 75.06,109.18 75.22,109.34 75.54,109.34 75.69,109.18 75.69,108.78 75.9,108.57 77.58,108.57 77.83,108.81
  BOTTOM w0.241: v2(99.23,119.32) 98.73,119.82 98.73,121.53 98.98,121.78 98.98,121.78 99.02,121.82 100.47,121.82 100.97,121.32 v2(101.23,121.32)
RLD3_C3_72B_DK0_N: length 154.7
  TOP w0.145: v2(103.24,73.84) U1.J31 ; v2(93.23,121.32) U141.C7
  20_SIG7 w0.107: v2(93.23,121.32) 92.83,120.92 91.98,120.92 91.83,121.08 91.83,122.66 91.56,122.92 88.93,122.92 88.63,122.62 88.63,116.75 88.61,116.73 88.61,116.7 ; v2(103.24,73.84) 103.53,73.84 103.64,73.95 103.64,74.1 103.49,74.24 102.98,74.24 102.64,74.59 102.64,75.09 102.48,75.24 101.98,75.24 101.64,75.59 101.64,76.01 101.4,76.24 100.99,76.24 100.64,76.6 100.64,77.01 100.41,77.24 99.98,77.24 99.64,77.58 99.64,78.01 99.41,78.24 98.97,78.24 98.64,78.58 98.64,80.04 98.43,80.24 97.93,80.24 97.64,80.54 97.64,81.03 97.42,81.24 94.89,81.24 94.41,81.72 94.41,82.32 94.35,82.38
  20_SIG7 w0.108: 94.7,108.46 94.68,108.48 94.68,108.52 93.81,109.38 93.81,115.46 93.41,115.87 89.15,115.87 88.61,116.41 88.61,116.7
  20_SIG7 w0.14: 94.35,82.38 94.35,87.88 96.91,90.44 96.91,94.22 97.26,94.56 97.88,94.56 98.22,94.22 98.22,92.67 98.36,92.53 98.73,92.53 98.96,92.3 98.96,91.76 99.1,91.62 99.38,91.62 99.52,91.76 99.52,92.2 99.85,92.53 100.08,92.53 100.28,92.74 100.28,93.08 100.14,93.22 99.29,93.22 98.92,93.59 98.92,94.45 99.24,94.77 99.78,94.77 99.92,94.91 99.92,95.3 99.78,95.44 97.36,95.44 97.04,95.75 97.04,96.3 97.38,96.65 99.85,96.65 100,96.8 100,97.21 99.54,97.66 97.16,97.66 96.56,98.26 96.56,100.83 96.88,101.15 97.41,101.15 97.68,100.89 97.68,100.64 97.89,100.44 98.4,100.44 98.68,100.71 98.68,102.26 99.06,102.64 103.97,102.64 104.23,102.9 104.23,105.76 105.44,106.97 105.44,107.55 104.83,108.17 104.83,109.73 104.75,109.81 104.62,109.81 103.87,109.06 103.52,109.06 102.95,109.62 102.95,110.05 103.43,110.52 103.43,111.81 103.29,111.94 102.65,111.94 102.54,111.83 102.54,108.65 102.73,108.46 103.57,108.46 103.89,108.14 103.89,106.55 103.58,106.25 103.58,103.56 103.22,103.2 102.64,103.2 102.34,103.51 102.34,106.62 102.2,106.76 101.78,106.76 101.63,106.6 101.63,103.79 101.24,103.4 98.12,103.4 97.97,103.25 97.97,102.67 97.61,102.31 96.97,102.31 96.65,102.63 96.65,104.38 96.97,104.7 100.22,104.7 100.36,104.84 100.36,105.27 100.22,105.41 94.94,105.41 94.55,105.8 94.55,106.25 94.99,106.68 96.85,106.68 96.99,106.82 96.99,107.2 97.31,107.52 97.84,107.52 98.16,107.2 98.16,106.82 98.3,106.68 100.22,106.68 100.36,106.82 100.36,107.85 100.1,108.1 95.05,108.1 94.7,108.46
RLD3_C3_72B_DK0_P: length 154.9
  TOP w0.145: U1.K31 v2(104.24,73.84) ; v2(93.23,120.32) U141.D7
  20_SIG7 w0.107: 94.66,82.38 94.61,82.34 94.61,81.8 94.97,81.44 97.51,81.44 97.84,81.11 97.84,80.62 98.02,80.44 98.51,80.44 98.84,80.12 98.84,78.66 99.06,78.44 99.49,78.44 99.84,78.1 99.84,77.67 100.06,77.44 100.49,77.44 100.84,77.1 100.84,76.68 101.07,76.45 101.49,76.45 101.84,76.1 101.84,75.67 102.07,75.44 102.57,75.44 102.84,75.17 102.84,74.67 103.07,74.45 103.57,74.45 103.84,74.18 103.84,73.95 103.95,73.84 v2(104.24,73.84) ; v2(93.23,120.32) 93.32,120.41 93.32,120.78 93.22,120.88 93.07,120.88 92.91,120.72 91.89,120.72 91.62,120.99 91.62,122.57 91.48,122.72 89.01,122.72 88.83,122.54 88.83,116.75 88.85,116.73 88.85,116.7
  20_SIG7 w0.108: 94.91,108.67 94.89,108.69 94.85,108.69 94.06,109.48 94.06,115.56 93.51,116.11 89.25,116.11 88.85,116.51 88.85,116.7
  20_SIG7 w0.14: 94.66,82.38 94.66,87.76 97.22,90.32 97.22,94.09 97.38,94.26 97.75,94.26 97.92,94.09 97.92,92.55 98.23,92.23 98.6,92.23 98.65,92.18 98.65,91.63 98.97,91.31 99.5,91.31 99.82,91.63 99.82,92.08 99.97,92.23 100.2,92.23 100.58,92.61 100.58,93.2 100.27,93.52 99.42,93.52 99.22,93.71 99.22,94.32 99.36,94.46 99.91,94.46 100.23,94.78 100.23,95.42 99.91,95.74 97.48,95.74 97.34,95.88 97.34,96.18 97.51,96.34 99.97,96.34 100.3,96.67 100.3,97.33 99.67,97.97 97.28,97.97 96.86,98.39 96.86,100.71 97,100.85 97.29,100.85 97.37,100.76 97.37,100.52 97.76,100.13 98.53,100.13 98.99,100.59 98.99,102.13 99.19,102.34 104.1,102.34 104.54,102.78 104.54,105.64 105.75,106.85 105.75,107.68 105.13,108.29 105.13,109.85 104.87,110.11 104.49,110.11 103.74,109.36 103.64,109.36 103.26,109.74 103.26,109.92 103.73,110.39 103.73,111.93 103.42,112.25 102.53,112.25 102.23,111.96 102.23,108.52 102.6,108.15 103.44,108.15 103.58,108.01 103.58,106.68 103.28,106.38 103.28,103.68 103.1,103.5 102.77,103.5 102.64,103.63 102.64,106.74 102.32,107.06 101.65,107.06 101.32,106.73 101.32,103.91 101.12,103.71 97.99,103.71 97.66,103.38 97.66,102.79 97.49,102.62 97.09,102.62 96.95,102.76 96.95,104.25 97.09,104.39 100.34,104.39 100.66,104.71 100.66,105.4 100.34,105.71 95.07,105.71 94.86,105.92 94.86,106.12 95.11,106.38 96.97,106.38 97.29,106.69 97.29,107.07 97.43,107.21 97.71,107.21 97.85,107.07 97.85,106.69 98.17,106.38 100.34,106.38 100.66,106.69 100.66,107.97 100.23,108.41 95.18,108.41 94.91,108.67
RLD3_C3_72B_DK1_N: length 155.3
  TOP w0.145: v2(93.23,112.32) U141.L7 ; v2(103.24,74.84) U1.J32
  16_SIG5 w0.107: 104.74,84.56 104.74,84.29 104.64,84.18 104.64,79.59 104.48,79.44 103.98,79.44 103.64,79.1 103.64,74.95 103.53,74.84 v2(103.24,74.84)
  16_SIG5 w0.108: 97.71,124.6 97.71,124.58 97.68,124.55 97.68,124.03 97.43,123.78 96.41,123.78 96.13,124.05 96.13,124.24 96.02,124.34 95.81,124.34 95.7,124.24 95.7,124.05 95.47,123.81 94.59,123.81 94.44,123.66 94.44,113.24 94.09,112.89 93.32,112.89 93.23,112.8 v2(93.23,112.32)
  16_SIG5 w0.13: 104.74,89.08 104.74,84.56
  16_SIG5 w0.14: 97.71,124.6 97.71,125.08 97.71,125.08 97.3,125.49 96.39,125.49 95.92,125.96 95.92,127.59 95.52,127.99 95.04,127.99 94.72,127.67 94.72,126.01 94.56,125.85 94.32,125.85 94.1,126.07 94.1,127.81 94.31,128.02 94.31,129.82 93.5,130.63 92.36,130.63 92.22,130.77 92.22,133.65 92.39,133.81 92.69,133.81 92.87,133.63 92.87,131.51 93.28,131.11 93.95,131.11 94.32,131.48 94.32,133.65 94.53,133.86 94.94,133.86 95.15,133.65 95.15,130.65 95.47,130.33 96.27,130.33 96.59,130.65 96.59,133.65 96.81,133.87 97.11,133.87 97.29,133.69 97.29,130.67 97.61,130.35 98.4,130.35 98.72,130.67 98.72,133.61 98.97,133.86 99.26,133.86 99.5,133.62 99.5,131.39 100.02,130.87 100.56,130.87 100.88,131.19 100.88,132.17 101.04,132.34 101.3,132.34 101.44,132.2 101.44,131.19 101.76,130.87 106.72,130.87 110.35,127.24 110.35,122.46 111.13,121.69 111.13,121.31 110.92,121.1 110.6,121.1 110.21,120.71 110.21,120.04 110.6,119.66 110.92,119.66 111.13,119.45 111.13,119.03 110.92,118.82 110.6,118.82 110.21,118.44 110.21,117.77 110.6,117.38 110.92,117.38 111.13,117.17 111.13,116.76 110.92,116.55 110.6,116.55 110.21,116.16 110.21,115.49 110.6,115.1 110.92,115.1 111.13,114.9 111.13,114.48 110.92,114.27 110.6,114.27 110.21,113.88 110.21,113.22 110.6,112.83 110.92,112.83 111.13,112.62 111.13,112.2 110.92,112 110.6,112 110.21,111.61 110.21,110.94 110.6,110.55 110.92,110.55 111.13,110.34 111.13,109.81 110.72,109.41 110.43,109.41 109.43,110.41 108.8,110.41 108.18,109.78 108.18,109.09 108.64,108.64 109.17,108.64 109.41,108.39 109.41,107.66 105.99,104.25 105.76,104.25 104.65,103.13 104.65,101.45 104.06,100.87 104.06,100.18 104.71,99.53 104.71,98.91 104.98,98.64 104.98,98.49 104.87,98.37 103.94,98.37 103.59,98.03 103.59,97.34 103.92,97.01 105.64,97.01 106,96.65 106,96.31 105.69,96 104,96 103.61,95.62 103.61,94.95 103.94,94.62 105.79,94.62 105.98,94.43 105.98,94.01 105.75,93.78 103.87,93.78 103.58,93.49 103.58,92.82 104.06,92.34 104.83,92.34 105.06,92.12 105.06,89.4 104.74,89.08
RLD3_C3_72B_DK1_P: length 156
  TOP w0.145: U1.K32 v2(104.24,74.84) ; v2(93.23,113.32) U141.K7
  16_SIG5 w0.107: v2(104.24,74.84) 103.91,74.84 103.84,74.91 103.84,79.01 104.06,79.24 104.57,79.24 104.84,79.51 104.84,84.1 104.89,84.15 104.92,84.15
  16_SIG5 w0.108: 97.4,124.6 97.4,124.58 97.43,124.55 97.43,124.13 97.33,124.03 96.51,124.03 96.38,124.16 96.38,124.34 96.13,124.59 95.7,124.59 95.45,124.34 95.45,124.15 95.37,124.06 94.49,124.06 94.19,123.77 94.19,113.34 93.99,113.13 93.42,113.13 v2(93.23,113.32)
  16_SIG5 w0.13: 105.73,89.01 105.73,84.62 105.45,84.34 105.11,84.34 104.92,84.15
  16_SIG5 w0.14: 105.73,89.01 105.73,89.08 105.36,89.46 105.36,92.24 104.96,92.65 104.18,92.65 103.88,92.95 103.88,93.36 104,93.48 105.88,93.48 106.29,93.89 106.29,94.56 105.92,94.92 104.06,94.92 103.91,95.07 103.91,95.49 104.12,95.7 105.82,95.7 106.3,96.18 106.3,96.78 105.77,97.31 104.05,97.31 103.89,97.47 103.89,97.9 104.06,98.07 105,98.07 105.29,98.36 105.29,98.77 105.01,99.04 105.01,99.66 104.37,100.31 104.37,100.74 104.95,101.32 104.95,103.01 105.84,103.89 106.07,103.89 109.72,107.54 109.72,108.52 109.29,108.94 108.76,108.94 108.48,109.22 108.48,109.66 108.93,110.1 109.31,110.1 110.3,109.11 110.85,109.11 111.43,109.69 111.43,110.47 111.05,110.86 110.72,110.86 110.52,111.07 110.52,111.48 110.72,111.69 111.05,111.69 111.43,112.08 111.43,112.75 111.05,113.13 110.72,113.13 110.52,113.34 110.52,113.76 110.72,113.97 111.05,113.97 111.43,114.35 111.43,115.02 111.05,115.41 110.72,115.41 110.52,115.62 110.52,116.03 110.72,116.24 111.05,116.24 111.43,116.63 111.43,117.3 111.05,117.68 110.72,117.68 110.52,117.89 110.52,118.31 110.72,118.52 111.05,118.52 111.43,118.9 111.43,119.57 111.05,119.96 110.72,119.96 110.52,120.17 110.52,120.59 110.72,120.79 111.05,120.79 111.43,121.18 111.43,121.81 110.66,122.59 110.66,127.36 106.85,131.17 101.88,131.17 101.74,131.31 101.74,132.33 101.42,132.64 100.92,132.64 100.57,132.3 100.57,131.31 100.43,131.17 100.15,131.17 99.81,131.51 99.81,133.75 99.39,134.16 98.84,134.16 98.42,133.73 98.42,130.8 98.28,130.66 97.74,130.66 97.6,130.8 97.6,133.81 97.24,134.17 96.69,134.17 96.29,133.78 96.29,130.77 96.15,130.63 95.59,130.63 95.45,130.77 95.45,133.78 95.07,134.16 94.4,134.16 94.01,133.78 94.01,131.61 93.82,131.42 93.4,131.42 93.18,131.64 93.18,133.75 92.82,134.12 92.26,134.12 91.92,133.77 91.92,130.65 92.24,130.33 93.37,130.33 94.01,129.69 94.01,128.14 93.8,127.93 93.8,125.94 94.19,125.54 94.68,125.54 95.02,125.88 95.02,127.54 95.16,127.68 95.4,127.68 95.61,127.47 95.61,125.84 96.27,125.18 97.17,125.18 97.4,124.95 97.4,124.6
RLD3_C3_72B_DK2_N: length 116
  TOP w0.145: v2(103.24,72.84) U1.J30 ; v2(80.32,117.17) U142.C7
  14_SIG4 w0.107: 94.6,73.98 94.6,73.91 95.07,73.44 102.49,73.44 102.84,73.1 102.84,72.59 102.98,72.44 103.13,72.44 103.24,72.55 v2(103.24,72.84)
  14_SIG4 w0.108: v2(80.32,117.17) 80.04,116.88 80.04,116.8 80.22,116.62 83.54,116.62 83.56,116.64 83.59,116.64
  14_SIG4 w0.14: 83.59,116.64 84.7,116.64 84.97,116.38 85.32,116.38 86.08,115.62 86.08,109.13 86.8,108.41 87.79,108.41 88.39,107.81 88.39,106.59 88.66,106.32 88.88,106.32 89.04,106.48 89.53,106.48 89.95,106.06 89.95,105.56 89.79,105.41 89.79,105.19 90.87,104.11 91.12,104.11 91.21,104.2 91.21,104.95 91.5,105.23 92.19,105.23 92.47,104.95 92.47,101.31 92.63,101.15 92.77,101.15 93.12,100.8 93.12,100.21 92.77,99.86 92.63,99.86 92.47,99.71 92.47,98.76 93.75,97.49 94.11,97.49 95.61,95.99 95.61,94.84 95.38,94.62 95.38,94.4 95.81,93.98 95.81,93.43 95.39,93.02 94.95,93.02 94.47,93.49 94.25,93.49 94.03,93.26 94.03,93.04 95.54,91.53 95.54,90.93 95.15,90.54 94.63,90.54 93.04,92.13 92.89,92.13 92.67,91.91 92.67,91.69 93.14,91.21 93.14,90.77 92.72,90.35 92.18,90.35 91.76,90.77 91.54,90.77 91.21,90.45 91.21,89.73 91.34,89.6 94.9,89.6 95.21,89.3 95.21,88.67 94.85,88.31 91.39,88.31 91.21,88.13 91.21,87.52 91.37,87.36 94.44,87.36 94.74,87.06 94.74,86.43 94.39,86.07 91.37,86.07 91.21,85.92 91.21,85.6 91.37,85.44 93.22,85.44 93.56,85.1 93.56,84.5 93.21,84.15 91.37,84.15 91.21,84 91.21,83.68 91.37,83.52 92.08,83.52 92.45,83.15 92.45,82.56 92.13,82.23 91.37,82.23 91.21,82.08 91.21,81.76 91.37,81.6 92.08,81.6 92.45,81.23 92.45,80.64 92.13,80.31 91.37,80.31 91.21,80.16 91.21,79.84 91.37,79.68 92.08,79.68 92.45,79.31 92.45,78.72 92.13,78.39 91.37,78.39 91.21,78.24 91.21,77.92 91.37,77.76 92.08,77.76 92.45,77.39 92.45,76.79 92.13,76.47 91.37,76.47 91.21,76.32 91.21,76 91.37,75.84 92.23,75.84 92.61,75.46 92.61,75 92.16,74.55 91.37,74.55 91.21,74.4 91.21,74 91.37,73.84 91.94,73.84 92.27,73.52 92.27,73.03 91.97,72.74 91.74,72.74 91.62,72.61 91.62,72.43 91.77,72.27 93.4,72.27 93.63,72.49 93.63,72.87 92.86,73.63 92.86,74.16 93.33,74.64 93.95,74.64 94.6,73.98
RLD3_C3_72B_DK2_P: length 116.4
  TOP w0.145: v2(79.32,117.17) U142.D7 ; U1.J29 v2(103.24,71.84)
  14_SIG4 w0.107: v2(103.24,71.84) 103.24,72.13 103.13,72.24 102.9,72.24 102.63,72.5 102.63,73.01 102.41,73.24 94.98,73.24 94.48,73.75 94.41,73.75 94.39,73.77
  14_SIG4 w0.108: 83.59,116.34 83.56,116.34 83.54,116.37 80.12,116.37 v2(79.32,117.17)
  14_SIG4 w0.14: 94.39,73.77 94.06,74.1 93.82,74.33 93.46,74.33 93.17,74.04 93.17,73.76 93.93,72.99 93.93,72.37 93.53,71.96 91.65,71.96 91.31,72.3 91.31,72.74 91.61,73.04 91.85,73.04 91.96,73.16 91.96,73.39 91.81,73.54 91.24,73.54 90.91,73.87 90.91,74.52 91.24,74.86 92.03,74.86 92.31,75.13 92.31,75.33 92.1,75.54 91.24,75.54 90.91,75.87 90.91,76.44 91.24,76.78 92,76.78 92.15,76.92 92.15,77.26 91.95,77.46 91.24,77.46 90.91,77.79 90.91,78.36 91.24,78.7 92,78.7 92.15,78.84 92.15,79.18 91.95,79.38 91.24,79.38 90.91,79.71 90.91,80.28 91.24,80.62 92,80.62 92.15,80.76 92.15,81.1 91.95,81.3 91.24,81.3 90.91,81.63 90.91,82.2 91.24,82.54 92,82.54 92.15,82.68 92.15,83.02 91.95,83.22 91.24,83.22 90.91,83.55 90.91,84.12 91.24,84.46 93.09,84.46 93.26,84.63 93.26,84.97 93.09,85.14 91.24,85.14 90.91,85.47 90.91,86.04 91.24,86.38 94.26,86.38 94.44,86.55 94.44,86.93 94.31,87.06 91.24,87.06 90.91,87.39 90.91,88.26 91.27,88.62 94.72,88.62 94.9,88.8 94.9,89.17 94.78,89.3 91.22,89.3 90.91,89.61 90.91,90.58 91.41,91.08 91.88,91.08 92.31,90.66 92.6,90.66 92.84,90.9 92.84,91.09 92.36,91.56 92.36,92.03 92.77,92.44 93.16,92.44 94.75,90.85 95.02,90.85 95.24,91.06 95.24,91.4 93.72,92.92 93.72,93.39 94.13,93.8 94.6,93.8 95.07,93.32 95.26,93.32 95.5,93.56 95.5,93.85 95.08,94.28 95.08,94.75 95.3,94.97 95.3,95.86 93.98,97.18 93.62,97.18 92.17,98.64 92.17,99.83 92.5,100.17 92.64,100.17 92.81,100.34 92.81,100.68 92.64,100.85 92.5,100.85 92.17,101.18 92.17,104.82 92.06,104.93 91.62,104.93 91.52,104.82 91.52,104.08 91.25,103.81 90.74,103.81 89.49,105.06 89.49,105.53 89.64,105.69 89.64,105.93 89.4,106.17 89.16,106.17 89.01,106.02 88.53,106.02 88.09,106.46 88.09,107.68 87.67,108.1 86.68,108.1 85.78,109 85.78,115.49 85.19,116.07 84.84,116.07 84.57,116.34 83.59,116.34
