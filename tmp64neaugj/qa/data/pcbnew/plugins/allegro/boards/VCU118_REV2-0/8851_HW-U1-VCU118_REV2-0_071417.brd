# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCCINT_ISENSE1: length 32.6
  TOP w0.178: U159.15 214.74,113.77 215.22,113.28 215.48,113.28 v1(215.86,112.9)
  03_SIG1 w0.173: v1(238.17,102.13) 238.17,103.71 235.98,105.9 229.05,105.9 224.68,110.26 217.57,110.26 215.86,111.97 v1(215.86,112.9)
  BOTTOM w0.178: R1269.2 v1(238.17,102.13) 237.54,101.5 R1225.2
VCCINT_ISENSE2: length 27.3
  TOP w0.178: v1(215.61,102.74) 215.35,102.74 214.74,103.35 U160.15
  03_SIG1 w0.173: v1(215.61,102.74) 215.61,103.52 218,105.92 227.74,105.92 228.98,104.67 230.9,104.67 232.33,103.25 234.46,103.25 v1(235.63,102.08)
  BOTTOM w0.216: R1224.2 235.38,101.18 235.63,101.43 v1(235.63,102.08) R1268.2
VCCINT_ISENSE3: length 30.3
  TOP w0.178: v1(215.61,92.33) 215.35,92.33 214.74,92.94 U161.15
  03_SIG1 w0.173: v1(215.61,92.33) 215.92,92.64 217.06,92.64 219.96,95.54 220.56,95.54 222.73,97.71 222.73,102.67 224.64,104.58 227.77,104.58 230.23,102.13 v1(233.09,102.13)
  BOTTOM w0.216: R1223.2 233.22,101.99 v1(233.09,102.13) R1267.2
VCCINT_ISENSE4: length 41.9
  TOP w0.152: R169.2 235.39,101.23 v1(234.99,101.62) 234.95,101.67 234.95,102.66 235.07,102.78 R171.2
  TOP w0.178: U11.15 214.74,82.53 215.35,81.91 v1(215.61,81.91)
  03_SIG1 w0.173: v1(234.99,101.62) 234.81,101.44 230.07,101.44 228.14,103.37 224.24,103.37 223.29,102.42 223.29,95.61 220.62,92.94 219.39,92.94 216.79,90.34 216.79,84.24 215.61,83.05 v1(215.61,81.91)
VCCINT_PGOOD: length 120.2
  TOP w0.381: D10.1 v1(202.82,171.56)
  07_SIG3 w0.381: v1(202.82,171.56) 201.96,170.69 201.96,169.28 200.34,167.66 194.63,167.66 188.22,161.25 188.22,159.32 192.94,154.6 192.94,153.28 194.83,151.39 196.98,151.39 198.05,150.31 200.03,150.31 v1(202.06,148.29)
  20_SIG7 w0.381: v1(234.76,104.8) 234.76,104.48 234.44,104.15 231.5,104.15 230.72,104.94 230.72,108.85 229.39,110.19 224.26,110.19 223.06,111.38 223.06,119.77 220.29,122.54 211.23,122.54 201.89,131.88 199.11,131.88 197.68,133.3 197.68,141.22 202.06,145.59 v1(202.06,148.29)
  BOTTOM w0.178: U164.24 234.67,105.04 234.74,104.98 234.74,104.83 v1(234.76,104.8)
  BOTTOM w0.381: RP2.8 201.78,149.09 202.06,148.82 v1(202.06,148.29) 202.2,148.14 U51.3
VCCINT_PWM1: length 35.2
  TOP w0.178: 213.74,114.91 213.74,114.93 213.56,115.11 212.1,115.11 v2(211.82,114.83)
  TOP w0.216: 213.74,114.91 U159.13
  03_SIG1 w0.173: v1(239.28,107.04) 229.6,107.04 225.18,111.46 224.15,111.46 223.37,112.23 223.37,113.02 221.36,115.03 218.3,115.03 218.1,114.83 v2(211.82,114.83)
  BOTTOM w0.279: U164.18 239.11,107.21 v1(239.28,107.04)
VCCINT_PWM2: length 44.6
  TOP w0.178: 213.74,104.47 213.74,104.56 213.57,104.72 212.05,104.72 v2(211.74,104.42)
  TOP w0.216: 213.74,104.47 U160.13
  03_SIG1 w0.173: v2(211.74,104.42) 211.74,110.34 214.85,113.45 218.43,113.45 218.77,113.79 221.76,113.79 222.82,112.73 222.82,112 222.93,111.9 223.92,110.9 224.1,110.9 224.14,110.86 224.93,110.86 229.31,106.49 239.54,106.49 v1(240.17,107.11)
  BOTTOM w0.279: U164.17 238.46,107.71 238.47,107.7 239.58,107.7 v1(240.17,107.11)
VCCINT_PWM3: length 60.4
  TOP w0.178: U161.13 213.74,94.11 213.54,94.31 212.05,94.31 v2(211.74,94)
  03_SIG1 w0.173: v1(239.91,108.21) 239.84,108.13 238.68,108.13 236.97,109.84 227.64,109.84 225.47,112.01 225.05,112.01 224.75,112.31 224.75,112.86 224.54,113.06 222.2,115.41 222.2,115.87 221.78,116.29 211.56,116.29 210.34,115.06 210.34,95.41 v2(211.74,94)
  BOTTOM w0.279: v1(239.91,108.21) 239.86,108.15 238.66,108.15 238.61,108.21 U164.16
VCCINT_PWM4: length 71.3
  TOP w0.178: U11.13 213.74,83.7 213.54,83.89 212.05,83.89 v2(211.74,83.59)
  03_SIG1 w0.173: v2(211.74,83.59) 209.76,85.57 209.76,115.43 211.93,117.6 216.41,117.6 216.7,117.31 219.26,117.31 219.55,117.6 221.25,117.6 222.76,116.09 222.76,115.64 224.69,113.7 226.23,113.7 226.88,113.06 226.88,112.53 228.23,111.18 236.61,111.18 238.12,109.67 239.05,108.73 v1(239.15,108.73)
  BOTTOM w0.178: v1(239.15,108.73) 239.13,108.71 U164.15
VCCINT_SLAVE_1V8: length 16.5
  TOP w0.381: U11.11 212.73,83.13 v2(211.56,81.96) 210.97,82.54 C228.1 ; U160.11 212.73,103.96 v2(211.56,102.78) 211.23,103.11 C1678.1 ; C1679.1 211.23,92.7 v2(211.56,92.37) 212.73,93.55 U161.11 ; C1677.1 211.23,113.53 v2(211.56,113.2) 212.73,114.37 U159.11
  BOTTOM w0.152: R1209.1 v2(211.56,102.78) ; R1208.1 v2(211.56,113.2) ; R167.1 v2(211.56,81.96) ; v2(211.56,92.37) R1210.1 ; R1230.1 v1(235.25,117.39)
  vias: v1(231.39,92.63) v1(232.28,92.63) v1(233.17,92.63) v1(234.06,95.3) v1(234.06,94.41) v1(234.06,93.52) v1(234.06,92.63) v1(234.95,95.3) v1(234.95,94.41) v1(234.95,93.52) v1(235.84,95.3) v1(235.84,94.41) v1(235.84,93.52) v1(236.73,95.3) v1(236.73,94.41) v1(236.73,93.52)
VCCINT_SNS_N: length 109.2
  03_SIG1 w0.135: v1(143.29,104.59) 143.6,104.9 147.17,104.9 150.13,107.86 158.99,107.86 160.04,106.81 168.92,106.81 174.93,112.81 185.74,112.81 188.01,115.09 188.01,117.35 189.29,118.62 189.64,118.62 189.94,118.92 193.12,118.92 193.99,119.79 197.51,119.79 197.99,120.27 213.89,120.27 214.32,120.69 221.02,120.69 222.27,119.45 223.46,118.25 223.46,115.76 224.3,114.92 226.1,114.92 227.59,113.43 227.59,112.97 228.02,112.55 228.54,112.55 v1(228.9,112.19)
  BOTTOM w0.104: v1(143.29,104.59) 143.29,104.82 143.17,104.94 142.99,104.94 142.75,104.69 142.75,103.44 141.88,102.57 141.5,102.57 Z129.1
  BOTTOM w0.178: U164.35 231.48,110.71 231.02,111.16 231.02,112.27 230.8,112.5 230.22,112.5 C1688.2 v1(228.9,112.19)
VCCINT_SNS_P: length 110.4
  03_SIG1 w0.135: v1(228.88,113.19) 228.52,112.83 228.13,112.83 227.87,113.09 227.87,113.55 226.22,115.2 224.42,115.2 223.74,115.87 223.74,118.37 222.55,119.56 221.14,120.97 214.2,120.97 213.78,120.55 197.87,120.55 197.39,120.07 193.87,120.07 193.01,119.2 v1(189.46,119.2) 189.46,119.2 187.73,117.46 187.73,115.2 185.62,113.09 174.81,113.09 168.81,107.09 160.16,107.09 159.11,108.14 150.01,108.14 147.05,105.18 143.62,105.18 v1(143.29,105.51)
  BOTTOM w0.104: v1(143.29,105.51) 143.29,105.26 143.19,105.16 142.89,105.16 142.52,104.79 142.52,103.53 141.78,102.79 141.48,102.79 140.98,103.3 Z128.1 ; U35.8 189.67,119.41 v1(189.46,119.2)
  BOTTOM w0.178: U164.36 231.49,111.21 231.38,111.31 231.38,112.41 230.94,112.85 230.24,112.85 C1688.1 v1(228.88,113.19)
VCCINT_TS_FAULTB: length 107.6
  BOTTOM w0.152: R1275.1 217.64,111.26 217.37,111 214.96,111 213.18,109.22 213.18,102.77 214.67,101.28 216.83,101.28 217.02,101.48 R1276.1 217.64,100.7 217.09,100.15 214.33,100.15 213.31,99.14 213.31,92.58 215.09,90.8 216.64,90.8 216.9,91.06 R1277.1 217.64,90.43 216.89,89.69 214.38,89.69 213.31,88.62 213.31,81.89 214.48,80.72 216.56,80.72 217,81.16 R196.1 218.24,80.56 218.24,80.04 220.9,77.37 238.96,77.37 239.73,78.13 239.73,101.22 240.03,101.53 240.03,105.87 239.82,106.07 C1714.1
  BOTTOM w0.178: U164.19 238.04,106.31 238.27,106.07 C1714.1
VCCINT_VDD_MASTER: length 7.6
  TOP w0.152: R1235.1 v1(236.52,114.79)
  BOTTOM w0.254: C1587.1 v1(236.52,114.79) 236.85,114.46 236.85,113.84 236.67,113.66 U164.8 ; C1587.1 237.24,115.73 237.28,115.69 C1660.1 ; C1587.1 R1230.2
VCCINT_VIN_N: length 2.9
  BOTTOM w0.104: R109.1 192.29,119.2 C152.1 191.86,118.77 191.44,118.77 191.3,118.91 U35.9
VCCINT_VIN_P: length 2.9
  BOTTOM w0.104: R110.1 192.32,118.06 C152.2 191.84,118.54 191.44,118.54 191.3,118.41 U35.10
VCCINT_VIN_R_N: length 10.8
  TOP w0.178: v1(194.52,119.2) 194.18,118.86 193.23,118.86 192.72,118.35 192.72,115.67 192.24,115.19 190.17,115.19 189.39,114.41 189.39,113.61 Z7.2
  BOTTOM w0.104: R109.2 v1(194.52,119.2)
VCCINT_VIN_R_P: length 10.8
  TOP w0.178: Z6.2 189.85,113.61 189.85,114.22 190.36,114.73 192.43,114.73 193.18,115.48 193.18,116.65 193.34,116.8 193.61,116.8 193.76,116.96 193.76,117.18 193.61,117.33 193.34,117.33 193.18,117.49 193.18,118.17 193.42,118.4 194.18,118.4 v1(194.52,118.06)
  BOTTOM w0.104: R110.2 v1(194.52,118.06)
VCCINT_VIN_UV: length 8.7
  TOP w0.152: v1(239.51,112.58) R1216.2 R1219.1 C1712.1
  BOTTOM w0.254: v1(239.51,112.58) 240.16,111.94 240.16,109.78 239.67,109.3 238.87,109.3 238.78,109.21 U164.14
VCCINTIO_BRAM: length 36.3
  TOP w0.152: L7.2 201.26,58.5 201.04,58.72 199.64,58.72 v1(199.39,58.47)
  TOP w0.254: R79.2 v1(193.07,60.66)
  03_SIG1 w0.508: v1(206.21,53.77) 201.4,53.77 198.44,50.82 193.73,50.82 191.95,52.6 191.95,55.14 190.96,56.13 190.96,58.55 v1(193.07,60.66)
  BOTTOM w0.152: Z2.2 199.52,58.6 v1(199.39,58.47)
  BOTTOM w0.381: v1(205.88,56.31) 205.88,56.32 R156.1
  vias: v1(206.21,52.88) v1(206.21,51.99) v1(207.23,53.77) v1(207.23,52.88) v1(207.23,51.99) v1(208.25,53.77) v1(208.25,52.88) v1(208.25,51.99) v1(209.26,53.77) v1(209.26,52.88) v1(209.26,51.99)
VCCINTIO_BRAM_DH_R: length 16.6
  TOP w0.152: Q19.1 199.25,66.3 v1(199.01,66.55)
  03_SIG1 w0.173: v1(199.01,66.55) 200.48,66.55 208.87,58.16 v1(210.25,58.16)
  BOTTOM w0.381: R154.2 v1(210.25,58.16)
VCCINTIO_BRAM_DL: length 7.5
  TOP w0.254: Q19.7 203.68,65.65 v1(204.03,65.3)
  03_SIG1 w0.381: v1(208.07,63.37) 206.14,65.3 v1(204.03,65.3)
  BOTTOM w0.254: v1(208.07,63.37) 208.3,63.37 208.69,63.76 U6.19
VCCINTIO_BRAM_FET_SWITCH: length 24
  TOP w0.152: v1(211.4,58.09) 211.4,57.08 R139.1 ; v1(199.4,59.35) 199.64,59.11 201.04,59.11 201.26,59.33 L7.1
  BOTTOM w0.152: R80.2 199.52,59.23 v1(199.4,59.35)
  BOTTOM w0.254: C184.2 209.2,58.93 209.44,59.17 209.44,60.58 210.03,61.16 U6.16
  BOTTOM w0.381: 202.91,60.32 205.73,60.32 205.88,60.17 206.85,60.17 208.09,58.93 C184.2 208.6,57.68 209.08,57.2 211.04,57.2 211.42,57.58 211.42,58.06 v1(211.4,58.09) R158.2
  vias: v1(198.21,64.69) v1(198.21,63.42) v1(198.19,62.33) v1(198.16,61.06) v1(198.85,65.45) v1(198.98,64.18) v1(199.48,63.42) v1(199.48,62.15) v1(199.48,60.88)
VCCINTIO_BRAM_FPGA: length 93.5
  TOP w0.254: R78.2 195.3,60.66 195.45,60.5 195.45,59.99 v1(195.71,59.74)
  TOP w0.381: v2(122.24,69.84) 121.74,69.34 U1.AG27 ; J21.1 193.34,58.39 ; J21.1 193.6,57.58 ; J21.1 192.53,58.65 ; J21.1 191.73,58.39 ; J21.1 192.53,56.51 ; J21.1 191.73,56.78 ; J21.1 191.47,57.58 ; J21.1 193.34,56.78 ; U1.V28 v2(112.24,70.84) ; U1.AJ27 123.74,69.34 v2(124.24,69.84) ; U1.AC13 117.74,55.34 v2(117.24,54.84) ; v2(117.24,69.84) 117.74,69.34 U1.AC27 ; U1.AD14 118.74,56.34 v2(119.24,55.84) ; U1.AH14 122.74,56.34 v2(123.24,55.84) ; U1.AK28 124.74,70.34 v2(125.24,70.84) ; U1.AG13 121.74,55.34 v2(122.24,54.84) ; U1.AA27 v2(115.24,69.84) ; U1.W27 v2(113.24,69.84) ; v2(111.24,69.84) 111.74,69.34 U1.U27 ; v2(120.24,69.84) 119.74,69.34 U1.AE27 ; v2(121.24,55.84) 120.74,56.34 U1.AF14
  05_SIG2 w0.381: v1(185.93,42.27) 186.69,43.03 186.69,47.78 186.94,48.03 186.94,48.87 187.18,49.1 187.18,51.43 186.13,52.48 186.13,54.25 187.55,55.68 190.63,55.68 J21.1
  09_PWR1 w0.381: J21.1 193.34,58.39 ; J21.1 193.6,57.58 ; J21.1 192.53,58.65 ; J21.1 191.47,57.58 ; J21.1 191.73,58.39 ; J21.1 193.34,56.78 ; J21.1 192.53,56.51 ; J21.1 191.73,56.78
  BOTTOM w0.191: Z4.2 144.72,32.48 142.24,34.96 142.24,40.99 139.74,43.5 139.74,44.07 139.46,44.34 137.95,44.34 137.74,44.56 137.74,49.2 137.59,49.34 132.09,49.34 131.74,49.7 131.74,50.07 131.46,50.34 127.94,50.34 127.74,50.55 127.74,51.09 127.48,51.34 126.94,51.34 126.74,51.55 126.74,52.07 126.46,52.34 125.94,52.34 125.74,52.55 125.74,53.07 125.46,53.34 125.02,53.34 125.02,53.35 124.74,53.64 124.74,54.07 124.46,54.34 122.74,54.34 v2(122.24,54.84)
  BOTTOM w0.381: C1462.1 150.95,48.31 150.5,47.85 v1(150.5,47.55) 150.88,47.17 C160.1 ; v1(150.5,46.28) 150.88,45.9 C1463.1
  vias: v1(185.24,42.29) v1(196.21,54.61) v1(196.21,53.34) v1(196.21,52.07) v1(196.26,55.83) v1(197.4,55.83) v1(197.48,54.61) v1(197.48,53.34) v1(197.48,52.07) v1(198.72,56.82) v1(198.72,55.55) v1(198.72,54.15)
VCCINTIO_BRAM_FPGA_SNS_N: length 111.7
  05_SIG2 w0.135: v1(211.07,69.98) 211.51,70.42 211.51,71.36 211.18,71.68 210.55,71.68 210.46,71.59 210.46,71.49 210.38,71.4 210.2,71.4 210.11,71.49 210.11,71.59 210.02,71.68 209.84,71.68 209.75,71.59 209.75,71.49 209.66,71.4 209.49,71.4 209.4,71.49 209.4,71.59 209.31,71.68 194.68,71.68 191.41,68.41 191.41,66.78 191.78,66.41 192.4,66.41 192.53,66.54 192.53,66.73 v1(192.21,67.06)
  BOTTOM w0.104: Z5.1 145.18,31.28 145.18,30.98 145.4,30.76 145.92,30.76 146.32,30.36 146.47,30.36 146.75,30.64 146.9,30.64 147.05,30.49 147.05,30.34 146.77,30.06 146.77,29.92 146.91,29.77 147.06,29.77 147.35,30.05 147.49,30.05 147.64,29.91 147.64,29.76 147.36,29.47 147.36,29.33 147.57,29.11 151.02,29.11 153.01,31.1 153.01,38.21 155.38,40.58 165.35,40.58 169.02,44.26 169.02,48.97 177.77,57.71 177.77,60.89 179.15,62.27 179.15,66 181.15,68 186.24,68 188.08,66.17 192.45,66.17 192.56,66.27 192.56,66.71 v1(192.21,67.06) ; C187.2 211.35,68.71 211.35,68.45 210.53,67.63 U6.26 ; C187.2 211.05,69.96 v1(211.07,69.98) ; C187.2 C175.1
VCCINTIO_BRAM_FPGA_SNS_P: length 134.8
  05_SIG2 w0.135: v1(193.14,67.06) 192.81,66.73 192.81,66.43 192.51,66.13 191.67,66.13 191.13,66.66 191.13,68.53 194.57,71.96 211.3,71.96 211.79,71.47 211.79,70.3 v1(212.18,69.9) 211.68,69.4 197.34,69.4 195.29,67.35 195.29,63.38 v1(194.56,62.66)
  BOTTOM w0.104: Z4.1 144.95,31.29 144.95,30.88 145.3,30.53 145.83,30.53 147.48,28.88 151.12,28.88 153.24,31.01 153.24,38.12 155.48,40.35 165.44,40.35 169.25,44.16 169.25,48.88 177.99,57.62 177.99,60.8 179.37,62.18 179.37,65.9 181.25,67.78 186.15,67.78 187.99,65.94 192.55,65.94 192.79,66.18 192.79,66.71 v1(193.14,67.06) ; U8.8 195.02,62.2 v1(194.56,62.66) ; U6.27 211.03,67.74 211.54,68.25 211.78,68.25 212.05,68.52 C187.1 212.05,69.76 v1(212.18,69.9)
VCCINTIO_BRAM_FPGA_VIN: length 3
  TOP w0.152: R78.1 194.76,59.4 v1(194.76,59.4)
  BOTTOM w0.152: v1(194.76,59.4) C127.1 194.76,60.56 194.52,60.8 U8.9
VCCINTIO_BRAM_PGOOD: length 152.8
  TOP w0.381: D17.1 v1(195.15,171.56) ; v1(202.99,158.08) 202.95,158.12 R106.2
  03_SIG1 w0.381: v1(195.15,171.56) 196.46,172.87 203.17,172.87 204.24,171.81 204.24,169.04 202.79,167.59 202.79,163.53 202.29,163.02 202.29,160.84 205.29,157.84 205.29,157.06 205.94,156.41 v1(209.22,156.41)
  05_SIG2 w0.381: v1(209.22,156.41) 209.22,154.74 210.36,153.6 210.36,142.72 205.41,137.77 205.41,131.27 206.65,130.02 206.65,79.8 213.7,72.76 215.4,72.76 216.32,71.84 216.32,68.53 215.11,67.32 214.56,67.32 v1(214.19,67.69)
  18_SIG6 w0.381: v1(202.99,158.08) 202.99,158.04 202.34,157.39 201.82,157.39 196.82,162.39 196.82,168.57 195.15,170.25 v1(195.15,171.56)
  BOTTOM w0.254: U6.32 213.53,67.15 214.06,67.69 v1(214.19,67.69)
  BOTTOM w0.381: Q26.1 v1(202.99,158.08)
VCCINTIO_BRAM_TEMPX: length 22.9
  BOTTOM w0.254: U6.7 214.7,63.26 215.59,62.38 215.59,61.86 215.98,61.47 C188.1 216.65,61.22 216.65,60.29 212.31,55.95 211.05,55.95 210.19,55.09 203.66,55.09 203.06,55.68 Q20.1 203.06,57.35 Q20.2
VCCINTIO_BRAM_VIN: length 3
  TOP w0.152: R79.1 v1(193.76,59.4)
  BOTTOM w0.152: v1(193.76,59.4) C127.2 193.76,60.59 194.02,60.85 U8.10
VCCPLL: length 0.6
  TOP w0.381: U111.F5 v5(17.9,137.37)
1N1524: length 0.9
  TOP w0.152: J2.B1 v1(176.94,159.51)
1N1551: length 0.9
  TOP w0.152: J2.D34 v1(135.03,162.05)
1N1554: length 0.9
  TOP w0.152: J2.B40 v1(127.41,159.51)
1N4342: length 0.9
  TOP w0.152: J2.A2 v1(175.67,158.24)
1N4343: length 0.9
  TOP w0.152: J2.A18 v1(155.35,158.24)
1N4344: length 0.9
  TOP w0.152: J2.A3 v1(174.4,158.24)
1N4345: length 0.9
  TOP w0.152: J2.A27 v1(143.92,158.24)
1N4346: length 0.9
  TOP w0.152: J2.A26 v1(145.19,158.24)
1N4347: length 0.9
  TOP w0.152: J2.A7 v1(169.32,158.24)
1N4348: length 0.9
  TOP w0.152: J2.A23 v1(149,158.24)
1N4349: length 0.9
  TOP w0.152: J2.A6 v1(170.59,158.24)
1N4350: length 0.9
  TOP w0.152: J2.A11 v1(164.24,158.24)
1N4351: length 0.9
  TOP w0.152: v1(154.08,158.24) J2.A19
1N4352: length 0.9
  TOP w0.152: J2.A14 v1(160.43,158.24)
1N4353: length 0.9
  TOP w0.152: J2.A15 v1(159.16,158.24)
1N4354: length 0.9
  TOP w0.152: J2.A10 v1(165.51,158.24)
1N4355: length 0.9
  TOP w0.152: J2.A22 v1(150.27,158.24)
1N4377: length 0.9
  TOP w0.152: J2.A30 v1(140.11,158.24)
1N4378: length 0.9
  TOP w0.152: J2.A31 v1(138.84,158.24)
1N4379: length 0.9
  TOP w0.152: J2.A35 v1(133.76,158.24)
1N4380: length 0.9
  TOP w0.152: J2.A34 v1(135.03,158.24)
1N4381: length 0.9
  TOP w0.152: J2.A39 v1(128.68,158.24)
1N4383: length 0.9
  TOP w0.152: J2.A38 v1(129.95,158.24)
1N4399: length 0.9
  TOP w0.152: J2.B4 v1(173.13,159.51)
1N4400: length 0.9
  TOP w0.152: J2.B5 v1(171.86,159.51)
1N4401: length 0.9
  TOP w0.152: J2.B9 v1(166.78,159.51)
1N4402: length 0.9
  TOP w0.152: J2.B8 v1(168.05,159.51)
1N4403: length 0.9
  TOP w0.152: J2.B13 v1(161.7,159.51)
1N4404: length 0.9
  TOP w0.152: J2.B16 v1(157.89,159.51)
1N4405: length 0.9
  TOP w0.152: J2.B17 v1(156.62,159.51)
1N4406: length 0.9
  TOP w0.152: J2.B12 v1(162.97,159.51)
1N4423: length 0.9
  TOP w0.152: J2.B24 v1(147.73,159.51)
1N4424: length 0.9
  TOP w0.152: J2.B25 v1(146.46,159.51)
1N4425: length 0.9
  TOP w0.152: J2.B29 v1(141.38,159.51)
1N4426: length 0.9
  TOP w0.152: J2.B28 v1(142.65,159.51)
1N4427: length 0.9
  TOP w0.152: J2.B33 v1(136.3,159.51)
1N4428: length 0.9
  TOP w0.152: J2.B36 v1(132.49,159.51)
1N4429: length 0.9
  TOP w0.152: J2.B37 v1(131.22,159.51)
1N4430: length 0.9
  TOP w0.152: J2.B32 v1(137.57,159.51)
1N4447: length 0.9
  TOP w0.152: J2.C2 v1(175.67,160.78)
1N4448: length 0.9
  TOP w0.152: J2.C3 v1(174.4,160.78)
1N4449: length 0.9
  TOP w0.152: J2.C7 v1(169.32,160.78)
1N4450: length 0.9
  TOP w0.152: J2.C6 v1(170.59,160.78)
1N4611: length 0.9
  TOP w0.152: J2.D4 v1(173.13,162.05)
1N4612: length 0.9
  TOP w0.152: J2.D5 v1(171.86,162.05)
1N4617: length 0.9
  TOP w0.152: J2.B20 v1(152.81,159.51)
1N4618: length 0.9
  TOP w0.152: J2.B21 v1(151.54,159.51)
4N2355: length 1.9
  BOTTOM w0.152: D15.2 171.3,25.88 171.3,25.88 171.1,25.68 R115.1
4N2356: length 2
  TOP w0.14: v1(222.91,172) 222.94,171.97 DS2.4
  BOTTOM w0.152: R473.2 222.77,171.86 v1(222.91,172)
4N2357: length 2.3
  TOP w0.14: DS2.1 226.41,169.64 v1(225.17,169.64)
  BOTTOM w0.152: v1(225.17,169.64) 225.26,169.55 R472.2
4N2358: length 256
  TOP w0.14: U53.3 132.53,16.23 132.72,16.41 132.72,16.59 133.02,16.89 133.93,16.89 134.29,16.54 v1(134.29,15.95)
  07_SIG3 w0.173: v1(134.29,15.95) 134.87,16.53 143.12,16.53 143.87,15.78 148,15.78 148.45,16.23 152.91,16.23 153.98,17.3 159.66,17.3 160.44,16.53 162.41,16.53 162.74,16.86 169.08,16.86 169.67,17.45 172.87,17.45 177.65,22.23 186.04,22.23 186.96,21.31 188.36,21.31 189.27,22.23 192.07,22.23 197.36,16.94 199.12,16.94 203.45,21.27 207.84,21.27 215.25,28.69 215.25,34.49 216.63,35.86 216.63,44.08 218.52,45.97 218.52,58.07 216.56,60.03 216.56,75.5 217.25,76.19 217.25,78.71 215.44,80.52 211.65,80.52 210.07,82.1 210.07,128.57 211.45,129.96 211.45,132.82 210.39,133.88 210.39,135.66 213.31,138.58 213.31,146.5 214.26,147.46 214.26,152.18 215.83,153.75 215.83,155.51 217.85,157.53 218.34,157.53 218.97,158.17 218.97,158.65 220,159.67 220,161.18 219.76,161.42 219.76,163.63 220.29,164.16 220.29,164.95 223.11,167.77 223.11,169.31 v1(224.87,171.07)
  BOTTOM w0.152: R473.1 v1(224.87,171.07) 225.38,170.55 R472.1
4N4374: length 2.2
  TOP w0.152: R554.1 J78.1
4N4376: length 2.2
  TOP w0.152: R553.1 J78.2
4N4692: length 1.3
  BOTTOM w0.152: D15.1 172.35,23.28 v1(171.93,22.86)
4N6788: length 2.6
  TOP w0.152: DS34.1 229.21,170.02 v1(229.54,169.7)
  BOTTOM w0.152: v1(229.54,169.7) 228.91,170.32 R598.1
4N6800: length 16.7
  16_SIG5 w0.089: v1(229.51,170.87) 221.96,163.31 221.96,162.09 220.73,160.86 v1(220.73,159.88)
  BOTTOM w0.152: Q2.3 v1(220.73,159.88) ; R598.2 229.06,171.32 v1(229.51,170.87)
5N11680: length 0.7
  TOP w0.152: U1.AN29 127.74,71.34 v2(128.24,71.84)
5N11683: length 0.7
  TOP w0.152: U1.AU36 v2(132.24,78.84)
6N5608: length 0.7
  TOP w0.152: U1.AL26 125.74,68.34 v2(126.24,68.84)
7N8237: length 0.7
  TOP w0.152: U1.J15 103.74,57.34 v2(103.24,56.84)
8N9313: length 5
  BOTTOM w0.152: R193.1 180.45,39.29 180.59,39.42 180.59,40.29 180.44,40.44 R218.2 179.32,40.44 178.88,40.88 U31.1
8N9315: length 6.2
  TOP w0.152: R319.1 172.46,40.7 172.85,40.31 173.86,40.31 v1(174.24,40.69) 174.24,40.7 R217.2
  BOTTOM w0.152: U31.15 173.8,40.25 v1(174.24,40.69)
8N9317: length 3.7
  TOP w0.152: R213.2 R318.1 178.61,39.4 v1(178.84,39.17)
  BOTTOM w0.152: U31.3 178.5,39.61 178.82,39.29 178.82,39.19 v1(178.84,39.17)
8N9319: length 3.5
  TOP w0.152: R208.2 R229.1 178.42,40.45 v1(178.8,40.07)
  BOTTOM w0.152: v1(178.8,40.07) 178.63,40.25 U31.2
8N9384: length 3.3
  BOTTOM w0.152: R223.1 R221.2 170.74,38.53 171.18,38.98 U31.13
8N9386: length 3.5
  BOTTOM w0.152: U31.14 171.18,39.61 170.16,40.63 R222.1 R220.2
8N9847: length 0.7
  TOP w0.152: U1.AL17 v2(126.24,58.84)
8N9851: length 0.7
  TOP w0.152: v2(141.24,61.84) U1.BF20
8N9854: length 0.7
  TOP w0.152: v2(140.24,61.84) U1.BE20
8N9858: length 0.7
  TOP w0.152: v2(140.24,60.84) U1.BE19
8N9859: length 0.7
  TOP w0.152: v2(141.24,60.84) U1.BF19
8N9863: length 0.7
  TOP w0.152: U1.AR17 v2(130.24,58.84)
8N9864: length 0.7
  TOP w0.152: v2(128.24,59.84) U1.AN18
8N9865: length 0.7
  TOP w0.152: v2(128.24,60.84) U1.AN19
8N9869: length 0.7
  TOP w0.152: U1.AT19 v2(131.24,60.84)
8N9870: length 0.7
  TOP w0.152: U1.AR18 v2(130.24,59.84)
8N9871: length 0.7
  TOP w0.152: v2(134.24,58.84) 133.74,59.34 U1.AW17
8N9873: length 0.7
  TOP w0.152: U1.BF17 v2(141.24,58.84)
8N9880: length 0.7
  TOP w0.152: v2(139.24,61.84) U1.BD20
8N9881: length 0.7
  TOP w0.152: U1.BD17 v2(139.24,58.84)
8N9882: length 0.7
  TOP w0.152: v2(139.24,59.84) U1.BD18
8N9883: length 0.7
  TOP w0.152: v2(140.24,59.84) U1.BE18
8N9884: length 0.7
  TOP w0.152: v2(138.24,61.84) U1.BC20
8N9885: length 0.7
  TOP w0.152: U1.BE17 v2(140.24,58.84)
8N9892: length 0.7
  TOP w0.152: U1.AT17 v2(131.24,58.84)
8N9893: length 0.7
  TOP w0.152: U1.AT20 v2(131.24,61.84)
8N9894: length 0.7
  TOP w0.152: U1.AU17 v2(132.24,58.84)
8N9895: length 0.7
  TOP w0.152: U1.AW20 v2(134.24,61.84)
8N9896: length 0.7
  TOP w0.152: U1.AR19 v2(130.24,60.84)
8N9897: length 0.7
  TOP w0.152: U1.AR20 v2(130.24,61.84)
8N9910: length 0.7
  TOP w0.152: U1.AU19 v2(132.24,60.84)
8N9911: length 0.7
  TOP w0.152: U1.AV20 v2(133.24,61.84)
8N9912: length 0.7
  TOP w0.152: U1.AU18 v2(132.24,59.84)
8N9913: length 0.7
  TOP w0.152: v2(135.24,58.84) 134.74,59.34 U1.AY17
8N9914: length 0.7
  TOP w0.152: U1.AV18 v2(133.24,59.84)
8N9915: length 0.7
  TOP w0.152: U1.AV19 v2(133.24,60.84)
8N9916: length 0.7
  TOP w0.152: U1.BA19 v2(136.24,60.84)
8N9917: length 0.7
  TOP w0.152: U1.AY18 v2(135.24,59.84)
8N9918: length 0.7
  TOP w0.152: U1.AW18 v2(134.24,59.84)
8N9919: length 0.7
  TOP w0.152: U1.BA17 135.74,59.34 v2(136.24,58.84)
8N9920: length 0.7
  TOP w0.152: U1.AY19 v2(135.24,60.84)
8N9921: length 0.7
  TOP w0.152: v2(137.24,58.84) 136.74,59.34 U1.BB17
8N9928: length 0.7
  TOP w0.152: v2(138.24,59.84) U1.BC18
8N9929: length 0.7
  TOP w0.152: v2(138.24,60.84) U1.BC19
8N9930: length 0.7
  TOP w0.152: U1.BB19 v2(137.24,60.84)
8N9931: length 0.7
  TOP w0.152: U1.AY20 v2(135.24,61.84)
8N9932: length 0.7
  TOP w0.152: U1.BB18 v2(137.24,59.84)
8N9933: length 0.7
  TOP w0.152: U1.BA20 v2(136.24,61.84)
8N9935: length 0.7
  TOP w0.152: v2(126.24,60.84) U1.AL19
9N9684: length 0.7
  TOP w0.152: U1.K36 v2(104.24,78.84)
9N9688: length 0.7
  TOP w0.152: U1.R36 v2(109.24,78.84)
9N9690: length 0.7
  TOP w0.152: v2(112.24,72.84) U1.V30
9N9738: length 0.7
  TOP w0.152: U1.AH30 v2(123.24,72.84)
9N9739: length 0.7
  TOP w0.152: v2(127.24,73.84) U1.AM31
9N10300: length 0.7
  TOP w0.152: v2(113.24,73.84) U1.W31
9N10301: length 0.7
  TOP w0.152: U1.U32 v2(111.24,74.84)
9N10302: length 0.7
  TOP w0.152: U1.U31 v2(111.24,73.84)
9N10303: length 0.7
  TOP w0.152: U1.T31 v2(110.24,73.84)
9N10304: length 0.7
  TOP w0.152: v2(114.24,73.84) U1.Y31
9N10308: length 0.7
  TOP w0.152: U1.T30 v2(110.24,72.84)
9N10384: length 0.7
  TOP w0.152: v2(105.24,80.84) 105.74,80.34 U1.L38
9N10385: length 0.7
  TOP w0.152: U1.M37 v2(106.24,79.84)
9N10740: length 0.7
  TOP w0.152: 109.74,75.34 v2(109.24,75.84)
9N10741: length 0.7
  TOP w0.152: 110.74,75.34 v2(110.24,75.84)
10N8170: length 0.7
  TOP w0.152: U1.AM16 v2(127.24,57.84)
10N8224: length 0.7
  TOP w0.152: U1.BB11 v2(137.24,52.84)
10N8836: length 0.7
  TOP w0.152: v2(130.24,56.84) 129.74,57.34 U1.AR15
10N8842: length 0.7
  TOP w0.152: v2(134.24,57.84) 133.74,58.34 U1.AW16
10N8984: length 0.7
  TOP w0.152: v2(139.24,51.84) U1.BD10
10N8985: length 0.7
  TOP w0.152: v2(138.24,51.84) U1.BC10
10N8987: length 0.7
  TOP w0.152: v2(140.24,51.84) U1.BE10
10N8988: length 0.7
  TOP w0.152: v2(140.24,48.84) U1.BE7
10N8989: length 0.7
  TOP w0.152: v2(140.24,49.84) U1.BE8
10N8990: length 0.7
  TOP w0.152: v2(139.24,48.84) U1.BD7
10N8992: length 0.7
  TOP w0.152: v2(140.24,50.84) U1.BE9
10N8994: length 0.7
  TOP w0.152: v2(139.24,49.84) U1.BD8
10N9224: length 0.7
  TOP w0.152: U1.AU14 131.74,56.34 v2(132.24,55.84)
10N9225: length 0.7
  TOP w0.152: U1.AN13 v2(128.24,54.84)
10N9226: length 0.7
  TOP w0.152: U1.AN14 v2(128.24,55.84)
10N9228: length 0.7
  TOP w0.152: v2(132.24,54.84) 131.74,55.34 U1.AU13
10N9606: length 0.7
  TOP w0.152: U1.BB8 v2(137.24,49.84)
10N9607: length 0.7
  TOP w0.152: U1.BB9 v2(137.24,50.84)
10N9644: length 0.7
  TOP w0.152: U1.BA10 v2(136.24,51.84)
10N9645: length 0.7
  TOP w0.152: v2(141.24,48.84) U1.BF7
11N5838: length 0.7
  TOP w0.152: U1.AE8 v2(120.24,49.84)
11N5839: length 0.7
  TOP w0.152: U1.AE9 v2(120.24,50.84)
11N8666: length 0.7
  TOP w0.152: v2(128.24,50.84) U1.AN9
11N8667: length 0.7
  TOP w0.152: v2(128.24,49.84) U1.AN8
11N8774: length 0.7
  TOP w0.152: v2(115.24,50.84) U1.AA9
11N8775: length 0.7
  TOP w0.152: v2(115.24,49.84) U1.AA8
11N9044: length 0.7
  TOP w0.152: U1.AR9 v2(130.24,50.84)
11N9045: length 0.7
  TOP w0.152: U1.AR8 v2(130.24,49.84)
12N5415: length 0.7
  TOP w0.152: U1.AW21 v2(134.24,62.84)
17N1467: length 2.2
  TOP w0.14: v1(63.05,144.15) 62.54,143.64 62.25,143.64 62.05,143.84 U19.18
17N1575: length 3.4
  TOP w0.152: U115.4 6.15,170.24 v1(5.76,169.85)
  BOTTOM w0.14: R575.2 v1(5.76,169.85)
17N1576: length 15.9
  TOP w0.152: U115.3 11.15,168 v1(11.27,167.87)
  BOTTOM w0.152: R574.2 9.82,158.97 13.21,162.36 13.21,165.94 v1(11.27,167.87)
17N1577: length 20.6
  TOP w0.152: U115.2 16.15,169.23 15.19,168.28 15.19,157.58 13.97,156.36 v1(11.18,156.36)
  BOTTOM w0.152: R573.2 v1(11.18,156.36)
17N1924: length 4.9
  TOP w0.152: U19.2 v1(53.32,147.09)
  BOTTOM w0.152: R861.2 54.58,148.67 54.58,148.01 53.67,147.09 v1(53.32,147.09)
17N2056: length 1.3
  BOTTOM w0.152: U13.4 36.96,68.62 v1(37.09,68.49)
17N2120: length 5.1
  TOP w0.152: J106.4 6.23,82.97 6.68,83.41 v1(6.68,84.63)
  BOTTOM w0.152: X7.3 7.23,84.08 v1(6.68,84.63)
17N2123: length 11.1
  TOP w0.381: J106.9 3.15,87.71 4.09,86.77 4.44,86.77 ; 4.44,86.77 4.44,85.85 J106.10 ; 4.44,86.77 4.64,86.77 5.63,87.76 R1324.1 ; J106.11 4.44,81.39 4.44,80.51 3.48,79.55 1.31,79.55
17N2634: length 65.5
  TOP w0.152: U115.7 v1(3.4,154.65)
  07_SIG3 w0.173: v1(3.4,154.65) 6.79,151.26 21.92,151.26 25.55,147.62 26.42,147.62 27.89,146.15 27.89,145.29 30.91,142.27 41.43,142.27 41.81,142.65 42.88,142.65 43.59,141.94 43.59,133.25 47.24,129.59 J17.1
17N2635: length 23.7
  TOP w0.152: U115.6 v1(1.2,162.11)
  03_SIG1 w0.173: J18.1 9.27,146.48 9.27,151.26 6.53,154 6.53,156.79 v1(1.2,162.11)
17N2674: length 32.7
  TOP w0.152: U115.5 v1(3.4,169.63)
  05_SIG2 w0.173: J19.1 10.92,155.32 10.39,155.85 10.39,158.33 10.97,158.91 10.97,167.41 10.24,168.15 10.24,169.03 8.43,170.84 4.61,170.84 v1(3.4,169.63)
  BOTTOM w0.152: v1(3.4,169.63) 3.54,169.49 R140.2
18N3158: length 0.6
  BOTTOM w0.152: U60.T7 v4(68.36,39.84)
18N4182: length 0.6
  BOTTOM w0.152: U61.T7 v4(68.36,68.04)
20N153: length 0.6
  BOTTOM w0.152: U62.T7 v4(68.36,96.23)
20N1721: length 0.6
  BOTTOM w0.152: U63.T7 v4(68.36,82.13)
21N4739: length 2.4
  TOP w0.381: R565.2 83.77,93.77 R566.2 83.76,93.76 C639.2
21N5660: length 0.6
  BOTTOM w0.152: U64.T7 v4(68.36,53.94)
22N1524: length 0.9
  TOP w0.152: J22.B1 v1(106.93,159.51)
22N1551: length 0.9
  TOP w0.152: J22.D34 v1(65.02,162.05)
22N1554: length 0.9
  TOP w0.152: J22.B40 v1(57.4,159.51)
23N1212: length 0.9
  TOP w0.152: J22.E21 v1(81.53,163.32)
23N1215: length 0.9
  TOP w0.152: J22.E22 v1(80.26,163.32)
23N1218: length 0.9
  TOP w0.152: J22.E24 v1(77.72,163.32)
23N1220: length 0.9
  TOP w0.152: J22.E25 v1(76.45,163.32)
23N1224: length 0.9
  TOP w0.152: J22.E27 v1(73.91,163.32)
23N1226: length 0.9
  TOP w0.152: J22.E28 v1(72.64,163.32)
23N1230: length 0.9
  TOP w0.152: J22.E30 v1(70.1,163.32)
23N1232: length 0.9
  TOP w0.152: J22.E31 v1(68.83,163.32)
23N1236: length 0.9
  TOP w0.152: J22.E33 v1(66.29,163.32)
23N1238: length 0.9
  TOP w0.152: J22.E34 v1(65.02,163.32)
23N1242: length 0.9
  TOP w0.152: J22.E36 v1(62.48,163.32)
23N1244: length 0.9
  TOP w0.152: J22.E37 v1(61.21,163.32)
23N1248: length 0.9
  TOP w0.152: J22.F22 v1(80.26,164.59)
23N1251: length 0.9
  TOP w0.152: J22.F23 v1(78.99,164.59)
23N1254: length 0.9
  TOP w0.152: J22.F25 v1(76.45,164.59)
23N1256: length 0.9
  TOP w0.152: J22.F26 v1(75.18,164.59)
23N1260: length 0.9
  TOP w0.152: J22.F28 v1(72.64,164.59)
23N1262: length 0.9
  TOP w0.152: J22.F29 v1(71.37,164.59)
23N1266: length 0.9
  TOP w0.152: J22.F31 v1(68.83,164.59)
23N1268: length 0.9
  TOP w0.152: J22.F32 v1(67.56,164.59)
23N1272: length 0.9
  TOP w0.152: J22.F34 v1(65.02,164.59)
23N1274: length 0.9
  TOP w0.152: J22.F35 v1(63.75,164.59)
23N1278: length 0.9
  TOP w0.152: J22.F37 v1(61.21,164.59)
23N1280: length 0.9
  TOP w0.152: J22.F38 v1(59.94,164.59)
24N1169: length 0.9
  TOP w0.152: J22.J24 v1(77.72,168.4)
24N1172: length 0.9
  TOP w0.152: J22.J25 v1(76.45,168.4)
24N1175: length 0.9
  TOP w0.152: J22.J27 v1(73.91,168.4)
24N1178: length 0.9
  TOP w0.152: J22.J28 v1(72.64,168.4)
24N1181: length 0.9
  TOP w0.152: J22.J30 v1(70.1,168.4)
24N1184: length 0.9
  TOP w0.152: J22.J31 v1(68.83,168.4)
24N1187: length 0.9
  TOP w0.152: J22.J33 v1(66.29,168.4)
24N1189: length 0.9
  TOP w0.152: J22.J34 v1(65.02,168.4)
24N1193: length 0.9
  TOP w0.152: J22.J36 v1(62.48,168.4)
24N1195: length 0.9
  TOP w0.152: J22.J37 v1(61.21,168.4)
24N1199: length 0.9
  TOP w0.152: J22.J39 v1(58.67,168.4)
24N1202: length 0.9
  TOP w0.152: J22.K25 v1(76.45,169.67)
24N1205: length 0.9
  TOP w0.152: J22.K26 v1(75.18,169.67)
24N1208: length 0.9
  TOP w0.152: J22.K28 v1(72.64,169.67)
24N1211: length 0.9
  TOP w0.152: J22.K29 v1(71.37,169.67)
24N1214: length 0.9
  TOP w0.152: J22.K31 v1(68.83,169.67)
24N1217: length 0.9
  TOP w0.152: J22.K32 v1(67.56,169.67)
24N1220: length 0.9
  TOP w0.152: J22.K34 v1(65.02,169.67)
24N1223: length 0.9
  TOP w0.152: J22.K35 v1(63.75,169.67)
24N1226: length 0.9
  TOP w0.152: J22.K37 v1(61.21,169.67)
24N1229: length 0.9
  TOP w0.152: J22.K38 v1(59.94,169.67)
24N1232: length 0.9
  TOP w0.152: J22.K40 v1(57.4,169.67)
24N1235: length 0.9
  TOP w0.152: J22.K1 v1(106.93,169.67)
24N1238: length 0.9
  TOP w0.152: J22.K4 v1(103.12,169.67)
24N1241: length 0.9
  TOP w0.152: J22.K5 v1(101.85,169.67)
24N1244: length 0.9
  TOP w0.152: v1(105.66,168.4) J22.J2
24N1247: length 0.9
  TOP w0.152: J22.J3 v1(104.39,168.4)
25N293: length 8.1
  BOTTOM w0.381: C466.1 114.35,163.06 114.35,166.56 J22.ST2 114.31,166.8 R346.1
25N294: length 10.3
  BOTTOM w0.381: R345.1 51.67,169.74 51.32,169.39 J22.ST1 52.92,164.99 C467.1
26N1212: length 0.9
  TOP w0.152: J2.E21 v1(151.54,163.32)
26N1215: length 0.9
  TOP w0.152: J2.E22 v1(150.27,163.32)
26N1218: length 0.9
  TOP w0.152: J2.E24 v1(147.73,163.32)
26N1220: length 0.9
  TOP w0.152: J2.E25 v1(146.46,163.32)
26N1224: length 0.9
  TOP w0.152: J2.E27 v1(143.92,163.32)
26N1226: length 0.9
  TOP w0.152: J2.E28 v1(142.65,163.32)
26N1230: length 0.9
  TOP w0.152: J2.E30 v1(140.11,163.32)
26N1232: length 0.9
  TOP w0.152: J2.E31 v1(138.84,163.32)
26N1236: length 0.9
  TOP w0.152: J2.E33 v1(136.3,163.32)
26N1238: length 0.9
  TOP w0.152: J2.E34 v1(135.03,163.32)
26N1242: length 0.9
  TOP w0.152: J2.E36 v1(132.49,163.32)
26N1244: length 0.9
  TOP w0.152: J2.E37 v1(131.22,163.32)
26N1248: length 0.9
  TOP w0.152: J2.F22 v1(150.27,164.59)
26N1251: length 0.9
  TOP w0.152: J2.F23 v1(149,164.59)
26N1254: length 0.9
  TOP w0.152: J2.F25 v1(146.46,164.59)
26N1256: length 0.9
  TOP w0.152: J2.F26 v1(145.19,164.59)
26N1260: length 0.9
  TOP w0.152: J2.F28 v1(142.65,164.59)
26N1262: length 0.9
  TOP w0.152: J2.F29 v1(141.38,164.59)
26N1266: length 0.9
  TOP w0.152: J2.F31 v1(138.84,164.59)
26N1268: length 0.9
  TOP w0.152: J2.F32 v1(137.57,164.59)
26N1272: length 0.9
  TOP w0.152: J2.F34 v1(135.03,164.59)
26N1274: length 0.9
  TOP w0.152: J2.F35 v1(133.76,164.59)
26N1278: length 0.9
  TOP w0.152: J2.F37 v1(131.22,164.59)
26N1280: length 0.9
  TOP w0.152: J2.F38 v1(129.95,164.59)
26N1653: length 0.9
  TOP w0.152: J2.F4 v1(173.13,164.59)
26N1655: length 0.9
  TOP w0.152: J2.F5 v1(171.86,164.59)
26N1657: length 0.9
  TOP w0.152: J2.F7 v1(169.32,164.59)
26N1659: length 0.9
  TOP w0.152: J2.F8 v1(168.05,164.59)
26N1665: length 0.9
  TOP w0.152: J2.F10 v1(165.51,164.59)
26N1667: length 0.9
  TOP w0.152: J2.F11 v1(164.24,164.59)
26N1669: length 0.9
  TOP w0.152: J2.F13 v1(161.7,164.59)
26N1671: length 0.9
  TOP w0.152: J2.F14 v1(160.43,164.59)
26N1677: length 0.9
  TOP w0.152: J2.F16 v1(157.89,164.59)
26N1679: length 0.9
  TOP w0.152: J2.F17 v1(156.62,164.59)
26N1681: length 0.9
  TOP w0.152: v1(154.08,164.59) J2.F19
26N1683: length 0.9
  TOP w0.152: J2.F20 v1(152.81,164.59)
26N1689: length 0.9
  TOP w0.152: J2.E15 v1(159.16,163.32)
26N1691: length 0.9
  TOP w0.152: J2.E16 v1(157.89,163.32)
26N1693: length 0.9
  TOP w0.152: J2.E18 v1(155.35,163.32)
26N1695: length 0.9
  TOP w0.152: v1(154.08,163.32) J2.E19
26N1701: length 0.9
  TOP w0.152: J2.E9 v1(166.78,163.32)
26N1703: length 0.9
  TOP w0.152: J2.E10 v1(165.51,163.32)
26N1705: length 0.9
  TOP w0.152: J2.E12 v1(162.97,163.32)
26N1707: length 0.9
  TOP w0.152: J2.E13 v1(161.7,163.32)
26N1713: length 0.9
  TOP w0.152: J2.E2 v1(175.67,163.32)
26N1715: length 0.9
  TOP w0.152: J2.E3 v1(174.4,163.32)
26N1717: length 0.9
  TOP w0.152: J2.E6 v1(170.59,163.32)
26N1719: length 0.9
  TOP w0.152: J2.E7 v1(169.32,163.32)
29N3158: length 0.6
  TOP w0.152: U135.T7 v4(167.56,49.96)
29N4153: length 0.6
  TOP w0.152: U136.T7 v4(167.56,64.06)
30N3617: length 0.7
  TOP w0.152: U1.N12 v2(107.24,53.84)
30N3618: length 0.7
  TOP w0.152: v2(103.24,55.84) 103.74,56.34 U1.J14
30N3619: length 0.7
  TOP w0.152: U1.R16 109.74,58.34 v2(109.24,57.84)
30N4994: length 0.7
  TOP w0.152: v2(126.24,63.84) U1.AL22
31N2260: length 6.3
  BOTTOM w0.178: R1261.1 R1241.1 228.44,111.72 228.74,111.42 229.38,111.42 229.74,111.05 230.42,111.05 231.27,110.21 U164.34
31N2264: length 6.9
  BOTTOM w0.178: R1261.2 R1215.1 C1713.1 228.35,109.56 228.49,109.7 C1689.2 229,109.71 231.1,109.71 U164.33
31N2266: length 4.7
  BOTTOM w0.178: U164.32 230.25,109.21 229.66,108.61 C1719.2 228.47,108.61 228.42,108.56 C1713.2
31N2267: length 7.2
  BOTTOM w0.178: C1690.2 R1272.1 228.52,105.96 231.27,108.71 U164.31
31N2291: length 9.6
  BOTTOM w0.178: U164.28 232.27,106.53 231.69,105.96 230.62,105.96 229.87,105.21 229.87,100.63 229.23,99.99 R1253.1
31N2351: length 3.1
  BOTTOM w0.178: C1719.1 227.08,107.61 226.58,108.11 R1215.2
31N2375: length 1.1
  BOTTOM w0.178: R1241.2 228.98,110.72 C1689.1
31N3241: length 4.3
  BOTTOM w0.178: U164.6 235.67,113.59 233.98,115.28 R1206.1
31N3243: length 5.3
  BOTTOM w0.178: R1201.1 232.71,114.81 233.04,114.48 234.16,114.48 235.17,113.46 U164.5
31N3245: length 6
  BOTTOM w0.178: U164.4 234.67,113.39 233.97,114.1 232.28,114.1 231.44,114.94 R1205.1
31N3247: length 6.2
  BOTTOM w0.178: R1254.1 230.17,115.58 232.08,113.67 233.65,113.67 234.17,113.14 U164.3
31N3249: length 7.1
  BOTTOM w0.178: R1265.1 228.9,115.07 229.11,114.86 230.28,114.86 231.95,113.19 233.34,113.19 233.6,112.94 233.6,112.92 233.67,112.84 U164.2
31N3251: length 7.5
  BOTTOM w0.178: U164.1 232.27,112.11 229.9,114.48 228.09,114.48 227.63,114.94 R1238.1
31N3398: length 3
  BOTTOM w0.254: U164.26 233.67,105.42 232.19,103.94
31N3508: length 4.6
  BOTTOM w0.152: U164.22 235.67,105.68 235.78,105.57 235.78,104.98 234.97,104.18 234.75,104.18 C1683.1
  BOTTOM w0.178: R1267.1 C1683.1
31N3515: length 4
  BOTTOM w0.178: C1684.1 R1268.1 235.63,104.24 236.17,104.78 U164.21
31N3619: length 4.7
  BOTTOM w0.178: C1685.1 R1269.1 238.17,104.65 237.41,105.41 236.85,105.41 236.67,105.59 U164.20
31N5850: length 11.6
  BOTTOM w0.178: R1222.1 226.91,99.86 227.05,99.99 C1691.2 227.82,100.31 228.09,100.31 R1253.2 229.23,101.46 229.23,103.56 229.49,103.81 229.49,105.66 231.54,107.71 U164.29
31N5852: length 1.3
  BOTTOM w0.178: C1637.1 R1222.2
31N6030: length 1.3
  BOTTOM w0.178: R1244.2 227.38,103.44 227.25,103.57 C1690.1
31N8456: length 5
  TOP w0.152: v1(235.25,105.36) 235.25,105.3 235.68,104.88 236.55,104.88 236.9,104.53 C229.1
  TOP w0.178: R171.1 C229.1
  BOTTOM w0.152: 235.19,105.46 235.19,105.42 v1(235.25,105.36)
  BOTTOM w0.178: U164.23 235.17,105.48 235.19,105.46
32N2260: length 4.3
  TOP w0.152: R1236.1 R1263.1 172.88,44.57 173.78,45.47 174.39,45.47 174.6,45.67 U165.34
32N2264: length 9
  TOP w0.152: v1(170.57,44.26) 170.87,44.57 R1263.2 ; U165.33 174.49,46.17 174.29,45.97 173.41,45.97 v1(173.18,45.75)
  BOTTOM w0.152: C1724.2 171.34,43.22 170.57,43.99 v1(170.57,44.26) 170.57,44.79 171.18,45.4 R1259.1 171.81,45.89 171.81,46.03 R1248.1 172.73,46.55 173.18,46.1 v1(173.18,45.75)
32N2266: length 7.7
  TOP w0.152: v1(170.57,47.71) 170.57,47.37 170.85,47.08 171.04,47.08 171.94,46.19 171.94,45.97 C1695.2 172.55,45.78 172.55,46.44 172.79,46.68 173.32,46.68 173.64,46.36 174.17,46.36 174.49,46.67 U165.32
  BOTTOM w0.152: C1638.2 170.59,47.69 v1(170.57,47.71)
32N2267: length 3.1
  TOP w0.152: U165.31 174.43,47.17 174.32,47.07 172.95,47.07 172.55,47.46 R1273.1
32N2291: length 3.4
  TOP w0.152: R1255.1 173.26,49.98 174.57,48.67 U165.28
32N2351: length 4.9
  BOTTOM w0.152: R1259.2 172.82,44.9 173.39,44.9 173.87,45.38 173.87,46.14 C1638.1
32N2375: length 3.6
  TOP w0.152: R1236.2 170.9,43.57 v1(170.56,43.23)
  BOTTOM w0.152: v1(170.56,43.23) 170.56,42.88 170.87,42.56 172.15,42.56 172.34,42.75 C1724.1
32N3241: length 2.5
  TOP w0.152: U165.6 178.54,43.04 v1(179.08,42.5)
  BOTTOM w0.152: R1280.1 179.08,42.63 v1(179.08,42.5)
32N3243: length 2.4
  TOP w0.152: v1(178.28,42.47) 178.04,42.71 U165.5
  BOTTOM w0.152: R1213.1 178.68,42.87 v1(178.28,42.47)
32N3245: length 2.2
  TOP w0.152: v1(177.43,42.5) 177.54,42.62 U165.4
  BOTTOM w0.152: R1281.1 177.68,43.24 177.68,42.76 v1(177.43,42.5)
32N3247: length 2.3
  TOP w0.152: U165.3 177.04,42.91 v1(176.61,42.47)
  BOTTOM w0.152: R1256.1 176.65,42.51 v1(176.61,42.47)
32N3249: length 2.4
  TOP w0.152: v1(175.77,42.5) 176.54,43.27 U165.2
  BOTTOM w0.152: R1229.1 175.77,43.11 v1(175.77,42.5)
32N3251: length 2.9
  TOP w0.152: v1(174.86,42.4) 175.54,43.08 175.74,43.08 176.04,43.38 U165.1
  BOTTOM w0.152: v1(174.86,42.4) 174.76,42.51 174.76,43.11 R1239.1
32N3398: length 5
  TOP w0.254: L97.2 176.31,53.04 176.02,52.76 176.02,51.23 176.54,50.71 U165.26
32N3515: length 4.5
  TOP w0.152: U165.21 179.04,51.11 v1(179.46,51.52)
  BOTTOM w0.152: C1720.1 178.31,49.6 R1270.1 179.46,50.75 v1(179.46,51.52)
32N3990: length 6.6
  TOP w0.152: U162.12 184.21,63.97 183.96,64.23 v1(183.96,64.97) 183.79,65.14 C1599.1
  BOTTOM w0.152: v1(183.96,64.97) 183.78,64.8 R1211.2 182.39,64.8 182.05,65.14 C1599.1
32N4051: length 4.1
  TOP w0.152: U162.16 184.57,61.97 184.23,61.63 184.23,61.09 183.29,60.15 v1(183.29,60.1) C1708.1
  BOTTOM w0.152: C1708.1 v1(183.29,60.1)
32N5850: length 6.9
  TOP w0.152: 171.34,49.36 v1(173.11,49.36) 173.35,49.36 174.54,48.17 U165.29 ; 171.34,49.36 C1694.2 ; 171.34,49.36 171.34,49.96 R1255.2
  BOTTOM w0.152: v1(173.11,49.36) 173.11,49.83 172.96,49.98 R1233.1
32N5852: length 1.3
  BOTTOM w0.152: C1722.1 171.32,48.74 R1233.2
32N6304: length 1.9
  TOP w0.152: C1703.2 185.73,66.21 186.01,65.93 U162.10
32N8319: length 2.4
  TOP w0.152: C1695.1 170.73,45.57 170.59,45.71 v1(170.59,46.55)
  BOTTOM w0.152: v1(170.59,46.55) R1248.2
32N9731: length 2.1
  TOP w0.152: v1(172.58,65.43) 172.32,65.18 U36.1
  BOTTOM w0.152: R129.2 v1(172.58,65.43)
32N9732: length 1.9
  TOP w0.152: U36.2 172.82,63.65 v1(173.08,63.39)
  BOTTOM w0.152: R128.2 v1(173.08,63.39)
34N153: length 0.6
  TOP w0.152: U137.T7 v4(167.56,78.15)
34N2121: length 0.6
  TOP w0.152: U138.T7 v4(167.56,92.25)
35N3590: length 2.2
  TOP w0.14: X6.3 165.22,22.63 165.29,22.56 U122.2
35N3592: length 8.1
  TOP w0.152: U122.1 165.79,22.3 166.09,22.6 168.87,22.6 169.31,23.04 169.31,24.15 168.9,24.56 168.21,25.25 X6.1
35N3667: length 3.9
  TOP w0.152: R803.2 R801.1 162.18,17.28 161.98,17.49 161.98,18.03 162.2,18.25 U122.12
35N3680: length 3.9
  TOP w0.152: U122.19 166.49,17.21 166.75,16.94 167.97,16.94 R804.1 168.01,15.73 R802.2
35N4466: length 4.1
  TOP w0.152: v1(203.17,22.12) 203.07,22.02 202.44,22.02 202.1,21.68 R28.2
  BOTTOM w0.152: v1(203.17,22.12) 203.79,21.5 U18.2
35N4621: length 30.7
  TOP w0.14: U157.2 177.2,16.07 v1(177.6,15.67)
  14_SIG4 w0.089: J8.2 200.91,20.73 199.47,19.28 197.38,19.28 194.72,16.61 178.54,16.61 v1(177.6,15.67)
  BOTTOM w0.152: R9.1 177.03,16.24 v1(177.6,15.67)
36N328: length 3.2
  TOP w0.152: v1(115,24.42) 115.58,25 U32.2
  BOTTOM w0.152: R77.2 115.04,24.43 arc(115.02,24.43) v1(115,24.42)
36N1657: length 46.8
  TOP w0.152: v1(104.07,22.63) 105.05,21.64 105.94,21.64 106.14,21.85 U104.2
  18_SIG6 w0.089: J9.2 65.3,20.02 71.02,20.02 72.87,21.87 76.48,21.87 77.09,22.48 79.53,22.48 80.77,21.23 89.89,21.23 90.58,21.92 98.68,21.92 99.26,21.34 102.77,21.34 v1(104.07,22.63)
  BOTTOM w0.152: v1(104.07,22.63) 104.23,22.79 R194.1
36N1876: length 2.5
  TOP w0.152: R86.2 U38.2
36N2434: length 1.8
  BOTTOM w0.152: R126.2 U14.1
38N7680: length 4
  TOP w0.152: R44.1 34.05,143.78 U7.12
38N7682: length 3.9
  TOP w0.152: U7.22 32.67,137.86 31.87,137.06 31.87,136.68 30.73,135.53 R30.2
38N7683: length 7.4
  TOP w0.152: U7.23 32.68,137.36 32.38,137.06 32.38,136.26 32.03,135.91 32.03,135.23 31.87,135.07 31.87,134.34 31.45,133.91 31.45,132 31.07,131.63 R29.2
38N7684: length 4
  TOP w0.152: U7.20 33.32,138.85 32.13,138.85 31.38,138.1 31.38,137.46 30.73,136.8 R31.2
38N7725: length 3.1
  TOP w0.14: U7.25 34.05,135.93 33.83,135.71 33.3,135.71 v1(33.02,135.43)
  BOTTOM w0.152: v1(33.02,135.43) 33.78,134.67 R73.2
38N7726: length 7.8
  TOP w0.152: U7.26 34.55,135.59 34.14,135.18 33.5,135.18 33.07,134.75 32.6,134.75 32.23,134.38 32.23,134.19 31.8,133.76 31.8,132.05 v1(32.44,131.42)
  BOTTOM w0.152: v1(32.44,131.42) 32.77,131.09 R35.2
38N10484: length 1.5
  TOP w0.152: v1(32,137.95) 32.41,138.36 U7.21
38N10790: length 3.7
  TOP w0.152: R32.1 30.85,138.07 31.93,139.15 31.93,139.61 32.19,139.87 33.31,139.87 U7.18
38N10890: length 2
  TOP w0.14: DS1.2 v1(41.1,147.5)
  BOTTOM w0.152: R33.2 v1(41.1,147.5)
38N12235: length 3.6
  TOP w0.152: C238.1 29.99,153.4 J10.7
38N12237: length 4.9
  TOP w0.152: J10.1 30.27,156.68 C237.1
38N12239: length 25.8
  TOP w0.152: C129.1 v1(32.58,147.34)
  05_SIG2 w0.173: J10.6 40.12,156.97 30.66,156.97 28.83,155.14 28.83,149.66 29.74,148.74 31.87,148.74 32.58,148.03 v1(32.58,147.34)
38N12241: length 3.1
  TOP w0.152: C1781.1 42.75,152.93 J10.12
39N5824: length 2.6
  TOP w0.152: U133.14 157.57,23.65 R1017.2
39N5868: length 2.5
  BOTTOM w0.152: U43.14 143.54,23.65 R215.2
40N107: length 4.7
  TOP w0.152: v1(147.54,112.56) 148.46,113.47 R352.1 R399.2
  BOTTOM w0.152: U12.3 v1(147.54,112.56)
40N4216: length 4
  TOP w0.152: U34.9 15.91,65.3 17.22,63.98 v1(17.22,63.76)
  BOTTOM w0.152: R498.1 16.94,63.47 v1(17.22,63.76)
40N4217: length 5.1
  TOP w0.14: v1(13.5,65.54) 14.14,66.17 U34.6
  TOP w0.152: C54.1 13.11,64.36 13.5,64.76 v1(13.5,65.54)
  BOTTOM w0.152: v1(13.5,65.54) 12.83,65.54 12.51,65.21 C470.1
40N4218: length 5.3
  TOP w0.152: J4.4 6.46,70.14 6.74,70.42 v1(6.74,71.88)
  BOTTOM w0.152: X1.3 7.36,71.26 v1(6.74,71.88)
40N4221: length 11.2
  TOP w0.381: 1.31,74.9 3.29,74.9 4.25,73.94 4.44,73.94 ; J4.11 4.44,68.56 4.44,67.69 3.48,66.72 1.31,66.72 ; 4.44,73.94 4.64,73.94 5.63,74.93 R1325.1 ; 4.44,73.94 4.44,73.02 J4.10
40N4233: length 0.8
  TOP w0.152: U34.16 v1(18.97,68.04)
40N4235: length 2.5
  TOP w0.152: v1(18.07,64.28) 17.52,64.28 16.41,65.39 U34.10
40N4237: length 1.3
  TOP w0.14: v1(17.63,64.89) 17.46,64.89 16.91,65.44 U34.11
40N4241: length 2
  TOP w0.14: v1(19.86,69.31) 19.21,68.66 18.83,68.66 18.72,68.54 U34.17
40N4295: length 6.1
  BOTTOM w0.152: R858.1 10.07,71.03 R859.1 12.2,71.03 12.83,70.41 v1(12.83,69.93) 12.83,69.09 12.36,68.62 12.36,68.19 12.23,68.06 U131.4
40N4316: length 1.5
  TOP w0.152: U34.19 17.41,70.43 v1(17.27,70.57)
  BOTTOM w0.152: Q55.3 v1(17.27,70.57)
40N4317: length 5.7
  TOP w0.152: v1(19.74,70.09) 18.7,69.04 U34.18
  BOTTOM w0.152: v1(19.74,70.09) 20.36,70.09 21.21,69.24 Q54.3
40N4318: length 4.2
  TOP w0.152: v1(13.46,70.57) 13.6,70.43 16.15,70.43 16.41,70.17 U34.21
  BOTTOM w0.152: Q53.3 v1(13.46,70.57)
40N4319: length 2.5
  TOP w0.152: v1(16.3,71.1) 16.3,70.82 16.91,70.21 U34.20
  BOTTOM w0.152: v1(16.3,71.1) 16.12,71.28 Q52.3
40N5167: length 2.1
  TOP w0.152: v1(19.97,68.17) 19.25,67.45 18.71,67.45 18.63,67.54 U34.15
40N5170: length 1.8
  TOP w0.152: U34.14 19.6,67.04 v1(19.84,67.28)
40N5326: length 3.6
  TOP w0.152: U34.13 18.93,66.54 19.08,66.4 v1(19.23,66.4)
  BOTTOM w0.152: v1(19.23,66.4) 20.41,65.22 Q56.3
40N5328: length 2.7
  TOP w0.152: U34.12 17.47,65.77 17.89,65.35 v1(19.18,65.35)
  BOTTOM w0.152: Q57.3 v1(19.18,65.35)
41N94: length 10.2
  TOP w0.152: SW6.2 v1(208.35,27.58) SW6.1
  BOTTOM w0.152: R840.2 v1(208.35,27.58)
41N96: length 10.3
  TOP w0.152: SW9.2 v1(222.88,27.58) SW9.1
  BOTTOM w0.152: R841.2 v1(222.88,27.58)
41N97: length 12.5
  TOP w0.381: v1(213.21,34.39) SW10.1 ; v1(217.88,34.39) SW10.2
  BOTTOM w0.381: R839.2 218.14,34.64 v1(217.88,34.39) v1(213.21,34.39)
41N2776: length 10.5
  TOP w0.152: SW17.2 v1(218.44,15.13) SW17.1
  BOTTOM w0.152: R837.2 218.72,14.85 v1(218.44,15.13)
41N2778: length 10.3
  TOP w0.152: SW7.2 v1(218.44,22.5) SW7.1
  BOTTOM w0.152: R838.2 v1(218.44,22.5)
41N3761: length 4
  TOP w0.152: DS7.2 221.45,169.61 221.68,169.38 v1(221.68,168.75)
  BOTTOM w0.152: v1(221.68,168.75) 221.68,170.25 221.47,170.46 R151.2
41N3762: length 4
  TOP w0.152: v1(220.03,168.75) 220.03,169.38 219.8,169.61 DS6.2
  BOTTOM w0.152: v1(220.03,168.75) 220.03,170.25 219.82,170.46 R149.2
41N3763: length 4
  TOP w0.152: v1(218.38,168.75) 218.38,169.38 218.15,169.61 DS8.2
  BOTTOM w0.152: v1(218.38,168.75) 218.38,170.25 218.17,170.46 R148.2
41N3764: length 4
  TOP w0.152: DS9.2 216.5,169.61 216.73,169.38 v1(216.73,168.75)
  BOTTOM w0.152: R147.2 216.52,170.46 216.73,170.25 v1(216.73,168.75)
41N3765: length 5.5
  TOP w0.152: DS10.2 214.09,169.61 214.4,169.29 v1(214.4,168)
  BOTTOM w0.152: R146.2 214.11,170.46 214.4,170.17 v1(214.4,168)
41N3766: length 3.9
  TOP w0.152: v1(212.45,168.73) 212.45,169.45 212.3,169.61 DS12.2
  BOTTOM w0.152: v1(212.45,168.73) 212.45,170.31 212.3,170.46 R145.2
41N3767: length 4
  TOP w0.152: DS13.2 210.66,169.61 210.89,169.38 v1(210.89,168.75)
  BOTTOM w0.152: v1(210.89,168.75) 210.89,170.25 210.68,170.46 R144.2
41N3768: length 4
  TOP w0.152: DS18.2 209.01,169.61 209.24,169.38 v1(209.24,168.75)
  BOTTOM w0.152: R143.2 209.03,170.46 209.24,170.25 v1(209.24,168.75)
41N3809: length 14.8
  TOP w0.14: DS10.1 v1(213.49,172.03)
  03_SIG1 w0.173: v1(210,160.64) 210,161.59 210.39,161.98 210.39,162.76 210.06,163.09 210.06,167.18 212.42,169.54 212.42,170.96 v1(213.49,172.03)
  BOTTOM w0.152: Q12.3 v1(210,160.64)
41N3810: length 15.1
  TOP w0.14: DS8.1 v1(217.55,172.03)
  03_SIG1 w0.173: v1(217.55,172.03) 213.73,168.21 213.73,165.22 213.33,164.82 213.33,161.95 213.94,161.34 v1(213.94,160.64)
  BOTTOM w0.152: Q14.3 v1(213.94,160.64)
41N3811: length 20
  TOP w0.14: DS6.1 v1(219.2,172.03)
  03_SIG1 w0.173: v1(215.84,160.64) 216.81,161.61 216.81,164.01 216.58,164.24 216.58,164.95 217.88,166.25 221.77,166.25 222.94,167.41 222.94,168.16 222.63,168.47 222.63,168.61 v1(219.2,172.03)
  BOTTOM w0.152: Q15.3 v1(215.84,160.64)
41N3812: length 14.7
  TOP w0.14: DS9.1 v1(215.9,172.03)
  03_SIG1 w0.173: v1(215.9,172.03) 212.97,169.11 212.97,165.78 212.71,165.51 212.71,162.03 212.03,161.36 v1(212.03,160.64)
  BOTTOM w0.152: Q13.3 v1(212.03,160.64)
41N3813: length 19
  TOP w0.14: DS7.1 v1(220.85,172.03)
  03_SIG1 w0.173: v1(217.88,160.64) 217.88,161.74 217.38,162.23 217.38,163.95 217.66,164.23 217.66,164.99 218.37,165.7 222,165.7 223.49,167.19 223.49,168.39 223.22,168.67 223.22,169.67 v1(220.85,172.03)
  BOTTOM w0.152: Q16.3 v1(217.88,160.64)
41N3814: length 16.6
  TOP w0.14: DS12.1 v1(211.71,172.03)
  03_SIG1 w0.173: v1(211.71,172.03) 210.86,171.18 209.05,171.18 207.36,169.49 207.36,164.64 208.46,163.54 208.46,161 v1(208.1,160.64)
  BOTTOM w0.152: Q11.3 v1(208.1,160.64)
41N3815: length 18.8
  TOP w0.14: DS13.1 v1(210.06,172.03)
  18_SIG6 w0.089: v1(210.06,172.03) 205.89,167.86 205.89,164.62 204.93,163.65 204.93,160.5 204.52,160.1 v1(204.52,157.58)
  BOTTOM w0.152: Q10.3 204.03,157.09 v1(204.52,157.58)
41N3816: length 19.3
  TOP w0.14: DS18.1 v1(208.41,172.03)
  18_SIG6 w0.089: v1(202.08,158.01) 202.08,163.04 203.61,164.57 203.61,168.71 206.93,172.03 v1(208.41,172.03)
  BOTTOM w0.152: v1(202.08,158.01) 201.87,157.81 Q8.3
42N2449: length 3.1
  BOTTOM w0.152: v1(62.72,30.54) 62.35,30.17 U17.11
42N2458: length 1.6
  BOTTOM w0.152: v1(63,34.79) 62.35,34.13 U17.10
42N2553: length 1.2
  BOTTOM w0.152: U44.11 v1(48.37,79.68)
42N2555: length 1.2
  BOTTOM w0.152: U44.10 v1(40.12,79.68)
42N3296: length 5
  BOTTOM w0.152: R85.2 47.17,74.49 U44.19 46.08,74.48 45.92,74.32 45.92,73.94 46.03,73.83 U44.20
42N3414: length 5.4
  BOTTOM w0.152: v1(56.85,51.99) 56.5,52.34 U3.20 ; v1(56.85,51.99) 56.85,51.17 57.21,50.8 R89.2 ; v1(56.85,51.99) 57.15,52.3 U3.19
42N3417: length 6.2
  BOTTOM w0.152: R90.2 57.18,25.23 v1(56.77,25.63) ; U17.20 56.5,25.9 v1(56.77,25.63) ; U17.19 57.15,26.01 v1(56.77,25.63)
43N2999: length 0.7
  TOP w0.152: v2(110.24,70.84) 110.74,70.34 U1.T28
48N1291: length 5.1
  TOP w0.152: R131.2 v1(223.98,71.05)
  BOTTOM w0.152: U41.20 221.75,70.4 221.62,70.54 221.62,70.92 221.75,71.05 U41.19 v1(223.98,71.05)
48N1428: length 4.8
  BOTTOM w0.152: R132.2 233.19,88.94 v1(233.19,88.16) U42.19 233.19,85.89 233.3,85.78 233.68,85.78 233.84,85.93 U42.20
49N610: length 6.1
  BOTTOM w0.152: R356.1 R75.2 v1(59.78,140.41) 57.55,142.64 U28.21
49N611: length 4.2
  TOP w0.152: R58.1 R355.2 51.48,141.59 v1(52.27,140.79)
  BOTTOM w0.152: U28.2 51.73,141.34 v1(52.27,140.79)
