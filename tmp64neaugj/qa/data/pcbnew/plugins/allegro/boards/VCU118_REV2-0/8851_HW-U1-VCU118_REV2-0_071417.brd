# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FMCP_HSPC_LA08_N: length 178.3
  TOP w0.104: v2(125.24,72.84) U1.AK30 ; J22.G13 v1(91.69,165.86)
  16_SIG5 w0.076: 136.9,89.63 136.9,89.61 136.85,89.57 136.85,87.57 136.84,87.55 136.84,86.12 136.82,86.1 136.82,84.66 136.84,84.64 136.84,71.59 136.49,71.24 124.89,71.24 124.65,71.48 124.65,72.24 124.86,72.44 125.16,72.44 125.24,72.52 v2(125.24,72.84)
  16_SIG5 w0.089: v1(91.69,165.86) 92.19,166.36 92.19,170.11 92.54,170.46 107.33,170.46 108.04,169.75 108.79,169.75 108.93,169.88 108.93,170.53 109.22,170.83 109.99,170.83 110.29,170.53 110.29,169.88 110.43,169.75 112.31,169.75 112.44,169.88 112.44,170.58 112.74,170.87 117.58,170.87 118.85,169.61 118.85,165.91 119.26,165.5 119.26,165.08 118.67,164.49 118.67,164.36 119.07,163.96 119.19,163.96 119.74,164.51 120.25,164.51 122.36,162.39 122.36,162.04 121.99,161.66 121.99,161.54 122.24,161.29 122.37,161.29 122.74,161.66 123.1,161.66 123.75,161.01 123.75,160.51 123.45,160.21 122.62,160.21 122.42,160.01 122.42,159.74 122.75,159.41 124.97,159.41 126.39,157.99 126.72,157.99 127.3,157.4 127.3,156.43 128.09,155.65 137.76,155.65 138.35,155.06 138.35,154.58 138.1,154.33 137.33,154.33 137.24,154.24 137.24,153.89 137.33,153.8 138.1,153.8 138.35,153.55 138.35,151.61 138.1,151.36 137.22,151.36 137.13,151.27 137.13,150.92 137.22,150.83 138.3,150.83 138.92,150.21 138.92,147.77 139.62,147.07 139.62,142.52 138.92,141.82 138.92,127.48 137.67,126.23 137.67,119.08 137.81,118.95 139.09,118.95 139.38,118.65 139.38,117.88 139.09,117.58 137.81,117.58 137.67,117.45 137.67,113.9 136.66,112.9 136.66,110.19 137.51,109.34 137.51,105.4 136.3,104.19 136.3,94.63 136.9,94.04 136.9,89.63
FMCP_HSPC_LA08_P: length 178.1
  TOP w0.104: J22.G12 v1(92.96,165.86) ; v2(125.24,71.84) 124.74,71.34 U1.AK29
  16_SIG5 w0.076: v2(125.24,71.84) 125.24,72.17 125.16,72.24 124.94,72.24 124.85,72.15 124.85,71.57 124.98,71.44 136.4,71.44 136.64,71.68 136.64,84.56 136.62,84.58 136.62,86.18 136.64,86.2 136.64,87.63 136.66,87.65 136.66,89.57 136.62,89.61 136.62,89.63
  16_SIG5 w0.089: v1(92.96,165.86) 92.96,165.38 92.79,165.2 92.43,165.2 92.31,165.32 92.31,166.08 92.47,166.24 92.47,169.99 92.66,170.18 107.21,170.18 107.93,169.47 108.91,169.47 109.2,169.77 109.2,170.41 109.34,170.55 109.88,170.55 110.01,170.41 110.01,169.77 110.31,169.47 112.42,169.47 112.72,169.77 112.72,170.46 112.86,170.59 117.47,170.59 118.57,169.49 118.57,165.79 118.98,165.38 118.98,165.19 118.39,164.61 118.39,164.25 118.95,163.68 119.31,163.68 119.85,164.23 120.13,164.23 122.08,162.28 122.08,162.15 121.71,161.78 121.71,161.42 122.13,161.01 122.48,161.01 122.86,161.38 122.98,161.38 123.47,160.89 123.47,160.63 123.33,160.49 122.51,160.49 122.14,160.12 122.14,159.63 122.64,159.13 124.86,159.13 126.27,157.71 126.6,157.71 127.03,157.29 127.03,156.32 127.97,155.37 137.64,155.37 138.07,154.94 138.07,154.7 137.99,154.61 137.21,154.61 136.96,154.36 136.96,153.77 137.21,153.52 137.99,153.52 138.07,153.43 138.07,151.73 137.99,151.64 137.11,151.64 136.86,151.39 136.86,150.8 137.11,150.55 138.19,150.55 138.64,150.09 138.64,147.65 139.34,146.95 139.34,142.64 138.64,141.93 138.64,127.59 137.39,126.34 137.39,118.97 137.69,118.67 138.97,118.67 139.1,118.53 139.1,118 138.97,117.86 137.69,117.86 137.39,117.56 137.39,114.02 136.39,113.01 136.39,110.07 137.23,109.22 137.23,105.52 136.02,104.31 136.02,94.52 136.62,93.92 136.62,89.63
FMCP_HSPC_LA09_N: length 172
  TOP w0.104: J22.D15 v1(89.15,162.05) ; v2(125.24,75.84) 124.74,75.34
  16_SIG5 w0.076: 125.88,90.34 125.88,90.22 125.84,90.18 125.84,89.08 125.82,89.06 125.82,87.63 125.84,87.61 125.84,86.19 125.85,86.17 125.85,84.54 125.82,84.5 125.82,82.66 125.84,82.64 125.84,77.6 125.48,77.24 124.99,77.24 124.84,77.09 124.84,75.92 124.91,75.84 v2(125.24,75.84)
  16_SIG5 w0.089: 125.88,90.34 125.88,90.92 123.19,93.6 123.19,94.76 122.71,95.25 122.33,95.25 122,95.58 122,95.87 122.14,96.01 123.29,96.01 123.59,96.31 123.59,97.08 123.29,97.37 122.14,97.37 122,97.51 122,98 122.14,98.14 123.39,98.14 123.69,98.44 123.69,100.02 123.06,100.65 122.55,100.65 121.98,100.09 121.55,100.09 121.42,100.22 121.42,100.76 121.96,101.3 121.96,102.14 122.71,102.89 122.71,103.86 122.36,104.21 122.36,104.79 122.56,104.99 122.81,104.99 123.18,105.36 123.18,106.36 122.31,107.24 122.31,124.6 121.95,124.96 121.95,125.93 121.69,126.18 121.42,126.18 121.34,126.27 121.34,126.45 121.42,126.54 121.69,126.54 121.95,126.79 121.95,127.2 121.69,127.45 121.42,127.45 121.34,127.54 121.34,127.72 121.42,127.81 121.69,127.81 121.95,128.06 121.95,128.47 121.69,128.72 121.42,128.72 121.34,128.81 121.34,128.99 121.42,129.08 121.69,129.08 121.95,129.33 121.95,130.48 122.03,130.57 122.48,130.57 122.73,130.82 122.73,131.23 122.48,131.48 122.03,131.48 121.95,131.57 121.95,131.75 122.03,131.84 122.48,131.84 122.73,132.09 122.73,132.5 122.48,132.75 122.03,132.75 121.95,132.84 121.95,133.02 122.03,133.11 122.48,133.11 122.73,133.36 122.73,133.77 122.48,134.02 122.03,134.02 121.95,134.11 121.95,134.29 122.03,134.38 122.48,134.38 122.73,134.63 122.73,135.04 122.48,135.29 122.03,135.29 121.95,135.38 121.95,135.8 121.63,136.12 121.11,136.12 120.85,135.87 120.85,130.3 120.65,130.1 120.47,130.1 120.29,130.28 120.29,132.08 119.4,132.97 119.4,133.16 120.18,133.93 120.18,134.41 119.73,134.86 119.36,134.86 118.53,134.03 118.34,134.03 116,136.37 116,137.81 115.75,138.06 115.02,138.06 114.93,138.15 114.93,138.42 115.02,138.5 115.75,138.5 116,138.76 116,139.24 114.35,140.89 114.35,144.17 114.07,144.45 113.39,144.45 113.13,144.2 113.13,143.09 113.05,143 106.34,143 106.25,143.09 106.25,143.36 106.34,143.45 112.44,143.45 112.69,143.7 112.69,144.2 112.44,144.45 105.13,144.45 104.88,144.7 104.88,146.23 104.6,146.51 98.68,146.51 98.12,147.07 98.12,150.41 97.63,150.9 90.09,150.9 88.52,152.48 88.52,152.6 89.13,153.21 89.13,153.57 88.78,153.92 88.42,153.92 87.81,153.31 87.68,153.31 87.39,153.61 87.39,154.07 87.48,154.16 87.77,154.16 87.86,154.25 87.86,154.43 87.77,154.52 87.48,154.52 87.39,154.61 87.39,162.26 87.68,162.55 89.53,162.55 89.7,162.38 89.7,162.21 89.55,162.05 v1(89.15,162.05)
FMCP_HSPC_LA09_P: length 171.9
  TOP w0.104: 123.74,75.34 v2(124.24,75.84) ; J22.D14 v1(90.42,162.05)
  16_SIG5 w0.076: 125.6,90.34 125.6,90.32 125.64,90.28 125.64,89.16 125.62,89.14 125.62,87.55 125.64,87.53 125.64,86.11 125.66,86.09 125.66,84.62 125.62,84.59 125.62,82.58 125.64,82.56 125.64,77.68 125.39,77.44 124.91,77.44 124.64,77.17 124.64,75.92 124.56,75.84 v2(124.24,75.84)
  16_SIG5 w0.089: v1(90.42,162.05) 89.65,162.83 89.29,162.83 87.56,162.83 87.11,162.38 87.11,153.49 87.57,153.03 87.93,153.03 88.53,153.64 88.66,153.64 88.85,153.45 88.85,153.33 88.24,152.72 88.24,152.36 89.98,150.62 97.51,150.62 97.84,150.29 97.84,146.95 98.56,146.23 104.48,146.23 104.6,146.11 104.6,144.59 105.01,144.17 112.32,144.17 112.41,144.08 112.41,143.81 112.32,143.73 106.22,143.73 105.97,143.47 105.97,142.98 106.22,142.72 113.16,142.72 113.41,142.98 113.41,144.08 113.5,144.17 113.96,144.17 114.07,144.05 114.07,140.78 115.72,139.13 115.72,138.87 115.63,138.78 114.91,138.78 114.66,138.53 114.66,138.03 114.91,137.78 115.63,137.78 115.72,137.69 115.72,136.26 118.23,133.75 118.65,133.75 119.47,134.58 119.61,134.58 119.9,134.29 119.9,134.05 119.12,133.28 119.12,132.85 120.02,131.96 120.02,130.16 120.36,129.82 120.77,129.82 121.13,130.19 121.13,135.75 121.22,135.84 121.51,135.84 121.67,135.69 121.67,135.26 121.92,135.01 122.36,135.01 122.45,134.92 122.45,134.74 122.36,134.65 121.92,134.65 121.67,134.4 121.67,133.99 121.92,133.74 122.36,133.74 122.45,133.65 122.45,133.47 122.36,133.38 121.92,133.38 121.67,133.13 121.67,132.72 121.92,132.47 122.36,132.47 122.45,132.38 122.45,132.2 122.36,132.11 121.92,132.11 121.67,131.86 121.67,131.45 121.92,131.2 122.36,131.2 122.45,131.11 122.45,130.93 122.36,130.84 121.92,130.84 121.67,130.59 121.67,129.44 121.58,129.35 121.31,129.35 121.06,129.1 121.06,128.69 121.31,128.44 121.58,128.44 121.67,128.35 121.67,128.17 121.58,128.08 121.31,128.08 121.06,127.83 121.06,127.42 121.31,127.17 121.58,127.17 121.67,127.08 121.67,126.9 121.58,126.81 121.31,126.81 121.06,126.56 121.06,126.15 121.31,125.9 121.58,125.9 121.67,125.81 121.67,124.85 122.03,124.49 122.03,107.12 122.9,106.25 122.9,105.47 122.69,105.26 122.44,105.26 122.08,104.9 122.08,104.1 122.43,103.75 122.43,103.01 121.68,102.26 121.68,101.42 121.14,100.87 121.14,100.1 121.43,99.81 122.1,99.81 122.66,100.38 122.95,100.38 123.42,99.91 123.42,98.56 123.27,98.42 122.02,98.42 121.72,98.12 121.72,97.39 122.02,97.09 123.17,97.09 123.31,96.96 123.31,96.42 123.17,96.29 122.02,96.29 121.72,95.99 121.72,95.46 122.22,94.97 122.59,94.97 122.91,94.65 122.91,93.49 125.6,90.8 125.6,90.34
FMCP_HSPC_LA10_N: length 167.5
  TOP w0.104: J22.C15 v1(89.15,160.78) ; U1.AR35 v2(130.24,77.84)
  16_SIG5 w0.076: 126.9,89.74 126.9,89.72 126.85,89.68 126.85,87.52 126.84,87.5 126.84,86.09 126.82,86.08 126.82,84.15 126.85,84.11 126.85,82.57 126.84,82.55 126.84,78.68 127.07,78.44 129.58,78.44 129.77,78.25 129.77,77.93 129.85,77.84 v2(130.24,77.84)
  16_SIG5 w0.089: v1(89.15,160.78) 89.15,160.31 89.31,160.15 89.55,160.15 89.69,160.28 89.69,161.12 89.53,161.28 88.79,161.28 88.66,161.14 88.66,155.23 88.9,154.99 89.77,154.99 90.02,154.74 90.02,152.3 90.5,151.82 104,151.82 104.25,151.56 104.25,151.07 104,150.81 99.1,150.81 99.01,150.72 99.01,150.46 99.1,150.37 104,150.37 104.25,150.12 104.25,149.62 104,149.36 99.1,149.36 99.01,149.28 99.01,149.01 99.1,148.92 104,148.92 104.25,148.67 104.25,148.17 104,147.92 99.1,147.92 99.01,147.83 99.01,147.56 99.1,147.47 104.61,147.47 104.7,147.56 104.7,151.56 104.95,151.82 105.46,151.82 105.77,151.51 105.77,145.97 106.4,145.34 114.99,145.34 115.24,145.09 115.24,141.38 115.91,140.71 116.21,140.71 116.46,140.46 116.46,140.12 116.55,140.03 116.82,140.03 116.91,140.12 116.91,140.46 117.16,140.71 119.56,140.71 121.74,138.53 121.74,138.19 122.11,137.82 122.11,137.47 121.88,137.24 121.88,137.11 122.07,136.92 122.19,136.92 122.42,137.15 122.78,137.15 123.67,136.26 123.67,133.8 123.76,133.71 123.95,133.71 124.21,133.46 124.21,132.96 123.95,132.71 123.76,132.71 123.67,132.62 123.67,132.35 123.76,132.26 123.95,132.26 124.21,132.01 124.21,131.51 123.95,131.26 123.76,131.26 123.67,131.17 123.67,129.91 122.83,129.07 122.83,125.38 123.23,124.99 123.23,118.33 123.81,117.75 123.81,111.28 123.27,110.74 123.27,107.84 124.71,106.39 124.71,104.82 123.63,103.74 123.63,101.42 124.66,100.4 124.66,93.39 126.9,91.15 126.9,89.74
FMCP_HSPC_LA10_P: length 166.8
  TOP w0.104: J22.C14 v1(90.42,160.78) ; v2(129.24,77.84) U1.AP35
  16_SIG5 w0.076: 126.62,89.74 126.62,89.72 126.66,89.68 126.66,87.6 126.64,87.58 126.64,86.18 126.62,86.16 126.62,84.07 126.66,84.03 126.66,82.65 126.64,82.63 126.64,78.59 126.99,78.24 129.49,78.24 129.57,78.17 129.57,77.91 129.51,77.84 v2(129.24,77.84)
  16_SIG5 w0.089: v1(90.42,160.78) 90.06,161.15 89.97,161.24 89.65,161.56 89.42,161.56 88.68,161.56 88.38,161.26 88.38,155.12 88.78,154.71 89.65,154.71 89.74,154.62 89.74,152.18 90.38,151.54 103.89,151.54 103.98,151.45 103.98,151.18 103.89,151.09 98.98,151.09 98.73,150.84 98.73,150.34 98.98,150.09 103.89,150.09 103.98,150 103.98,149.73 103.89,149.64 98.98,149.64 98.73,149.39 98.73,148.89 98.98,148.64 103.89,148.64 103.98,148.55 103.98,148.29 103.89,148.2 98.98,148.2 98.73,147.94 98.73,147.45 98.98,147.19 104.73,147.19 104.98,147.45 104.98,151.45 105.07,151.54 105.35,151.54 105.49,151.4 105.49,145.86 106.28,145.06 114.87,145.06 114.96,144.97 114.96,141.26 115.79,140.43 116.09,140.43 116.18,140.34 116.18,140 116.43,139.75 116.93,139.75 117.18,140 117.18,140.34 117.27,140.43 119.45,140.43 121.46,138.41 121.46,138.07 121.83,137.71 121.83,137.58 121.6,137.35 121.6,137 121.95,136.65 122.31,136.65 122.54,136.87 122.66,136.87 123.39,136.14 123.39,133.69 123.65,133.43 123.84,133.43 123.93,133.34 123.93,133.08 123.84,132.99 123.65,132.99 123.39,132.74 123.39,132.24 123.65,131.99 123.84,131.99 123.93,131.9 123.93,131.63 123.84,131.54 123.65,131.54 123.39,131.29 123.39,130.02 122.55,129.18 122.55,125.26 122.95,124.87 122.95,118.21 123.53,117.63 123.53,111.39 122.99,110.86 122.99,107.72 124.43,106.28 124.43,104.94 123.35,103.86 123.35,101.31 124.38,100.28 124.38,93.27 126.62,91.04 126.62,89.74
FMCP_HSPC_LA11_N: length 176.8
  TOP w0.104: J22.H17 v1(86.61,167.13) ; U1.AJ31 v2(124.24,73.84)
  16_SIG5 w0.076: 137.86,89.79 137.86,89.77 137.82,89.73 137.82,87.56 137.84,87.54 137.84,86.27 137.85,86.25 137.85,84.51 137.84,84.49 137.84,70.59 137.49,70.24 123.99,70.24 123.64,70.59 123.64,73.11 123.97,73.44 124.16,73.44 124.24,73.52 v2(124.24,73.84)
  16_SIG5 w0.089: 137.86,89.79 137.86,94.31 137.17,95 137.17,103.63 138.6,105.07 138.6,111.76 140.48,113.64 140.48,126.04 139.84,126.68 139.84,141.26 140.51,141.94 140.51,147.83 139.84,148.5 139.84,150.85 139.75,150.94 139.75,152.79 140.01,153.05 140.51,153.05 140.77,153.31 140.77,153.89 139.8,154.86 139.8,156.22 139.41,156.62 129.31,156.62 129.01,156.92 129.01,157.23 128.19,158.04 128.19,158.57 127.76,159 126.73,159 125.25,160.49 125.25,162.08 123.57,163.75 123.57,168.15 122.33,169.39 121.97,169.39 119.4,171.97 108.5,171.97 108.26,171.72 87.54,171.72 87.11,171.28 87.11,167.63 v1(86.61,167.13)
FMCP_HSPC_LA11_P: length 176.4
  TOP w0.104: J22.H16 v1(87.88,167.13) ; U1.AJ30 v2(124.24,72.84)
  16_SIG5 w0.076: 137.58,89.79 137.58,89.77 137.62,89.73 137.62,87.48 137.64,87.46 137.64,86.19 137.66,86.17 137.66,84.59 137.64,84.57 137.64,70.68 137.4,70.44 124.07,70.44 123.84,70.68 123.84,73.03 124.05,73.24 124.16,73.24 124.24,73.17 v2(124.24,72.84)
  16_SIG5 w0.089: v1(87.88,167.13) 87.88,166.61 87.74,166.46 87.49,166.46 87.39,166.57 87.39,171.17 87.66,171.44 108.37,171.44 108.62,171.69 119.28,171.69 121.86,169.11 122.21,169.11 123.29,168.03 123.29,163.64 124.97,161.96 124.97,160.37 126.61,158.72 127.65,158.72 127.91,158.46 127.91,157.92 128.73,157.11 128.73,156.81 129.2,156.34 139.29,156.34 139.52,156.11 139.52,154.74 140.49,153.78 140.49,153.42 140.4,153.33 139.9,153.33 139.47,152.91 139.47,150.83 139.56,150.73 139.56,148.38 140.23,147.71 140.23,142.05 139.56,141.38 139.56,126.56 140.2,125.93 140.2,113.75 138.32,111.88 138.32,105.18 136.89,103.75 136.89,94.88 137.58,94.2 137.58,89.79
FMCP_HSPC_LA12_N: length 171.8
  TOP w0.104: U1.AH34 v2(123.24,76.84) ; J22.G16 v1(87.88,165.86)
  16_SIG5 w0.076: 123.58,89.81 123.58,89.79 123.62,89.75 123.62,87.45 123.64,87.43 123.64,84.26 123.62,84.24 123.62,82.46 123.64,82.44 123.64,76.66 123.42,76.44 123.31,76.44 123.24,76.52 v2(123.24,76.84)
  16_SIG5 w0.089: v1(87.88,165.86) 88.31,165.86 88.43,165.73 88.43,165.54 88.26,165.37 85.02,165.37 84.57,164.92 84.57,155.46 84.32,155.21 71.58,155.21 71.27,154.9 71.27,154.19 71.57,153.9 72.01,153.9 72.14,153.76 72.14,151.44 72.53,151.05 86.63,151.05 88.91,148.77 95.49,148.77 95.99,148.27 95.99,146.11 98.4,143.7 98.76,143.7 99.36,144.29 99.48,144.29 99.67,144.1 99.67,143.98 99.07,143.38 99.07,143.02 99.88,142.21 100.55,142.21 100.8,142.47 100.8,144.18 100.89,144.27 101.16,144.27 101.25,144.18 101.25,142.47 101.5,142.21 102,142.21 102.25,142.47 102.25,144.18 102.34,144.27 102.61,144.27 102.7,144.18 102.7,142.47 102.95,142.21 103.96,142.21 105.58,140.6 105.93,140.6 106.22,140.89 106.34,140.89 106.53,140.7 106.53,140.57 106.25,140.29 106.25,139.93 107.21,138.96 107.96,138.96 108.21,139.22 108.21,140.53 108.3,140.61 108.56,140.61 108.65,140.53 108.65,139.19 108.91,138.94 109.87,138.94 118.17,130.63 118.17,129.15 119.2,128.12 119.2,111.45 120.18,110.47 120.18,103.66 118.61,102.08 118.61,101.57 117.06,100.02 117.06,97.84 115.89,96.67 115.89,93.77 116.8,92.87 117.22,92.87 117.5,93.15 117.69,93.15 118.08,92.77 118.08,92.58 117.79,92.3 117.79,91.87 118.16,91.5 119.49,91.5 119.79,91.8 119.79,93.9 120.02,94.12 120.42,94.12 120.6,93.94 120.6,91.8 120.9,91.5 122.24,91.5 123.58,90.17 123.58,89.81
FMCP_HSPC_LA12_P: length 171.8
  TOP w0.104: J22.G15 v1(89.15,165.86) ; 122.74,75.34 v2(123.24,75.84)
  16_SIG5 w0.076: 123.86,89.81 123.86,89.79 123.82,89.75 123.82,87.53 123.84,87.51 123.84,84.18 123.82,84.16 123.82,82.54 123.84,82.52 123.84,76.58 123.5,76.24 123.31,76.24 123.24,76.17 v2(123.24,75.84)
  16_SIG5 w0.089: 123.86,89.81 123.86,90.28 122.36,91.78 121.01,91.78 120.88,91.92 120.88,94.06 120.53,94.4 119.9,94.4 119.51,94.01 119.51,91.92 119.38,91.78 118.28,91.78 118.07,91.99 118.07,92.18 118.36,92.47 118.36,92.89 117.81,93.43 117.39,93.43 117.1,93.15 116.91,93.15 116.17,93.89 116.17,96.56 117.34,97.72 117.34,99.9 118.89,101.45 118.89,101.97 120.46,103.54 120.46,110.59 119.48,111.57 119.48,128.23 118.45,129.26 118.45,130.75 109.98,139.22 109.02,139.22 108.93,139.31 108.93,140.64 108.68,140.89 108.18,140.89 107.93,140.64 107.93,139.33 107.84,139.24 107.33,139.24 106.53,140.05 106.53,140.17 106.81,140.46 106.81,140.81 106.46,141.17 106.1,141.17 105.82,140.88 105.69,140.88 104.08,142.49 103.06,142.49 102.98,142.58 102.98,144.3 102.72,144.55 102.23,144.55 101.97,144.3 101.97,142.58 101.88,142.49 101.62,142.49 101.53,142.58 101.53,144.3 101.28,144.55 100.78,144.55 100.52,144.3 100.52,142.58 100.44,142.49 100,142.49 99.35,143.14 99.35,143.27 99.95,143.86 99.95,144.22 99.6,144.57 99.24,144.57 98.64,143.98 98.52,143.98 96.27,146.23 96.27,148.39 95.61,149.05 89.03,149.05 86.74,151.33 72.64,151.33 72.42,151.55 72.42,153.88 72.12,154.18 71.69,154.18 71.55,154.31 71.55,154.78 71.7,154.93 84.43,154.93 84.85,155.34 84.85,164.8 85.14,165.09 88.38,165.09 v1(89.15,165.86)
FMCP_HSPC_LA13_N: length 169.5
  TOP w0.104: U1.AJ36 v2(124.24,78.84) ; J22.D18 v1(85.34,162.05)
  16_SIG5 w0.076: v2(124.24,78.84) 124.24,78.52 124.31,78.44 124.42,78.44 124.64,78.66 124.64,82.64 124.66,82.66 124.66,84.01 124.62,84.05 124.62,86.2 124.64,86.22 124.64,87.63 124.66,87.65 124.66,89.02 124.64,89.04 124.64,90.28 124.6,90.32 124.6,90.34
  16_SIG5 w0.089: v1(85.34,162.05) 85.84,161.56 85.84,155.03 85.04,154.23 73.46,154.23 73.08,153.86 73.08,153.37 73.34,153.11 74.07,153.11 74.15,153.02 74.15,152.2 74.41,151.94 74.91,151.94 75.16,152.2 75.16,153.02 75.25,153.11 75.51,153.11 75.6,153.02 75.6,152.2 75.85,151.94 76.35,151.94 76.61,152.2 76.61,153.02 76.69,153.11 76.96,153.11 77.05,153.02 77.05,152.2 77.3,151.94 77.8,151.94 78.05,152.2 78.05,153.02 78.14,153.11 78.41,153.11 78.5,153.02 78.5,152.2 78.75,151.94 79.25,151.94 79.5,152.2 79.5,153.02 79.59,153.11 79.86,153.11 79.95,153.02 79.95,152.2 80.2,151.94 80.7,151.94 80.95,152.2 80.95,153.02 81.04,153.11 81.3,153.11 81.39,153.02 81.39,152.2 81.65,151.94 82.14,151.94 82.4,152.2 82.4,153.02 82.49,153.11 82.75,153.11 82.84,153.02 82.84,152.2 83.09,151.94 83.59,151.94 83.84,152.2 83.84,153.02 83.93,153.11 84.2,153.11 84.29,153.02 84.29,152.2 84.54,151.94 85.04,151.94 85.29,152.2 85.29,153.02 85.38,153.11 86.02,153.11 89.42,149.71 96.43,149.71 96.95,149.19 96.95,146.52 98.16,145.31 103.31,145.31 103.66,144.97 103.66,144.02 105.87,141.81 108.85,141.81 110.82,139.84 111.17,139.84 112.11,140.78 112.24,140.78 112.43,140.59 112.43,140.47 111.49,139.53 111.49,139.17 111.84,138.82 112.2,138.82 113.39,140.01 113.52,140.01 113.68,139.85 113.68,139.67 112.51,138.5 112.51,138.15 113,137.66 113.36,137.66 113.51,137.81 113.64,137.81 113.83,137.62 113.83,137.49 113.67,137.34 113.67,136.99 119.09,131.57 119.09,129.59 120.12,128.57 120.12,125.07 121.1,124.08 121.1,123.65 120.97,123.51 120.47,123.51 120.17,123.22 120.17,122.45 120.47,122.15 120.97,122.15 121.1,122.01 121.1,120.1 120.97,119.97 120.49,119.97 120.19,119.67 120.19,118.9 120.49,118.6 120.97,118.6 121.1,118.47 121.1,117.23 121,117.13 120.75,117.13 120.47,116.85 120.47,116.46 120.77,116.16 120.97,116.16 121.13,116 121.13,115.08 120.97,114.91 120.57,114.91 120.3,114.64 120.3,114.16 120.6,113.86 120.97,113.86 121.1,113.73 121.1,103.13 120.2,102.23 120.2,101.25 120.07,101.12 119.52,101.12 119.22,100.82 119.22,100.05 119.52,99.75 120.07,99.75 120.2,99.62 120.2,98.94 119.99,98.72 118.35,98.72 118.07,98.45 118.07,97.74 118.37,97.44 120.07,97.44 120.2,97.3 120.2,95.67 121.66,94.21 121.66,92.87 122.05,92.48 122.63,92.48 124.6,90.51 124.6,90.34
FMCP_HSPC_LA13_P: length 171
  TOP w0.104: U1.AJ35 v2(124.24,77.84) ; J22.D17 v1(86.61,162.05)
  16_SIG5 w0.076: 124.88,90.34 124.88,90.32 124.84,90.28 124.84,89.12 124.85,89.1 124.85,87.57 124.84,87.55 124.84,86.14 124.82,86.12 124.82,84.13 124.85,84.09 124.85,82.57 124.84,82.56 124.84,78.58 124.5,78.24 124.31,78.24 124.24,78.17 v2(124.24,77.84)
  16_SIG5 w0.089: v1(86.61,162.05) 86.61,162.3 86.53,162.39 85.97,162.39 85.89,162.3 85.89,161.91 86.12,161.67 86.12,154.92 85.15,153.95 73.58,153.95 73.36,153.74 73.36,153.48 73.46,153.39 74.18,153.39 74.43,153.14 74.43,152.31 74.52,152.22 74.79,152.22 74.88,152.31 74.88,153.14 75.13,153.39 75.63,153.39 75.88,153.14 75.88,152.31 75.97,152.22 76.24,152.22 76.33,152.31 76.33,153.14 76.58,153.39 77.08,153.39 77.33,153.14 77.33,152.31 77.42,152.22 77.69,152.22 77.77,152.31 77.77,153.14 78.03,153.39 78.52,153.39 78.78,153.14 78.78,152.31 78.87,152.22 79.13,152.22 79.22,152.31 79.22,153.14 79.47,153.39 79.97,153.39 80.23,153.14 80.23,152.31 80.31,152.22 80.58,152.22 80.67,152.31 80.67,153.14 80.92,153.39 81.42,153.39 81.67,153.14 81.67,152.31 81.76,152.22 82.03,152.22 82.12,152.31 82.12,153.14 82.37,153.39 82.87,153.39 83.12,153.14 83.12,152.31 83.21,152.22 83.48,152.22 83.57,152.31 83.57,153.14 83.82,153.39 84.32,153.39 84.57,153.14 84.57,152.31 84.66,152.22 84.92,152.22 85.01,152.31 85.01,153.14 85.27,153.39 86.13,153.39 89.53,149.99 96.55,149.99 97.23,149.3 97.23,146.63 98.27,145.59 103.43,145.59 103.94,145.08 103.94,144.13 105.98,142.09 108.97,142.09 110.93,140.12 111.06,140.12 112,141.06 112.35,141.06 112.71,140.71 112.71,140.35 111.77,139.41 111.77,139.29 111.96,139.1 112.08,139.1 113.27,140.29 113.63,140.29 113.96,139.97 113.96,139.56 112.79,138.39 112.79,138.26 113.12,137.94 113.24,137.94 113.4,138.09 113.75,138.09 114.1,137.74 114.1,137.38 113.95,137.23 113.95,137.1 119.37,131.68 119.37,129.71 120.4,128.68 120.4,125.19 121.38,124.2 121.38,123.53 121.09,123.23 120.58,123.23 120.45,123.1 120.45,122.56 120.58,122.43 121.09,122.43 121.38,122.13 121.38,119.99 121.09,119.69 120.6,119.69 120.47,119.55 120.47,119.01 120.6,118.88 121.09,118.88 121.38,118.58 121.38,117.12 121.12,116.85 120.87,116.85 120.75,116.73 120.75,116.58 120.88,116.44 121.09,116.44 121.41,116.12 121.41,114.96 121.08,114.63 120.69,114.63 120.58,114.52 120.58,114.28 120.72,114.14 121.09,114.14 121.38,113.84 121.38,103.02 120.48,102.11 120.48,101.14 120.18,100.84 119.64,100.84 119.5,100.7 119.5,100.16 119.64,100.03 120.18,100.03 120.48,99.73 120.48,98.82 120.1,98.44 118.46,98.44 118.35,98.33 118.35,97.85 118.49,97.72 120.18,97.72 120.48,97.42 120.48,95.79 121.94,94.33 121.94,92.98 122.17,92.76 122.75,92.76 124.88,90.63 124.88,90.34
FMCP_HSPC_LA14_N: length 176.3
  TOP w0.104: J22.C19 v1(84.07,160.78) ; U1.AH31 v2(123.24,73.84)
  14_SIG4 w0.076: 122.01,90.73 121.95,90.73 121.55,90.34 121.25,90.34 120.67,89.76 120.54,89.76 119.82,89.04 119.82,87.5 119.85,87.46 119.85,85.31 119.84,85.29 119.84,84.28 119.82,84.26 119.82,82.34 119.84,82.32 119.84,74.68 120.07,74.44 122.5,74.44 122.84,74.11 122.84,73.92 122.91,73.84 v2(123.24,73.84)
  14_SIG4 w0.089: v1(84.07,160.78) 84.85,161.56 85.64,161.56 86.12,161.08 86.12,154.38 86.59,153.91 87.52,153.91 87.62,154.01 87.62,154.51 87.95,154.85 89.26,154.85 89.52,154.59 89.52,152.92 89.61,152.83 89.96,152.83 90.05,152.92 90.05,154.59 90.3,154.85 90.89,154.85 91.14,154.59 91.14,152.92 91.23,152.83 91.59,152.83 91.68,152.92 91.68,154.59 91.93,154.85 92.52,154.85 92.77,154.59 92.77,152.92 92.86,152.83 93.21,152.83 93.3,152.92 93.3,154.59 93.55,154.85 94.14,154.85 94.39,154.59 94.39,152.92 94.48,152.83 94.84,152.83 94.93,152.92 94.93,154.59 95.18,154.85 95.77,154.85 96.02,154.59 96.02,152.92 96.11,152.83 96.46,152.83 96.55,152.92 96.55,154.59 96.81,154.85 97.39,154.85 97.65,154.59 97.65,152.92 97.73,152.83 98.09,152.83 98.18,152.92 98.18,154.59 98.43,154.85 99.02,154.85 99.27,154.59 99.27,152.92 99.36,152.83 99.72,152.83 99.8,152.92 99.8,154.59 100.06,154.85 100.64,154.85 100.9,154.59 100.9,152.92 100.99,152.83 101.34,152.83 101.43,152.92 101.43,154.59 101.68,154.85 103.31,154.85 103.59,154.57 103.59,154.01 103.69,153.91 114.94,153.91 120.17,148.68 125.54,148.68 127.47,146.75 128.43,146.75 131.49,143.69 131.49,137.69 131.77,137.4 132.51,137.4 133.26,136.65 133.26,136.05 132.98,135.78 132.18,135.78 132.08,135.67 132.08,135.25 132.18,135.15 132.98,135.15 133.26,134.87 133.26,134.2 132.98,133.93 132.18,133.93 132.08,133.83 132.08,133.4 132.18,133.3 132.98,133.3 133.26,133.03 133.26,132.36 132.98,132.09 132.18,132.09 132.08,131.99 132.08,130.87 131.41,130.2 131.41,129.23 130.92,128.75 130.92,122.48 131.31,122.1 131.31,121.23 130.04,119.96 130.04,113.87 130.86,113.05 130.86,108.08 129.72,106.93 129.72,98.44 122.01,90.73
FMCP_HSPC_LA14_P: length 176.4
  TOP w0.104: J22.C18 v1(85.34,160.78) ; U1.AG31 v2(122.24,73.84)
  14_SIG4 w0.076: 121.82,90.94 121.82,90.89 121.47,90.53 121.17,90.53 120.59,89.96 120.46,89.96 119.62,89.12 119.62,87.42 119.66,87.38 119.66,85.39 119.64,85.38 119.64,84.36 119.62,84.34 119.62,82.26 119.64,82.24 119.64,74.59 119.99,74.24 122.42,74.24 122.64,74.03 122.64,73.92 122.56,73.84 v2(122.24,73.84)
  14_SIG4 w0.089: v1(85.34,160.78) 85.34,160.48 85.24,160.38 84.94,160.38 84.73,160.59 84.73,161.04 84.96,161.28 85.52,161.28 85.84,160.96 85.84,154.27 86.48,153.63 87.63,153.63 87.9,153.89 87.9,154.4 88.07,154.57 89.15,154.57 89.24,154.48 89.24,152.8 89.49,152.55 90.08,152.55 90.33,152.8 90.33,154.48 90.42,154.57 90.77,154.57 90.86,154.48 90.86,152.8 91.12,152.55 91.7,152.55 91.96,152.8 91.96,154.48 92.04,154.57 92.4,154.57 92.49,154.48 92.49,152.8 92.74,152.55 93.33,152.55 93.58,152.8 93.58,154.48 93.67,154.57 94.03,154.57 94.11,154.48 94.11,152.8 94.37,152.55 94.95,152.55 95.21,152.8 95.21,154.48 95.3,154.57 95.65,154.57 95.74,154.48 95.74,152.8 95.99,152.55 96.58,152.55 96.83,152.8 96.83,154.48 96.92,154.57 97.28,154.57 97.37,154.48 97.37,152.8 97.62,152.55 98.21,152.55 98.46,152.8 98.46,154.48 98.55,154.57 98.9,154.57 98.99,154.48 98.99,152.8 99.24,152.55 99.83,152.55 100.08,152.8 100.08,154.48 100.17,154.57 100.53,154.57 100.62,154.48 100.62,152.8 100.87,152.55 101.46,152.55 101.71,152.8 101.71,154.48 101.8,154.57 103.2,154.57 103.31,154.46 103.31,153.89 103.57,153.63 114.83,153.63 120.06,148.4 125.42,148.4 127.35,146.47 128.31,146.47 131.21,143.57 131.21,137.57 131.66,137.12 132.39,137.12 132.98,136.54 132.98,136.16 132.87,136.05 132.07,136.05 131.8,135.79 131.8,135.13 132.07,134.87 132.87,134.87 132.98,134.76 132.98,134.32 132.87,134.21 132.07,134.21 131.8,133.95 131.8,133.29 132.07,133.02 132.87,133.02 132.98,132.91 132.98,132.48 132.87,132.37 132.07,132.37 131.8,132.1 131.8,130.98 131.13,130.31 131.13,129.35 130.64,128.86 130.64,122.37 131.03,121.99 131.03,121.34 129.76,120.07 129.76,113.76 130.58,112.93 130.58,108.19 129.44,107.05 129.44,98.56 121.82,90.94
FMCP_HSPC_LA15_N: length 172.3
  TOP w0.104: 121.74,75.34 v2(122.24,75.84) ; J22.H20 v1(82.8,167.13)
  16_SIG5 w0.076: v2(122.24,75.84) 122.24,75.52 122.16,75.44 118.71,75.44 118.67,75.48 118.65,75.48
  16_SIG5 w0.089: v1(82.8,167.13) 83.23,167.13 83.36,167.27 83.36,167.45 83.18,167.63 82.57,167.63 82.31,167.37 82.31,157.9 81.88,157.47 67.32,157.47 67.07,157.21 67.07,155.46 68.41,154.12 69.26,154.12 69.62,153.76 69.62,149.5 70.74,148.39 71.12,148.39 71.21,148.48 71.21,149.28 71.46,149.53 72.05,149.53 72.3,149.28 72.3,148.48 72.39,148.39 72.75,148.39 72.83,148.48 72.83,149.28 73.09,149.53 73.67,149.53 73.93,149.28 73.93,148.48 74.02,148.39 86.92,148.39 88.21,147.09 92.65,147.09 92.99,146.75 92.99,146.39 92.55,145.95 92.55,145.82 92.8,145.57 92.93,145.57 93.37,146.01 93.73,146.01 94.14,145.6 94.14,145.24 93.7,144.8 93.7,144.67 93.95,144.42 94.07,144.42 94.52,144.86 94.88,144.86 95.29,144.45 95.29,144.09 94.85,143.65 94.85,143.52 95.1,143.27 95.22,143.27 95.67,143.71 96.03,143.71 96.44,143.3 96.44,142.94 96,142.5 96,142.37 96.25,142.12 96.37,142.12 96.82,142.56 97.18,142.56 97.59,142.15 97.59,141.79 97.15,141.35 97.15,141.22 97.4,140.97 97.52,140.97 97.97,141.41 98.33,141.41 99,140.74 103.17,140.74 106.47,137.44 109.12,137.44 116.54,130.02 116.54,126.97 116.84,126.66 116.84,125.65 117.61,124.88 117.61,110.68 118.52,109.78 118.52,105.78 115.79,103.06 115.79,101.26 114.34,99.81 114.34,97.35 113.71,96.72 113.71,91.58 113.12,91 113.12,90.23 113.44,89.92 117.67,89.92 118.04,89.55 118.04,77.84 118.13,77.75 118.44,77.75 118.53,77.66 118.53,77.4 118.44,77.31 118.13,77.31 118.04,77.22 118.04,76.95 118.13,76.86 118.44,76.86 118.53,76.78 118.53,76.51 118.44,76.42 118.13,76.42 118.04,76.33 118.04,75.93 118.48,75.48 118.65,75.48
FMCP_HSPC_LA15_P: length 171.7
  TOP w0.104: U1.AG32 v2(122.24,74.84) ; J22.H19 v1(84.07,167.13)
  16_SIG5 w0.076: 118.65,75.2 118.67,75.2 118.71,75.24 121.84,75.24 v2(122.24,74.84)
  16_SIG5 w0.089: v1(84.07,167.13) 83.3,167.91 82.45,167.91 82.03,167.49 82.03,158.01 81.76,157.75 67.21,157.75 66.79,157.33 66.79,155.35 68.29,153.84 69.15,153.84 69.34,153.64 69.34,149.39 70.62,148.11 71.24,148.11 71.49,148.36 71.49,149.16 71.58,149.25 71.93,149.25 72.02,149.16 72.02,148.36 72.27,148.11 72.86,148.11 73.11,148.36 73.11,149.16 73.2,149.25 73.56,149.25 73.65,149.16 73.65,148.36 73.9,148.11 86.8,148.11 88.1,146.81 92.53,146.81 92.71,146.63 92.71,146.51 92.27,146.06 92.27,145.7 92.68,145.29 93.04,145.29 93.49,145.73 93.61,145.73 93.86,145.48 93.86,145.36 93.42,144.91 93.42,144.55 93.83,144.14 94.19,144.14 94.64,144.58 94.76,144.58 95.01,144.33 95.01,144.21 94.57,143.76 94.57,143.4 94.98,142.99 95.34,142.99 95.78,143.43 95.91,143.43 96.16,143.18 96.16,143.06 95.72,142.61 95.72,142.26 96.13,141.84 96.49,141.84 96.93,142.28 97.06,142.28 97.31,142.03 97.31,141.91 96.87,141.46 96.87,141.11 97.28,140.69 97.64,140.69 98.08,141.13 98.21,141.13 98.89,140.46 103.05,140.46 106.35,137.16 109,137.16 116.26,129.91 116.26,126.85 116.56,126.55 116.56,125.54 116.77,125.33 117.34,124.76 117.34,110.57 118.24,109.66 118.24,105.9 115.51,103.17 115.51,101.38 114.06,99.92 114.06,97.47 113.43,96.84 113.43,91.7 112.84,91.11 112.84,90.12 113.32,89.64 117.56,89.64 117.76,89.43 117.76,75.81 118.37,75.2 118.65,75.2
FMCP_HSPC_LA16_N: length 172.5
  TOP w0.104: J22.G19 v1(84.07,165.86) ; U1.AH35 v2(123.24,77.84)
  16_SIG5 w0.076: 122.9,89.7 122.9,89.68 122.85,89.64 122.85,87.49 122.84,87.47 122.84,84.22 122.85,84.2 122.85,82.53 122.84,82.51 122.84,77.92 122.91,77.84 v2(123.24,77.84)
  16_SIG5 w0.089: v1(84.07,165.86) 84.07,165.62 84.17,165.52 84.59,165.52 84.76,165.69 84.76,166.06 84.45,166.36 83.78,166.36 83.58,166.15 83.58,156.61 83.17,156.2 68.62,156.2 68.34,155.92 68.34,155.5 68.78,155.06 70.29,155.06 70.59,154.76 70.59,153.74 70.68,153.65 70.96,153.65 71.05,153.56 71.05,153.41 70.94,153.31 70.68,153.31 70.59,153.22 70.59,151.56 71.7,150.44 75.97,150.44 76.23,150.19 76.23,149.36 76.31,149.28 76.67,149.28 76.76,149.36 76.76,150.19 77.01,150.44 77.6,150.44 77.85,150.19 77.85,149.36 77.94,149.28 78.3,149.28 78.38,149.36 78.38,150.19 78.64,150.44 79.22,150.44 79.48,150.19 79.48,149.36 79.57,149.28 79.92,149.28 80.01,149.36 80.01,150.19 80.26,150.44 80.85,150.44 81.1,150.19 81.1,149.36 81.19,149.28 81.55,149.28 81.64,149.36 81.64,150.19 81.89,150.44 82.48,150.44 82.73,150.19 82.73,149.36 82.82,149.28 83.17,149.28 83.26,149.36 83.26,150.19 83.51,150.44 84.1,150.44 84.35,150.19 84.35,149.36 84.44,149.28 84.8,149.28 84.89,149.36 84.89,150.19 85.14,150.44 86.23,150.44 88.6,148.08 92.99,148.08 93.49,147.58 93.62,147.58 94.2,148.16 94.56,148.16 94.91,147.81 94.91,147.45 94.33,146.87 94.33,146.74 99.45,141.62 103.63,141.62 106.92,138.33 109.55,138.33 117.54,130.34 117.54,128.86 118.54,127.85 118.54,111.06 119.47,110.13 119.47,104.44 118.77,103.74 118.39,103.74 117.39,102.75 117.39,101.55 115.81,99.96 115.81,97.52 115.24,96.95 115.24,93.47 115.75,92.96 115.75,92.45 114.58,91.28 114.58,91.03 114.79,90.81 115.17,90.81 116.32,91.96 116.74,91.96 117.8,90.91 119.9,90.91 120.19,90.61 120.19,89.87 120.33,89.74 120.6,89.74 120.73,89.87 120.73,90.61 121.03,90.91 121.93,90.91 122.9,89.95 122.9,89.7
FMCP_HSPC_LA16_P: length 172.4
  TOP w0.104: U1.AG34 v2(122.24,76.84) ; J22.G18 v1(85.34,165.86)
  16_SIG5 w0.076: 122.62,89.7 122.62,89.68 122.66,89.64 122.66,87.57 122.64,87.55 122.64,84.14 122.66,84.12 122.66,82.61 122.64,82.59 122.64,77.24 v2(122.24,76.84)
  16_SIG5 w0.089: v1(85.34,165.86) 84.57,166.64 83.67,166.64 83.3,166.27 83.3,156.72 83.05,156.48 68.5,156.48 68.06,156.04 68.06,155.38 68.66,154.78 70.18,154.78 70.31,154.65 70.31,151.45 71.59,150.16 75.86,150.16 75.95,150.08 75.95,149.25 76.2,149 76.79,149 77.04,149.25 77.04,150.08 77.13,150.16 77.48,150.16 77.57,150.08 77.57,149.25 77.82,149 78.41,149 78.66,149.25 78.66,150.08 78.75,150.16 79.11,150.16 79.2,150.08 79.2,149.25 79.45,149 80.04,149 80.29,149.25 80.29,150.08 80.38,150.16 80.73,150.16 80.82,150.08 80.82,149.25 81.08,149 81.66,149 81.92,149.25 81.92,150.08 82,150.16 82.36,150.16 82.45,150.08 82.45,149.25 82.7,149 83.29,149 83.54,149.25 83.54,150.08 83.63,150.16 83.99,150.16 84.07,150.08 84.07,149.25 84.33,149 84.91,149 85.17,149.25 85.17,150.08 85.26,150.16 86.12,150.16 88.48,147.8 92.87,147.8 93.38,147.3 93.73,147.3 94.32,147.88 94.44,147.88 94.63,147.7 94.63,147.57 94.05,146.99 94.05,146.63 99.34,141.34 103.52,141.34 106.81,138.05 109.43,138.05 117.26,130.23 117.26,128.75 118.26,127.74 118.26,110.94 119.19,110.02 119.19,104.56 118.65,104.02 118.27,104.02 117.11,102.87 117.11,101.66 115.53,100.08 115.53,97.63 114.96,97.06 114.96,93.36 115.47,92.84 115.47,92.57 114.3,91.39 114.3,90.91 114.68,90.53 115.29,90.53 116.44,91.68 116.63,91.68 117.68,90.63 119.78,90.63 119.91,90.49 119.91,89.76 120.21,89.46 120.71,89.46 121.01,89.76 121.01,90.49 121.15,90.63 121.82,90.63 122.62,89.83 122.62,89.7
FMCP_HSPC_LA17_CC_N: length 157.2
  TOP w0.104: U1.P34 v2(108.24,76.84) ; J22.D21 v1(81.53,162.05)
  18_SIG6 w0.076: v2(108.24,76.84) 108.55,76.84 108.61,76.9 108.61,77.21 108.84,77.44 111.4,77.44 111.64,77.68 111.64,80.09 111.99,80.44 115.4,80.44 115.64,80.68 115.64,82.65 115.66,82.66 115.66,85.24 115.62,85.28 115.62,87.3 115.66,87.34 115.66,89.52 115.62,89.55 115.62,89.56
  18_SIG6 w0.089: v1(81.53,162.05) 81.89,162.05 82.03,161.92 82.03,159.23 81.81,159.02 71.05,159.02 70.6,158.56 70.6,154.36 67.31,151.07 67.31,145.66 67.56,145.4 68.01,145.4 68.1,145.31 68.1,144.96 68.01,144.87 67.56,144.87 67.31,144.62 67.31,143.96 66.7,143.35 66.7,141.62 66.91,141.4 67.4,141.4 68.09,142.09 68.5,142.09 68.75,142.34 68.75,143.37 68.84,143.46 69.19,143.46 69.28,143.37 69.28,142.34 69.53,142.09 70.12,142.09 70.37,142.34 70.37,143.37 70.46,143.46 70.82,143.46 70.91,143.37 70.91,142.67 71.21,142.37 73.96,142.37 76.21,144.62 94.26,144.62 96.75,142.12 99.85,142.12 114.64,127.33 115.15,127.33 116.64,125.84 116.64,124.92 118.23,123.32 118.23,106.39 117.63,105.79 117.63,102.52 117.19,102.07 117.19,97.81 115.94,96.56 115.94,90.42 115.62,90.1 115.62,89.56
FMCP_HSPC_LA17_CC_P: length 157
  TOP w0.104: U1.R34 v2(109.24,76.84) ; J22.D20 v1(82.8,162.05)
  18_SIG6 w0.076: 115.9,89.56 115.9,89.55 115.85,89.5 115.85,87.26 115.82,87.22 115.82,85.36 115.85,85.32 115.85,82.58 115.84,82.56 115.84,80.59 115.49,80.24 112.07,80.24 111.84,80.01 111.84,77.59 111.49,77.24 108.93,77.24 108.81,77.13 108.81,76.95 108.92,76.84 v2(109.24,76.84)
  18_SIG6 w0.089: 115.9,89.56 115.9,89.99 116.22,90.3 116.22,96.45 117.47,97.7 117.47,101.96 117.91,102.4 117.91,105.67 118.51,106.27 118.51,123.44 116.92,125.03 116.92,125.96 115.27,127.61 114.76,127.61 99.97,142.4 96.87,142.4 94.37,144.9 76.09,144.9 73.85,142.65 71.32,142.65 71.19,142.79 71.19,143.49 70.93,143.74 70.35,143.74 70.09,143.49 70.09,142.46 70.01,142.37 69.65,142.37 69.56,142.46 69.56,143.49 69.31,143.74 68.72,143.74 68.47,143.49 68.47,142.46 68.38,142.37 67.97,142.37 67.28,141.68 67.03,141.68 66.98,141.73 66.98,143.23 67.59,143.84 67.59,144.5 67.68,144.59 68.12,144.59 68.38,144.84 68.38,145.43 68.12,145.68 67.68,145.68 67.59,145.77 67.59,150.95 70.88,154.24 70.88,158.45 71.17,158.74 81.93,158.74 82.31,159.12 82.31,161.56 v1(82.8,162.05)
FMCP_HSPC_LA18_CC_N: length 160
  TOP w0.104: J22.C23 v1(78.99,160.78)
  TOP w0.152: U1.P31 v2(108.24,73.84)
  18_SIG6 w0.076: 114.55,89.48 114.55,89.47 114.62,89.4 114.62,87.55 114.66,87.51 114.66,87.08 114.66,84.75 114.61,84.71 114.61,84.01 114.62,84 114.62,81.66 114.4,81.44 110.96,81.44 110.64,81.12 110.64,78.68 110.4,78.44 107.99,78.44 107.64,78.09 107.64,76.54 107.94,76.23 108.45,76.23 108.64,76.04 108.64,73.92 108.56,73.84 v2(108.24,73.84)
  18_SIG6 w0.089: v1(78.99,160.78) 79.35,160.78 79.49,160.65 79.49,160.43 79.35,160.29 69.78,160.29 69.33,159.83 69.33,155.32 66.17,152.16 66.17,144.36 65.71,143.91 65.71,140.88 66.25,140.34 67.68,140.34 68.52,141.17 71.45,141.17 71.71,141.43 74.32,141.43 76.59,143.7 93.94,143.7 96.39,141.24 99.48,141.24 114.39,126.34 114.74,126.34 115.21,125.87 115.21,124.92 117.28,122.86 117.28,121.6 117.19,121.51 116.69,121.51 116.43,121.26 116.43,120.67 116.69,120.42 117.19,120.42 117.28,120.33 117.28,119.97 117.19,119.88 116.69,119.88 116.43,119.63 116.43,119.04 116.69,118.79 117.19,118.79 117.28,118.7 117.28,118.35 117.19,118.26 116.69,118.26 116.43,118 116.43,117.42 116.69,117.17 117.19,117.17 117.28,117.08 117.28,116.72 117.19,116.63 116.69,116.63 116.43,116.38 116.43,115.79 116.69,115.54 117.19,115.54 117.28,115.45 117.28,115.1 117.19,115.01 116.69,115.01 116.43,114.75 116.43,114.17 116.69,113.91 117.19,113.91 117.28,113.83 117.28,111.12 116.24,110.07 116.24,108.16 116.61,107.78 116.61,103 115.56,101.96 115.56,97.69 114.85,96.98 114.85,90.43 114.55,90.13 114.55,89.48
FMCP_HSPC_LA18_CC_P: length 159.9
  TOP w0.104: J22.C22 v1(80.26,160.78)
  TOP w0.152: U1.R31 v2(109.24,73.84)
  18_SIG6 w0.076: 114.82,89.48 114.82,89.47 114.82,89.46 114.82,87.63 114.86,87.59 114.86,87 114.85,84.67 114.81,84.62 114.81,84.09 114.82,84.08 114.82,81.58 114.49,81.24 111.04,81.24 110.84,81.04 110.84,78.59 110.49,78.24 108.07,78.24 107.84,78.01 107.84,76.62 108.03,76.43 108.53,76.43 108.84,76.13 108.84,73.92 108.91,73.84 v2(109.24,73.84)
  18_SIG6 w0.089: v1(80.26,160.78) 79.94,160.78 79.77,160.62 79.77,160.31 79.47,160.01 69.9,160.01 69.61,159.72 69.61,155.21 66.45,152.04 66.45,144.25 65.99,143.79 65.99,141 66.37,140.61 67.56,140.61 68.4,141.45 71.34,141.45 71.59,141.71 74.2,141.71 76.47,143.98 94.06,143.98 96.51,141.52 99.6,141.52 114.5,126.62 114.86,126.62 115.49,125.98 115.49,125.04 117.56,122.97 117.56,121.48 117.31,121.23 116.8,121.23 116.71,121.14 116.71,120.78 116.8,120.7 117.31,120.7 117.56,120.44 117.56,119.86 117.31,119.6 116.8,119.6 116.71,119.51 116.71,119.16 116.8,119.07 117.31,119.07 117.56,118.82 117.56,118.23 117.31,117.98 116.8,117.98 116.71,117.89 116.71,117.53 116.8,117.44 117.31,117.44 117.56,117.19 117.56,116.6 117.31,116.35 116.8,116.35 116.71,116.26 116.71,115.91 116.8,115.82 117.31,115.82 117.56,115.57 117.56,114.98 117.31,114.73 116.8,114.73 116.71,114.64 116.71,114.28 116.8,114.19 117.31,114.19 117.56,113.94 117.56,111 116.52,109.96 116.52,108.27 116.89,107.9 116.89,102.89 115.84,101.84 115.84,97.58 115.12,96.86 115.12,90.31 114.82,90.01 114.82,89.48
FMCP_HSPC_LA19_N: length 161
  TOP w0.104: J22.H23 v1(78.99,167.13) ; 106.74,75.34 v2(106.24,75.84)
  16_SIG5 w0.076: v2(106.24,75.84) 106.56,75.84 106.64,75.92 106.64,76.13 106.95,76.44 109.4,76.44 109.64,76.68 109.64,84.5 109.62,84.52 109.62,86.15 109.64,86.17 109.64,87.69 109.66,87.71 109.66,89.3 109.62,89.34 109.62,89.36
  16_SIG5 w0.089: v1(78.99,167.13) 79.33,167.13 79.49,166.98 79.49,160.55 79.23,160.29 64.7,160.29 64.25,159.83 64.25,153.24 67.31,150.18 67.31,148.53 69.51,146.33 85.48,146.33 87.59,144.22 87.95,144.22 88.56,144.83 88.68,144.83 88.93,144.58 88.93,144.46 88.32,143.85 88.32,143.49 88.74,143.07 89.1,143.07 89.7,143.68 89.83,143.68 90.08,143.43 90.08,143.31 89.47,142.7 89.47,142.34 89.89,141.92 90.24,141.92 90.85,142.53 90.98,142.53 91.23,142.28 91.23,142.16 90.62,141.55 90.62,141.19 91.04,140.77 91.39,140.77 92,141.38 92.13,141.38 92.38,141.13 92.38,141.01 91.77,140.4 91.77,140.04 92.19,139.62 92.54,139.62 93.15,140.23 93.28,140.23 93.53,139.98 93.53,139.86 92.92,139.25 92.92,138.89 93.2,138.61 102.23,138.61 105.46,135.38 108.13,135.38 113.88,129.63 113.88,125.15 115.39,123.63 115.39,112.76 115.07,112.45 115.07,106.02 112.48,103.43 112.48,101.4 110.92,99.84 110.92,92.19 109.62,90.88 109.62,89.36
FMCP_HSPC_LA19_P: length 160.8
  TOP w0.104: J22.H22 v1(80.26,167.13) ; 107.74,75.34 v2(107.24,75.84)
  16_SIG5 w0.076: v2(107.24,75.84) 106.91,75.84 106.84,75.92 106.84,76.05 107.03,76.24 109.49,76.24 109.84,76.59 109.84,84.58 109.82,84.6 109.82,86.07 109.84,86.09 109.84,87.61 109.85,87.63 109.85,89.3 109.9,89.34 109.9,89.36
  16_SIG5 w0.089: 109.9,89.36 109.9,90.77 111.2,92.07 111.2,99.72 112.76,101.28 112.76,103.31 115.35,105.9 115.35,112.33 115.67,112.65 115.67,123.75 114.16,125.26 114.16,129.75 108.24,135.66 105.58,135.66 102.35,138.89 93.32,138.89 93.2,139.01 93.2,139.13 93.81,139.74 93.81,140.1 93.39,140.51 93.04,140.51 92.43,139.9 92.3,139.9 92.05,140.16 92.05,140.28 92.66,140.89 92.66,141.25 92.25,141.66 91.89,141.66 91.28,141.05 91.15,141.05 90.9,141.31 90.9,141.43 91.51,142.04 91.51,142.4 91.1,142.81 90.74,142.81 90.13,142.2 90,142.2 89.75,142.46 89.75,142.58 90.36,143.19 90.36,143.55 89.95,143.96 89.59,143.96 88.98,143.35 88.85,143.35 88.6,143.6 88.6,143.73 89.21,144.34 89.21,144.7 88.8,145.11 88.44,145.11 87.83,144.5 87.7,144.5 85.6,146.61 69.62,146.61 67.59,148.64 67.59,150.29 64.53,153.35 64.53,159.72 64.82,160.01 79.35,160.01 79.77,160.43 79.77,166.64 v1(80.26,167.13)
FMCP_HSPC_LA20_N: length 162.1
  TOP w0.104: U1.M32 v2(106.24,74.84) ; J22.G22 v1(80.26,165.86)
  16_SIG5 w0.076: v2(106.24,74.84) 106.56,74.84 106.64,74.92 106.64,75.17 106.91,75.44 110.45,75.44 110.64,75.63 110.64,82.52 110.62,82.54 110.62,84.62 110.66,84.66 110.66,86.06 110.64,86.08 110.64,87.54 110.62,87.55 110.62,89.14 110.64,89.16 110.64,89.28 110.6,89.32 110.6,89.34
  16_SIG5 w0.089: v1(80.26,165.86) 80.76,165.37 80.76,159.25 80.53,159.02 65.97,159.02 65.52,158.56 65.52,155.27 68.35,152.44 68.35,149 70.13,147.22 86.26,147.22 87.58,145.9 90.79,145.9 91.09,145.59 91.09,145.47 90.45,144.83 90.45,144.47 90.87,144.06 91.23,144.06 91.87,144.7 91.99,144.7 92.24,144.44 92.24,144.32 91.6,143.68 91.6,143.32 92.02,142.91 92.38,142.91 93.02,143.55 93.14,143.55 93.39,143.3 93.39,143.17 92.75,142.53 92.75,142.17 93.17,141.76 93.53,141.76 94.17,142.4 94.29,142.4 94.54,142.15 94.54,142.02 93.9,141.38 93.9,141.02 94.32,140.61 94.67,140.61 95.32,141.25 95.44,141.25 95.69,141 95.69,140.87 95.05,140.23 95.05,139.87 95.31,139.61 95.98,139.61 96.46,140.1 96.59,140.1 97.11,139.58 102.62,139.58 105.92,136.28 108.55,136.28 115.21,129.62 115.21,125.31 116.41,124.11 116.41,110.61 116.19,110.38 116.19,108.16 116.66,107.68 116.66,106.19 114.02,103.55 114.02,101.46 112.44,99.88 112.44,92.09 110.6,90.25 110.6,89.34
FMCP_HSPC_LA20_P: length 162.3
  TOP w0.104: U1.N32 v2(107.24,74.84) ; J22.G21 v1(81.53,165.86)
  16_SIG5 w0.076: v2(107.24,74.84) 106.91,74.84 106.84,74.92 106.84,75.08 107,75.24 110.53,75.24 110.84,75.55 110.84,82.6 110.82,82.62 110.82,84.54 110.85,84.57 110.85,86.14 110.84,86.16 110.84,87.62 110.82,87.64 110.82,89.06 110.84,89.07 110.84,89.28 110.88,89.32 110.88,89.34
  16_SIG5 w0.089: 110.88,89.34 110.88,90.13 112.72,91.98 112.72,99.76 114.3,101.34 114.3,103.44 116.94,106.08 116.94,107.8 116.47,108.27 116.47,110.27 116.69,110.49 116.69,124.23 115.49,125.43 115.49,129.73 108.66,136.56 106.03,136.56 102.74,139.86 97.23,139.86 96.71,140.38 96.35,140.38 95.86,139.89 95.43,139.89 95.33,139.99 95.33,140.11 95.97,140.75 95.97,141.11 95.56,141.53 95.2,141.53 94.56,140.89 94.43,140.89 94.18,141.14 94.18,141.26 94.82,141.9 94.82,142.26 94.41,142.68 94.05,142.68 93.41,142.04 93.28,142.04 93.03,142.29 93.03,142.41 93.67,143.05 93.67,143.41 93.26,143.83 92.9,143.83 92.26,143.19 92.13,143.19 91.88,143.44 91.88,143.56 92.52,144.2 92.52,144.56 92.11,144.98 91.75,144.98 91.11,144.34 90.98,144.34 90.73,144.59 90.73,144.71 91.37,145.35 91.37,145.71 90.91,146.18 87.69,146.18 86.37,147.5 70.25,147.5 68.63,149.12 68.63,152.55 65.8,155.38 65.8,158.45 66.09,158.74 80.64,158.74 81.04,159.14 81.04,165.66 81.24,165.86 v1(81.53,165.86)
FMCP_HSPC_LA21_N: length 158.9
  TOP w0.104: U1.L35 v2(105.24,77.84) ; J22.H26 v1(75.18,167.13)
  16_SIG5 w0.076: v2(105.24,77.84) 105.56,77.84 105.64,77.92 105.64,78.11 105.97,78.44 107.4,78.44 107.64,78.68 107.64,84.42 107.62,84.44 107.62,86.15 107.64,86.17 107.64,87.65 107.66,87.67 107.66,89.32 107.62,89.36 107.62,89.38
  16_SIG5 w0.089: v1(75.18,167.13) 75.44,167.39 75.57,167.39 75.68,167.28 75.68,163.1 75.41,162.83 62.13,162.83 61.71,162.41 61.71,155.05 61.34,154.69 61.34,152.28 62.9,150.73 63.84,150.73 65.33,149.24 65.33,146.44 69.03,142.74 70.52,142.74 70.78,143 70.78,144.15 70.86,144.24 71.22,144.24 71.31,144.15 71.31,143 71.56,142.74 72.15,142.74 72.4,143 72.4,144.15 72.49,144.24 72.85,144.24 72.93,144.15 72.93,143 73.19,142.74 73.77,142.74 74.03,143 74.03,144.15 74.12,144.24 74.47,144.24 74.56,144.15 74.56,143 74.81,142.74 75.4,142.74 75.65,143 75.65,144.15 75.74,144.24 76.1,144.24 76.19,144.15 76.19,143 76.44,142.74 86.43,142.74 92.52,136.65 97.69,136.65 98.87,135.46 100.68,135.46 101.37,134.77 103.42,134.77 104.57,133.63 107.17,133.63 111.91,128.89 111.91,124.14 112.77,123.28 112.77,108.98 111.84,108.04 111.84,105.28 109.45,102.89 109.45,101.22 107.84,99.61 107.84,91.76 107.62,91.54 107.62,89.38
FMCP_HSPC_LA21_P: length 158.3
  TOP w0.104: U1.M35 v2(106.24,77.84) ; J22.H25 v1(76.45,167.13)
  16_SIG5 w0.076: 107.9,89.38 107.9,89.36 107.85,89.32 107.85,87.59 107.84,87.57 107.84,86.09 107.82,86.07 107.82,84.52 107.84,84.5 107.84,78.59 107.49,78.24 106.05,78.24 105.84,78.03 105.84,77.92 105.91,77.84 v2(106.24,77.84)
  16_SIG5 w0.089: 107.9,89.38 107.9,91.43 108.12,91.65 108.12,99.49 109.73,101.1 109.73,102.78 112.12,105.17 112.12,107.93 113.05,108.86 113.05,123.4 112.19,124.26 112.19,129.01 107.29,133.91 104.68,133.91 103.54,135.05 101.49,135.05 100.79,135.74 98.99,135.74 97.8,136.93 92.64,136.93 86.54,143.02 76.55,143.02 76.46,143.11 76.46,144.27 76.21,144.52 75.63,144.52 75.37,144.27 75.37,143.11 75.28,143.02 74.93,143.02 74.84,143.11 74.84,144.27 74.59,144.52 74,144.52 73.75,144.27 73.75,143.11 73.66,143.02 73.3,143.02 73.21,143.11 73.21,144.27 72.96,144.52 72.37,144.52 72.12,144.27 72.12,143.11 72.03,143.02 71.68,143.02 71.59,143.11 71.59,144.27 71.34,144.52 70.75,144.52 70.5,144.27 70.5,143.11 70.41,143.02 69.14,143.02 65.61,146.56 65.61,149.35 63.95,151.01 63.01,151.01 61.62,152.4 61.62,154.57 61.99,154.94 61.99,162.29 62.24,162.55 75.53,162.55 75.96,162.98 75.96,166.64 v1(76.45,167.13)
FMCP_HSPC_LA22_N: length 158.8
  TOP w0.104: U1.N35 v2(107.24,77.84) ; J22.G25 v1(76.45,165.86)
  16_SIG5 w0.076: v2(107.24,77.84) 107.24,77.75 107.54,77.44 108.5,77.44 108.64,77.58 108.64,84.63 108.66,84.65 108.66,86.06 108.64,86.07 108.64,87.52 108.62,87.54 108.62,89.33 108.58,89.37 108.58,89.39
  16_SIG5 w0.089: 108.58,89.39 108.58,91.1 108.81,91.34 108.81,92.91 109.11,93.21 109.77,93.21 109.9,93.35 109.9,93.88 109.77,94.02 109.11,94.02 108.81,94.32 108.81,97.09 109.5,97.78 109.5,99.88 110.94,101.32 110.94,103.12 113.28,105.46 113.28,107.83 113.7,108.26 113.7,123.67 112.8,124.57 112.8,129.36 107.66,134.51 105.07,134.51 103.86,135.71 102.65,135.71 101.88,136.48 99.65,136.48 98.52,137.61 92.88,137.61 85.05,145.44 83.57,145.44 83.49,145.35 83.49,144.09 83.23,143.84 82.65,143.84 82.39,144.09 82.39,145.35 82.3,145.44 81.95,145.44 81.86,145.35 81.86,144.09 81.61,143.84 81.02,143.84 80.77,144.09 80.77,145.35 80.68,145.44 80.32,145.44 80.23,145.35 80.23,144.09 79.98,143.84 79.39,143.84 79.14,144.09 79.14,145.35 79.05,145.44 78.7,145.44 78.61,145.35 78.61,144.09 78.36,143.84 77.77,143.84 77.52,144.09 77.52,145.35 77.43,145.44 68.19,145.44 66.32,147.31 66.32,149.86 63.62,152.56 63.02,152.56 62.59,153 62.59,154.09 62.98,154.48 62.98,161.14 63.4,161.56 76.71,161.56 76.95,161.8 76.95,165.37 v1(76.45,165.86)
FMCP_HSPC_LA22_P: length 159.5
  TOP w0.104: J22.G24 v1(77.72,165.86) ; U1.N34 v2(107.24,76.84)
  16_SIG5 w0.076: v2(107.24,76.84) 107.24,77.17 107.31,77.24 108.58,77.24 108.84,77.5 108.84,84.55 108.85,84.56 108.85,86.14 108.84,86.16 108.84,87.6 108.82,87.62 108.82,89.33 108.86,89.37 108.86,89.39
  16_SIG5 w0.089: v1(77.72,165.86) 77.32,165.86 77.23,165.78 77.23,161.68 76.82,161.28 63.51,161.28 63.26,161.02 63.26,154.37 62.87,153.97 62.87,153.12 63.14,152.84 63.74,152.84 66.6,149.98 66.6,147.43 68.31,145.72 77.54,145.72 77.8,145.47 77.8,144.21 77.89,144.12 78.24,144.12 78.33,144.21 78.33,145.47 78.58,145.72 79.17,145.72 79.42,145.47 79.42,144.21 79.51,144.12 79.87,144.12 79.96,144.21 79.96,145.47 80.21,145.72 80.79,145.72 81.05,145.47 81.05,144.21 81.14,144.12 81.49,144.12 81.58,144.21 81.58,145.47 81.83,145.72 82.42,145.72 82.67,145.47 82.67,144.21 82.76,144.12 83.12,144.12 83.21,144.21 83.21,145.47 83.46,145.72 85.17,145.72 92.99,137.89 98.63,137.89 99.76,136.76 102,136.76 102.77,135.99 103.98,135.99 105.18,134.79 107.77,134.79 113.08,129.48 113.08,124.69 113.98,123.79 113.98,108.14 113.56,107.72 113.56,105.35 111.22,103 111.22,101.21 109.78,99.77 109.78,97.66 109.09,96.98 109.09,94.43 109.23,94.3 109.88,94.3 110.18,94 110.18,93.23 109.88,92.93 109.23,92.93 109.09,92.8 109.09,91.22 108.86,90.99 108.86,89.39
FMCP_HSPC_LA23_N: length 163.1
  TOP w0.104: J22.D24 v1(77.72,162.05) ; v2(113.24,74.84) U1.W32
  14_SIG4 w0.076: 120.76,90.76 120.75,90.75 120.69,90.75 120.4,90.46 120.1,90.46 118.77,89.12 118.77,74.87 118.14,74.24 113.97,74.24 113.64,74.58 113.64,74.77 113.56,74.84 v2(113.24,74.84)
  14_SIG4 w0.089: 120.76,90.76 123.4,93.4 128.83,98.83 128.83,107.43 129.98,108.58 129.98,112.61 129.16,113.43 129.16,121.46 130,122.31 130,125.34 129.73,125.61 128.84,125.61 128.74,125.72 128.74,126.14 128.84,126.24 129.73,126.24 130,126.52 130,127.19 129.73,127.46 128.84,127.46 128.74,127.56 128.74,127.99 128.84,128.09 129.73,128.09 130,128.36 130,129.12 129.23,129.89 129.23,130.43 128.88,130.77 128.88,133.35 129.89,134.36 129.89,142.95 125.59,147.25 120.02,147.25 115.6,151.66 113.44,151.66 113.35,151.75 113.35,152.53 113.1,152.78 112.6,152.78 112.35,152.53 112.35,151.75 112.26,151.66 111.99,151.66 111.91,151.75 111.91,152.53 111.65,152.78 111.15,152.78 110.9,152.53 110.9,151.75 110.81,151.66 110.55,151.66 110.46,151.75 110.46,152.53 110.21,152.78 109.71,152.78 109.45,152.53 109.45,151.75 109.37,151.66 109.1,151.66 109.01,151.75 109.01,152.53 108.76,152.78 108.26,152.78 108.01,152.53 108.01,151.75 107.92,151.66 107.65,151.66 107.56,151.75 107.56,152.53 107.31,152.78 106.81,152.78 106.56,152.53 106.56,151.75 106.47,151.66 106.2,151.66 106.11,151.75 106.11,152.53 105.86,152.78 105.36,152.78 105.11,152.53 105.11,151.75 105.02,151.66 85.94,151.66 83.58,154.03 83.58,162.38 83.12,162.83 78.5,162.83 v1(77.72,162.05)
