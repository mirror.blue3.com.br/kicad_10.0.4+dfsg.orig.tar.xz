# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Nets (continued)
DDR4_C2_A5: R917.2 U1.AM28(IO_L22P_T3U_N6_DBC_AD0P_41_AM28) U135.P8(A5) U136.P8(A5) U137.P8(A5) U138.P8(A5) U139.P8(A5)
DDR4_C2_A6: R906.2 U1.AP28(IO_L21N_T3L_N5_AD8N_41_AP28) U135.P2(A6) U136.P2(A6) U137.P2(A6) U138.P2(A6) U139.P2(A6)
DDR4_C2_A7: R905.2 U1.AP27(IO_L21P_T3L_N4_AD8P_41_AP27) U135.R8(A7) U136.R8(A7) U137.R8(A7) U138.R8(A7) U139.R8(A7)
DDR4_C2_A8: R910.2 U1.AN26(IO_L20N_T3L_N3_AD1N_41_AN26) U135.R2(A8) U136.R2(A8) U137.R2(A8) U138.R2(A8) U139.R2(A8)
DDR4_C2_A9: R909.2 U1.AM26(IO_L20P_T3L_N2_AD1P_41_AM26) U135.R7(A9) U136.R7(A9) U137.R7(A9) U138.R7(A9) U139.R7(A9)
DDR4_C2_A10: R908.2 U1.AR28(IO_L19N_T3L_N1_DBC_AD9N_41_AR28) U135.M3(A10/AP) U136.M3(A10/AP) U137.M3(A10/AP) U138.M3(A10/AP) U139.M3(A10/AP)
DDR4_C2_A11: R907.2 U1.AR27(IO_L19P_T3L_N0_DBC_AD9P_41_AR27) U135.T2(A11) U136.T2(A11) U137.T2(A11) U138.T2(A11) U139.T2(A11)
DDR4_C2_A12: R912.2 U1.AV25(IO_T2U_N12_41_AV25) U135.M7(A12/BC_B) U136.M7(A12/BC_B) U137.M7(A12/BC_B) U138.M7(A12/BC_B) U139.M7(A12/BC_B)
DDR4_C2_A13: R920.2 U1.AT25(IO_L18N_T2U_N11_AD2N_41_AT25) U135.T8(A13) U136.T8(A13) U137.T8(A13) U138.T8(A13) U139.T8(A13)
DDR4_C2_A14_WE_B: R913.2 U1.AV28(IO_L15P_T2L_N4_AD11P_41_AV28) U135.L2(WE_B/A14) U136.L2(WE_B/A14) U137.L2(WE_B/A14) U138.L2(WE_B/A14) U139.L2(WE_B/A14)
DDR4_C2_A15_CAS_B: R914.2 U1.AU26(IO_L14P_T2L_N2_GC_41_AU26) U135.M8(CAS_B/A15) U136.M8(CAS_B/A15) U137.M8(CAS_B/A15) U138.M8(CAS_B/A15) U139.M8(CAS_B/A15)
DDR4_C2_A16_RAS_B: R923.2 U1.AV26(IO_L14N_T2L_N3_GC_41_AV26) U135.L8(RAS_B/A16) U136.L8(RAS_B/A16) U137.L8(RAS_B/A16) U138.L8(RAS_B/A16) U139.L8(RAS_B/A16)
DDR4_C2_ACT_B: R924.2 U1.AN25(IO_T3U_N12_41_AN25) U135.L3(ACT_B) U136.L3(ACT_B) U137.L3(ACT_B) U138.L3(ACT_B) U139.L3(ACT_B)
DDR4_C2_ALERT_B: R922.2 U1.AR29(IO_T3U_N12_40_AR29) U135.P9(ALERT_B) U136.P9(ALERT_B) U137.P9(ALERT_B) U138.P9(ALERT_B) U139.P9(ALERT_B)
DDR4_C2_BA0: R902.2 U1.AR25(IO_L18P_T2U_N10_AD2P_41_AR25) U135.N2(BA0) U136.N2(BA0) U137.N2(BA0) U138.N2(BA0) U139.N2(BA0)
DDR4_C2_BA1: R921.2 U1.AU28(IO_L17N_T2U_N9_AD10N_41_AU28) U135.N8(BA1) U136.N8(BA1) U137.N8(BA1) U138.N8(BA1) U139.N8(BA1)
DDR4_C2_BG0: R911.2 U1.AU27(IO_L17P_T2U_N8_AD10P_41_AU27) U135.M2(BG0) U136.M2(BG0) U137.M2(BG0) U138.M2(BG0) U139.M2(BG0)
DDR4_C2_CK_C: R898.1 U1.AT27(IO_L16N_T2U_N7_QBC_AD3N_41_AT27) U135.K8(CK_C) U136.K8(CK_C) U137.K8(CK_C) U138.K8(CK_C) U139.K8(CK_C)
DDR4_C2_CK_T: R897.1 U1.AT26(IO_L16P_T2U_N6_QBC_AD3P_41_AT26) U135.K7(CK_T) U136.K7(CK_T) U137.K7(CK_T) U138.K7(CK_T) U139.K7(CK_T)
DDR4_C2_CKE: R915.2 U1.AW28(IO_L15N_T2L_N5_AD11N_41_AW28) U135.K2(CKE) U136.K2(CKE) U137.K2(CKE) U138.K2(CKE) U139.K2(CKE)
DDR4_C2_CS_B: R1106.2 U1.AY29(IO_T1U_N12_41_AY29) U135.L7(CS_B) U136.L7(CS_B) U137.L7(CS_B) U138.L7(CS_B) U139.L7(CS_B)
DDR4_C2_DM0: U1.BE32(IO_L1P_T0L_N0_DBC_40_BE32) U135.E7(DML_B/DBIL_B)
DDR4_C2_DM1: U1.BB31(IO_L7P_T1L_N0_QBC_AD13P_40_BB31) U135.E2(DMU_B/DBIU_B)
DDR4_C2_DM2: U1.AV33(IO_L13P_T2L_N0_GC_QBC_40_AV33) U136.E7(DML_B/DBIL_B)
DDR4_C2_DM3: U1.AR32(IO_L19P_T3L_N0_DBC_AD9P_40_AR32) U136.E2(DMU_B/DBIU_B)
DDR4_C2_DM4: U1.BC34(IO_L1P_T0L_N0_DBC_42_BC34) U137.E7(DML_B/DBIL_B)
DDR4_C2_DM5: U1.BE40(IO_L7P_T1L_N0_QBC_AD13P_42_BE40) U137.E2(DMU_B/DBIU_B)
DDR4_C2_DM6: U1.AY37(IO_L13P_T2L_N0_GC_QBC_42_AY37) U138.E7(DML_B/DBIL_B)
DDR4_C2_DM7: U1.AV35(IO_L19P_T3L_N0_DBC_AD9P_42_AV35) U138.E2(DMU_B/DBIU_B)
DDR4_C2_DM8: U1.BE29(IO_L1P_T0L_N0_DBC_41_BE29) U139.E7(DML_B/DBIL_B)
DDR4_C2_DM9: U1.BA29(IO_L7P_T1L_N0_QBC_AD13P_41_BA29) U139.E2(DMU_B/DBIU_B)
DDR4_C2_DQ0: U1.BD30(IO_L2P_T0L_N2_40_BD30) U135.G2(DQL0)
DDR4_C2_DQ1: U1.BE30(IO_L2N_T0L_N3_40_BE30) U135.F7(DQL1)
DDR4_C2_DQ2: U1.BD32(IO_L3P_T0L_N4_AD15P_40_BD32) U135.H3(DQL2)
DDR4_C2_DQ3: U1.BE33(IO_L3N_T0L_N5_AD15N_40_BE33) U135.H7(DQL3)
DDR4_C2_DQ4: U1.BC33(IO_L5P_T0U_N8_AD14P_40_BC33) U135.H2(DQL4)
DDR4_C2_DQ5: U1.BD33(IO_L5N_T0U_N9_AD14N_40_BD33) U135.H8(DQL5)
DDR4_C2_DQ6: U1.BC31(IO_L6P_T0U_N10_AD6P_40_BC31) U135.J3(DQL6)
DDR4_C2_DQ7: U1.BD31(IO_L6N_T0U_N11_AD6N_40_BD31) U135.J7(DQL7)
DDR4_C2_DQ8: U1.BA32(IO_L8P_T1L_N2_AD5P_40_BA32) U135.A3(DQU0)
DDR4_C2_DQ9: U1.BB33(IO_L8N_T1L_N3_AD5N_40_BB33) U135.B8(DQU1)
DDR4_C2_DQ10: U1.BA30(IO_L9P_T1L_N4_AD12P_40_BA30) U135.C3(DQU2)
DDR4_C2_DQ11: U1.BA31(IO_L9N_T1L_N5_AD12N_40_BA31) U135.C7(DQU3)
DDR4_C2_DQ12: U1.AW31(IO_L11P_T1U_N8_GC_40_AW31) U135.C2(DQU4)
DDR4_C2_DQ13: U1.AW32(IO_L11N_T1U_N9_GC_40_AW32) U135.C8(DQU5)
DDR4_C2_DQ14: U1.AY32(IO_L12P_T1U_N10_GC_40_AY32) U135.D3(DQU6)
DDR4_C2_DQ15: U1.AY33(IO_L12N_T1U_N11_GC_40_AY33) U135.D7(DQU7)
DDR4_C2_DQ16: U1.AV30(IO_L14P_T2L_N2_GC_40_AV30) U136.G2(DQL0)
DDR4_C2_DQ17: U1.AW30(IO_L14N_T2L_N3_GC_40_AW30) U136.F7(DQL1)
DDR4_C2_DQ18: U1.AU33(IO_L15P_T2L_N4_AD11P_40_AU33) U136.H3(DQL2)
DDR4_C2_DQ19: U1.AU34(IO_L15N_T2L_N5_AD11N_40_AU34) U136.H7(DQL3)
DDR4_C2_DQ20: U1.AT31(IO_L17P_T2U_N8_AD10P_40_AT31) U136.H2(DQL4)
DDR4_C2_DQ21: U1.AU32(IO_L17N_T2U_N9_AD10N_40_AU32) U136.H8(DQL5)
DDR4_C2_DQ22: U1.AU31(IO_L18P_T2U_N10_AD2P_40_AU31) U136.J3(DQL6)
DDR4_C2_DQ23: U1.AV31(IO_L18N_T2U_N11_AD2N_40_AV31) U136.J7(DQL7)
DDR4_C2_DQ24: U1.AR33(IO_L20P_T3L_N2_AD1P_40_AR33) U136.A3(DQU0)
DDR4_C2_DQ25: U1.AT34(IO_L20N_T3L_N3_AD1N_40_AT34) U136.B8(DQU1)
DDR4_C2_DQ26: U1.AT29(IO_L21P_T3L_N4_AD8P_40_AT29) U136.C3(DQU2)
DDR4_C2_DQ27: U1.AT30(IO_L21N_T3L_N5_AD8N_40_AT30) U136.C7(DQU3)
DDR4_C2_DQ28: U1.AP30(IO_L23P_T3U_N8_40_AP30) U136.C2(DQU4)
DDR4_C2_DQ29: U1.AR30(IO_L23N_T3U_N9_40_AR30) U136.C8(DQU5)
DDR4_C2_DQ30: U1.AN30(IO_L24P_T3U_N10_40_AN30) U136.D3(DQU6)
DDR4_C2_DQ31: U1.AN31(IO_L24N_T3U_N11_40_AN31) U136.D7(DQU7)
DDR4_C2_DQ32: U1.BE34(IO_L2P_T0L_N2_42_BE34) U137.G2(DQL0)
DDR4_C2_DQ33: U1.BF34(IO_L2N_T0L_N3_42_BF34) U137.F7(DQL1)
DDR4_C2_DQ34: U1.BC35(IO_L3P_T0L_N4_AD15P_42_BC35) U137.H3(DQL2)
DDR4_C2_DQ35: U1.BC36(IO_L3N_T0L_N5_AD15N_42_BC36) U137.H7(DQL3)
DDR4_C2_DQ36: U1.BD36(IO_L5P_T0U_N8_AD14P_42_BD36) U137.H2(DQL4)
DDR4_C2_DQ37: U1.BE37(IO_L5N_T0U_N9_AD14N_42_BE37) U137.H8(DQL5)
DDR4_C2_DQ38: U1.BF36(IO_L6P_T0U_N10_AD6P_42_BF36) U137.J3(DQL6)
DDR4_C2_DQ39: U1.BF37(IO_L6N_T0U_N11_AD6N_42_BF37) U137.J7(DQL7)
DDR4_C2_DQ40: U1.BD37(IO_L8P_T1L_N2_AD5P_42_BD37) U137.A3(DQU0)
DDR4_C2_DQ41: U1.BE38(IO_L8N_T1L_N3_AD5N_42_BE38) U137.B8(DQU1)
DDR4_C2_DQ42: U1.BC39(IO_L9P_T1L_N4_AD12P_42_BC39) U137.C3(DQU2)
DDR4_C2_DQ43: U1.BD40(IO_L9N_T1L_N5_AD12N_42_BD40) U137.C7(DQU3)
DDR4_C2_DQ44: U1.BB38(IO_L11P_T1U_N8_GC_42_BB38) U137.C2(DQU4)
DDR4_C2_DQ45: U1.BB39(IO_L11N_T1U_N9_GC_42_BB39) U137.C8(DQU5)
DDR4_C2_DQ46: U1.BC38(IO_L12P_T1U_N10_GC_42_BC38) U137.D3(DQU6)
DDR4_C2_DQ47: U1.BD38(IO_L12N_T1U_N11_GC_42_BD38) U137.D7(DQU7)
DDR4_C2_DQ48: U1.BB36(IO_L14P_T2L_N2_GC_42_BB36) U138.G2(DQL0)
DDR4_C2_DQ49: U1.BB37(IO_L14N_T2L_N3_GC_42_BB37) U138.F7(DQL1)
DDR4_C2_DQ50: U1.BA39(IO_L15P_T2L_N4_AD11P_42_BA39) U138.H3(DQL2)
DDR4_C2_DQ51: U1.BA40(IO_L15N_T2L_N5_AD11N_42_BA40) U138.H7(DQL3)
DDR4_C2_DQ52: U1.AW40(IO_L17P_T2U_N8_AD10P_42_AW40) U138.H2(DQL4)
DDR4_C2_DQ53: U1.AY40(IO_L17N_T2U_N9_AD10N_42_AY40) U138.H8(DQL5)
DDR4_C2_DQ54: U1.AY38(IO_L18P_T2U_N10_AD2P_42_AY38) U138.J3(DQL6)
DDR4_C2_DQ55: U1.AY39(IO_L18N_T2U_N11_AD2N_42_AY39) U138.J7(DQL7)
DDR4_C2_DQ56: U1.AW35(IO_L20P_T3L_N2_AD1P_42_AW35) U138.A3(DQU0)
DDR4_C2_DQ57: U1.AW36(IO_L20N_T3L_N3_AD1N_42_AW36) U138.B8(DQU1)
DDR4_C2_DQ58: U1.AU40(IO_L21P_T3L_N4_AD8P_42_AU40) U138.C3(DQU2)
DDR4_C2_DQ59: U1.AV40(IO_L21N_T3L_N5_AD8N_42_AV40) U138.C7(DQU3)
DDR4_C2_DQ60: U1.AU38(IO_L23P_T3U_N8_42_AU38) U138.C2(DQU4)
DDR4_C2_DQ61: U1.AU39(IO_L23N_T3U_N9_42_AU39) U138.C8(DQU5)
DDR4_C2_DQ62: U1.AV38(IO_L24P_T3U_N10_42_AV38) U138.D3(DQU6)
DDR4_C2_DQ63: U1.AV39(IO_L24N_T3U_N11_42_AV39) U138.D7(DQU7)
DDR4_C2_DQ64: U1.BF26(IO_L2P_T0L_N2_41_BF26) U139.G2(DQL0)
DDR4_C2_DQ65: U1.BF27(IO_L2N_T0L_N3_41_BF27) U139.F7(DQL1)
DDR4_C2_DQ66: U1.BD28(IO_L3P_T0L_N4_AD15P_41_BD28) U139.H3(DQL2)
DDR4_C2_DQ67: U1.BE28(IO_L3N_T0L_N5_AD15N_41_BE28) U139.H7(DQL3)
DDR4_C2_DQ68: U1.BD27(IO_L5P_T0U_N8_AD14P_41_BD27) U139.H2(DQL4)
DDR4_C2_DQ69: U1.BE27(IO_L5N_T0U_N9_AD14N_41_BE27) U139.H8(DQL5)
DDR4_C2_DQ70: U1.BD25(IO_L6P_T0U_N10_AD6P_41_BD25) U139.J3(DQL6)
DDR4_C2_DQ71: U1.BD26(IO_L6N_T0U_N11_AD6N_41_BD26) U139.J7(DQL7)
DDR4_C2_DQ72: U1.BC25(IO_L8P_T1L_N2_AD5P_41_BC25) U139.A3(DQU0)
DDR4_C2_DQ73: U1.BC26(IO_L8N_T1L_N3_AD5N_41_BC26) U139.B8(DQU1)
DDR4_C2_DQ74: U1.BB28(IO_L9P_T1L_N4_AD12P_41_BB28) U139.C3(DQU2)
DDR4_C2_DQ75: U1.BC28(IO_L9N_T1L_N5_AD12N_41_BC28) U139.C7(DQU3)
DDR4_C2_DQ76: U1.AY27(IO_L11P_T1U_N8_GC_41_AY27) U139.C2(DQU4)
DDR4_C2_DQ77: U1.AY28(IO_L11N_T1U_N9_GC_41_AY28) U139.C8(DQU5)
DDR4_C2_DQ78: U1.BA27(IO_L12P_T1U_N10_GC_41_BA27) U139.D3(DQU6)
DDR4_C2_DQ79: U1.BB27(IO_L12N_T1U_N11_GC_41_BB27) U139.D7(DQU7)
DDR4_C2_DQS0_C: U1.BF31(IO_L4N_T0U_N7_DBC_AD7N_40_BF31) U135.F3(DQSL_C)
DDR4_C2_DQS0_T: U1.BF30(IO_L4P_T0U_N6_DBC_AD7P_40_BF30) U135.G3(DQSL_T)
DDR4_C2_DQS1_C: U1.BA34(IO_L10N_T1U_N7_QBC_AD4N_40_BA34) U135.A7(DQSU_C)
DDR4_C2_DQS1_T: U1.AY34(IO_L10P_T1U_N6_QBC_AD4P_40_AY34) U135.B7(DQSU_T)
DDR4_C2_DQS2_C: U1.AV29(IO_L16N_T2U_N7_QBC_AD3N_40_AV29) U136.F3(DQSL_C)
DDR4_C2_DQS2_T: U1.AU29(IO_L16P_T2U_N6_QBC_AD3P_40_AU29) U136.G3(DQSL_T)
DDR4_C2_DQS3_C: U1.AP32(IO_L22N_T3U_N7_DBC_AD0N_40_AP32) U136.A7(DQSU_C)
DDR4_C2_DQS3_T: U1.AP31(IO_L22P_T3U_N6_DBC_AD0P_40_AP31) U136.B7(DQSU_T)
DDR4_C2_DQS4_C: U1.BF35(IO_L4N_T0U_N7_DBC_AD7N_42_BF35) U137.F3(DQSL_C)
DDR4_C2_DQS4_T: U1.BE35(IO_L4P_T0U_N6_DBC_AD7P_42_BE35) U137.G3(DQSL_T)
DDR4_C2_DQS5_C: U1.BF39(IO_L10N_T1U_N7_QBC_AD4N_42_BF39) U137.A7(DQSU_C)
DDR4_C2_DQS5_T: U1.BE39(IO_L10P_T1U_N6_QBC_AD4P_42_BE39) U137.B7(DQSU_T)
DDR4_C2_DQS6_C: U1.BA36(IO_L16N_T2U_N7_QBC_AD3N_42_BA36) U138.F3(DQSL_C)
DDR4_C2_DQS6_T: U1.BA35(IO_L16P_T2U_N6_QBC_AD3P_42_BA35) U138.G3(DQSL_T)
DDR4_C2_DQS7_C: U1.AW38(IO_L22N_T3U_N7_DBC_AD0N_42_AW38) U138.A7(DQSU_C)
DDR4_C2_DQS7_T: U1.AW37(IO_L22P_T3U_N6_DBC_AD0P_42_AW37) U138.B7(DQSU_T)
DDR4_C2_DQS8_C: U1.BF25(IO_L4N_T0U_N7_DBC_AD7N_41_BF25) U139.F3(DQSL_C)
DDR4_C2_DQS8_T: U1.BE25(IO_L4P_T0U_N6_DBC_AD7P_41_BE25) U139.G3(DQSL_T)
DDR4_C2_DQS9_C: U1.BB26(IO_L10N_T1U_N7_QBC_AD4N_41_BB26) U139.A7(DQSU_C)
DDR4_C2_DQS9_T: U1.BA26(IO_L10P_T1U_N6_QBC_AD4P_41_BA26) U139.B7(DQSU_T)
DDR4_C2_ODT: R926.2 U1.BB29(IO_L7N_T1L_N1_QBC_AD13N_41_BB29) U135.K3(ODT) U136.K3(ODT) U137.K3(ODT) U138.K3(ODT) U139.K3(ODT)
DDR4_C2_PAR: R925.2 U1.BF29(IO_L1N_T0L_N1_DBC_41_BF29) U135.T3(PAR) U136.T3(PAR) U137.T3(PAR) U138.T3(PAR) U139.T3(PAR)
DDR4_C2_REFIN: C1208.1(CAP2) R900.2 R901.1 U134.1(REFIN)
DDR4_C2_RESET_B: R896.1 U1.BD35(IO_L1N_T0L_N1_DBC_42_BD35) U135.P1(RESET_B) U136.P1(RESET_B) U137.P1(RESET_B) U138.P1(RESET_B) U139.P1(RESET_B)
DDR4_C2_TEN: R899.1 U1.AY35(IO_T2U_N12_42_AY35) U135.N9(TEN) U136.N9(TEN) U137.N9(TEN) U138.N9(TEN) U139.N9(TEN)
DDR4_C2_VREFA: C1144.1(CAP2) R935.2 R936.1 U135.M1(VREFCA)
DDR4_C2_VREFB: C1147.1(CAP2) R937.2 R938.1 U136.M1(VREFCA)
DDR4_C2_VREFC: C1150.1(CAP2) R939.2 R940.1 U137.M1(VREFCA)
DDR4_C2_VREFD: C1153.1(CAP2) R941.2 R942.1 U138.M1(VREFCA)
DDR4_C2_VREFE: C1162.1(CAP2) R943.2 R944.1 U139.M1(VREFCA)
DDR4_C2_VTERM_0V60_PGOOD: Q37.1(GATE) R929.2 U134.9(PGOOD)
DDR4_C2_VTERM_EN: R928.2 U134.7(EN)
DDR4_C2_VTERM_REFOUT: C1142.1(CAP2) U134.6(REFOUT)
DDR4_C2_VTT: C1155.1(CAP2) C1156.1(CAP2) C1157.1(CAP2) C1158.1(CAP2) C1159.1(CAP2) C1179.1(CAP2) C1180.1(CAP2) C1181.1(CAP2) C1183.1(CAP2) C1184.1(CAP2) C1185.1(CAP2) J88.1(P1) R902.1 R903.1 R904.1 R905.1 R906.1 R907.1 R908.1 R909.1 R910.1 R911.1 R912.1 R913.1 R914.1 R915.1 R916.1 R917.1 R918.1 R919.1 R920.1 R921.1 R922.1 R923.1 R924.1 R925.1 R926.1 R1106.1 U134.3(VO) Z86.1(NET1)
DDR4_C2_ZQA: R930.1 U135.F9(ZQ)
DDR4_C2_ZQB: R931.1 U136.F9(ZQ)
DDR4_C2_ZQC: R932.1 U137.F9(ZQ)
DDR4_C2_ZQD: R933.1 U138.F9(ZQ)
DDR4_C2_ZQE: R7.1 U139.F9(ZQ)
DXN: C240.2(CAP1) U1.AE17(DXN_AE17) Z8.1(NET1)
DXP: C240.1(CAP2) U1.AE18(DXP_AE18) U31.8(DXP1)
ENET_LED_0: Q18.1(GATE) R54.2 R62.1 R198.2 R200.1 U7.47(LED_0)
ENET_LED_0_LS: DS1.1 Q18.3(DRAIN)
ENET_LED_1: Q60.1(GATE) R55.2 R63.1 R201.2 R202.1 U7.46(LED_1)
ENET_LED_1_LS: J10.13(RIGHT_GREEN_CA) Q60.3(DRAIN)
ENET_LED_2: Q59.1(GATE) R56.2 R64.1 R203.2 R204.1 U7.45(LED_2)
ENET_LED_2_LS: J10.15(LEFT_GREEN_CA) Q59.3(DRAIN)
ENET_TD_A_N: J10.10(TD0_N) U7.2(TD_M_A)
ENET_TD_A_P: J10.11(TD0_P) U7.1(TD_P_A)
ENET_TD_B_N: J10.5(TD1_N) U7.5(TD_M_B)
ENET_TD_B_P: J10.4(TD1_P) U7.4(TD_P_B)
ENET_TD_C_N: J10.2(TD2_N) U7.8(TD_M_C)
ENET_TD_C_P: J10.3(TD2_P) U7.7(TD_P_C)
ENET_TD_D_N: J10.9(TD3_N) U7.11(TD_M_D)
ENET_TD_D_P: J10.8(TD3_P) U7.10(TD_P_D)
ENET_XI: C144.1(CAP2) R84.1 U7.15(XI) X2.1(X1)
ENET_XO: C143.1(CAP2) R84.2 U7.14(XO) X2.3(X2)
FAN_FAIL_B: Q22.3(DRAIN) R192.2 U31.4(FANFAIL_B)
FAN_FAIL_LS_B: Q22.2(SOURCE) R210.2 U1.AW33(IO_L13N_T2L_N1_GC_QBC_40_AW33)
FAN_OT_B: Q28.3(DRAIN) R107.2 U31.9(OT_B)
FAN_OT_LS_B: Q28.2(SOURCE) R219.2 U1.BC40(IO_T1U_N12_42_BC40)
FAN_PWR_B: J73.1(P1) Q61.3(DRAIN)
FIREFLY_INT_B: J6.5(INTL) U22.9(A2)
FIREFLY_INT_LS_B: U1.BF24(IO_L1N_T0L_N1_DBC_64_BF24) U22.4(B2)
FIREFLY_MODPRS_B: J6.3(MODPRS) U22.8(A1)
FIREFLY_MODPRS_LS_B: U1.BD22(IO_L2N_T0L_N3_64_BD22) U22.5(B1)
FIREFLY_MODSEL_B: J6.4(MODSEL) U33.8(A1)
FIREFLY_MODSEL_LS_B: U1.BC23(IO_L2P_T0L_N2_64_BC23) U33.5(B1)
FIREFLY_RESET_B: J6.6(RESETL) U33.9(A2)
FIREFLY_RESET_LS_B: U1.BE24(IO_L1P_T0L_N0_DBC_64_BE24) U33.4(B2)
FIREFLY_RX1_N: J6.B18(RX1N) U1.K1(MGTYRXN0_233_K1)
FIREFLY_RX1_P: J6.B17(RX1P) U1.K2(MGTYRXP0_233_K2)
FIREFLY_RX2_N: J6.A18(RX2N) U1.H1(MGTYRXN1_233_H1)
FIREFLY_RX2_P: J6.A17(RX2P) U1.H2(MGTYRXP1_233_H2)
FIREFLY_RX3_N: J6.B15(RX3N) U1.F1(MGTYRXN2_233_F1)
FIREFLY_RX3_P: J6.B14(RX3P) U1.F2(MGTYRXP2_233_F2)
FIREFLY_RX4_N: J6.A15(RX4N) U1.D1(MGTYRXN3_233_D1)
FIREFLY_RX4_P: J6.A14(RX4P) U1.D2(MGTYRXP3_233_D2)
FIREFLY_SCL: J6.8(SCL) R94.2 U28.20(SC7)
FIREFLY_SDA: J6.7(SDA) R93.2 U28.19(SD7)
FIREFLY_TX1_N: J6.A2(TX1N) U1.G4(MGTYTXN0_233_G4)
FIREFLY_TX1_P: J6.A3(TX1P) U1.G5(MGTYTXP0_233_G5)
FIREFLY_TX2_N: J6.B2(TX2N) U1.F6(MGTYTXN1_233_F6)
FIREFLY_TX2_P: J6.B3(TX2P) U1.F7(MGTYTXP1_233_F7)
FIREFLY_TX3_N: J6.A5(TX3N) U1.E4(MGTYTXN2_233_E4)
FIREFLY_TX3_P: J6.A6(TX3P) U1.E5(MGTYTXP2_233_E5)
FIREFLY_TX4_N: J6.B5(TX4N) U1.C4(MGTYTXN3_233_C4)
FIREFLY_TX4_P: J6.B6(TX4P) U1.C5(MGTYTXP3_233_C5)
FMC_HPC1_CLK0_M2C_N: J2.H5(CLK0_M2C_N) U1.BC8(IO_L12N_T1U_N11_GC_66_BC8)
FMC_HPC1_CLK0_M2C_P: J2.H4(CLK0_M2C_P) U1.BC9(IO_L12P_T1U_N10_GC_66_BC9)
FMC_HPC1_CLK1_M2C_N: J2.G3(CLK1_M2C_N) U1.AV13(IO_L12N_T1U_N11_GC_67_AV13)
FMC_HPC1_CLK1_M2C_P: J2.G2(CLK1_M2C_P) U1.AV14(IO_L12P_T1U_N10_GC_67_AV14)
FMC_HPC1_IIC_SCL: J2.C30(SCL) R626.2 U80.9(SC2)
FMC_HPC1_IIC_SDA: J2.C31(SDA) R625.2 U80.8(SD2)
FMC_HPC1_LA00_CC_N: J2.G7(LA00_N_CC) U1.BA9(IO_L13N_T2L_N1_GC_QBC_66_BA9)
FMC_HPC1_LA00_CC_P: J2.G6(LA00_P_CC) U1.AY9(IO_L13P_T2L_N0_GC_QBC_66_AY9)
FMC_HPC1_LA01_CC_N: J2.D9(LA01_N_CC) U1.BF9(IO_L10N_T1U_N7_QBC_AD4N_66_BF9)
FMC_HPC1_LA01_CC_P: J2.D8(LA01_P_CC) U1.BF10(IO_L10P_T1U_N6_QBC_AD4P_66_BF10)
FMC_HPC1_LA02_N: J2.H8(LA02_N) U1.BD11(IO_L3N_T0L_N5_AD15N_66_BD11)
FMC_HPC1_LA02_P: J2.H7(LA02_P) U1.BC11(IO_L3P_T0L_N4_AD15P_66_BC11)
FMC_HPC1_LA03_N: J2.G10(LA03_N) U1.BE12(IO_L1N_T0L_N1_DBC_66_BE12)
FMC_HPC1_LA03_P: J2.G9(LA03_P) U1.BD12(IO_L1P_T0L_N0_DBC_66_BD12)
FMC_HPC1_LA04_N: J2.H11(LA04_N) U1.BF11(IO_L2N_T0L_N3_66_BF11)
FMC_HPC1_LA04_P: J2.H10(LA04_P) U1.BF12(IO_L2P_T0L_N2_66_BF12)
FMC_HPC1_LA05_N: J2.D12(LA05_N) U1.BF14(IO_L5N_T0U_N9_AD14N_66_BF14)
FMC_HPC1_LA05_P: J2.D11(LA05_P) U1.BE14(IO_L5P_T0U_N8_AD14P_66_BE14)
FMC_HPC1_LA06_N: J2.C11(LA06_N) U1.BE13(IO_L4N_T0U_N7_DBC_AD7N_66_BE13)
FMC_HPC1_LA06_P: J2.C10(LA06_P) U1.BD13(IO_L4P_T0U_N6_DBC_AD7P_66_BD13)
FMC_HPC1_LA07_N: J2.H14(LA07_N) U1.BD15(IO_L21N_T3L_N5_AD8N_66_BD15)
FMC_HPC1_LA07_P: J2.H13(LA07_P) U1.BC15(IO_L21P_T3L_N4_AD8P_66_BC15)
FMC_HPC1_LA08_N: J2.G13(LA08_N) U1.BF15(IO_L6N_T0U_N11_AD6N_66_BF15)
FMC_HPC1_LA08_P: J2.G12(LA08_P) U1.BE15(IO_L6P_T0U_N10_AD6P_66_BE15)
FMC_HPC1_LA09_N: J2.D15(LA09_N) U1.BB14(IO_L23N_T3U_N9_66_BB14)
FMC_HPC1_LA09_P: J2.D14(LA09_P) U1.BA14(IO_L23P_T3U_N8_66_BA14)
FMC_HPC1_LA10_N: J2.C15(LA10_N) U1.BB12(IO_L24N_T3U_N11_66_BB12)
FMC_HPC1_LA10_P: J2.C14(LA10_P) U1.BB13(IO_L24P_T3U_N10_66_BB13)
FMC_HPC1_LA11_N: J2.H17(LA11_N) U1.BA15(IO_L22N_T3U_N7_DBC_AD0N_66_BA15)
FMC_HPC1_LA11_P: J2.H16(LA11_P) U1.BA16(IO_L22P_T3U_N6_DBC_AD0P_66_BA16)
FMC_HPC1_LA12_N: J2.G16(LA12_N) U1.BC13(IO_L19N_T3L_N1_DBC_AD9N_66_BC13)
FMC_HPC1_LA12_P: J2.G15(LA12_P) U1.BC14(IO_L19P_T3L_N0_DBC_AD9P_66_BC14)
FMC_HPC1_LA13_N: J2.D18(LA13_N) U1.AY7(IO_L17N_T2U_N9_AD10N_66_AY7)
FMC_HPC1_LA13_P: J2.D17(LA13_P) U1.AY8(IO_L17P_T2U_N8_AD10P_66_AY8)
FMC_HPC1_LA14_N: J2.C19(LA14_N) U1.AW7(IO_L18N_T2U_N11_AD2N_66_AW7)
FMC_HPC1_LA14_P: J2.C18(LA14_P) U1.AW8(IO_L18P_T2U_N10_AD2P_66_AW8)
FMC_HPC1_LA15_N: J2.H20(LA15_N) U1.BC16(IO_L20N_T3L_N3_AD1N_66_BC16)
FMC_HPC1_LA15_P: J2.H19(LA15_P) U1.BB16(IO_L20P_T3L_N2_AD1P_66_BB16)
FMC_HPC1_LA16_N: J2.G19(LA16_N) U1.AV8(IO_L16N_T2U_N7_QBC_AD3N_66_AV8)
FMC_HPC1_LA16_P: J2.G18(LA16_P) U1.AV9(IO_L16P_T2U_N6_QBC_AD3P_66_AV9)
FMC_HPC1_LA17_CC_N: J2.D21(LA17_N_CC) U1.AT14(IO_L13N_T2L_N1_GC_QBC_67_AT14)
FMC_HPC1_LA17_CC_P: J2.D20(LA17_P_CC) U1.AR14(IO_L13P_T2L_N0_GC_QBC_67_AR14)
FMC_HPC1_LA18_CC_N: J2.C23(LA18_N_CC) U1.AR12(IO_L16N_T2U_N7_QBC_AD3N_67_AR12)
FMC_HPC1_LA18_CC_P: J2.C22(LA18_P_CC) U1.AP12(IO_L16P_T2U_N6_QBC_AD3P_67_AP12)
FMC_HPC1_LA19_N: J2.H23(LA19_N) U1.AY12(IO_L2N_T0L_N3_67_AY12)
FMC_HPC1_LA19_P: J2.H22(LA19_P) U1.AW12(IO_L2P_T0L_N2_67_AW12)
FMC_HPC1_LA20_N: J2.G22(LA20_N) U1.AY10(IO_L3N_T0L_N5_AD15N_67_AY10)
FMC_HPC1_LA20_P: J2.G21(LA20_P) U1.AW11(IO_L3P_T0L_N4_AD15P_67_AW11)
FMC_HPC1_LA21_N: J2.H26(LA21_N) U1.AV11(IO_L6N_T0U_N11_AD6N_67_AV11)
FMC_HPC1_LA21_P: J2.H25(LA21_P) U1.AU11(IO_L6P_T0U_N10_AD6P_67_AU11)
FMC_HPC1_LA22_N: J2.G25(LA22_N) U1.AY13(IO_L5N_T0U_N9_AD14N_67_AY13)
FMC_HPC1_LA22_P: J2.G24(LA22_P) U1.AW13(IO_L5P_T0U_N8_AD14P_67_AW13)
FMC_HPC1_LA23_N: J2.D24(LA23_N) U1.AP16(IO_L17N_T2U_N9_AD10N_67_AP16)
FMC_HPC1_LA23_P: J2.D23(LA23_P) U1.AN16(IO_L17P_T2U_N8_AD10P_67_AN16)
FMC_HPC1_LA24_N: J2.H29(LA24_N) U1.AR13(IO_L14N_T2L_N3_GC_67_AR13)
FMC_HPC1_LA24_P: J2.H28(LA24_P) U1.AP13(IO_L14P_T2L_N2_GC_67_AP13)
FMC_HPC1_LA25_N: J2.G28(LA25_N) U1.AU12(IO_L1N_T0L_N1_DBC_67_AU12)
FMC_HPC1_LA25_P: J2.G27(LA25_P) U1.AT12(IO_L1P_T0L_N0_DBC_67_AT12)
FMC_HPC1_LA26_N: J2.D27(LA26_N) U1.AL15(IO_L20N_T3L_N3_AD1N_67_AL15)
FMC_HPC1_LA26_P: J2.D26(LA26_P) U1.AK15(IO_L20P_T3L_N2_AD1P_67_AK15)
FMC_HPC1_LA27_N: J2.C27(LA27_N) U1.AM14(IO_L19N_T3L_N1_DBC_AD9N_67_AM14)
FMC_HPC1_LA27_P: J2.C26(LA27_P) U1.AL14(IO_L19P_T3L_N0_DBC_AD9P_67_AL14)
FMC_HPC1_LA28_N: J2.H32(LA28_N) U1.AW10(IO_L4N_T0U_N7_DBC_AD7N_67_AW10)
FMC_HPC1_LA28_P: J2.H31(LA28_P) U1.AV10(IO_L4P_T0U_N6_DBC_AD7P_67_AV10)
FMC_HPC1_LA29_N: J2.G31(LA29_N) U1.AP15(IO_L18N_T2U_N11_AD2N_67_AP15)
FMC_HPC1_LA29_P: J2.G30(LA29_P) U1.AN15(IO_L18P_T2U_N10_AD2P_67_AN15)
FMC_HPC1_LA30_N: J2.H35(LA30_N) U1.AL12(IO_L21N_T3L_N5_AD8N_67_AL12)
FMC_HPC1_LA30_P: J2.H34(LA30_P) U1.AK12(IO_L21P_T3L_N4_AD8P_67_AK12)
FMC_HPC1_LA31_N: J2.G34(LA31_N) U1.AM12(IO_L23N_T3U_N9_67_AM12)
FMC_HPC1_LA31_P: J2.G33(LA31_P) U1.AM13(IO_L23P_T3U_N8_67_AM13)
FMC_HPC1_LA32_N: J2.H38(LA32_N) U1.AJ12(IO_L22N_T3U_N7_DBC_AD0N_67_AJ12)
FMC_HPC1_LA32_P: J2.H37(LA32_P) U1.AJ13(IO_L22P_T3U_N6_DBC_AD0P_67_AJ13)
FMC_HPC1_LA33_N: J2.G37(LA33_N) U1.AK13(IO_L24N_T3U_N11_67_AK13)
FMC_HPC1_LA33_P: J2.G36(LA33_P) U1.AK14(IO_L24P_T3U_N10_67_AK14)
FMC_HPC1_PG_M2C: J2.F1(PG_M2C) R890.2 U44.12(B7)
FMC_HPC1_PG_M2C_LS: U1.BA7(IO_L15P_T2L_N4_AD11P_66_BA7) U44.9(A7)
FMC_HPC1_PRSNT_M2C_B: J2.H2(PRSNT_M2C_L) R888.2 U44.15(B4) U109.16(B3) U132.4(OE)
FMC_HPC1_PRSNT_M2C_B_LS: U1.BB7(IO_L15N_T2L_N5_AD11N_66_BB7) U44.6(A4)
FMC_HPC1_PRSNT_M2C_B_SYSCTLR: U109.5(A3) U111.R12(IO_L17P_T2_34_R12)
FMC_HPC1_TCK_BUF: J2.D29(TCK) U19.16(B6)
FMC_HPC1_TDO: J2.D31(TDO) U13.8(A1) U132.2(B)
FMC_HPC1_TDO_LS: J3.8(P8) U13.5(B1) U111.P9(IO_L23N_T3_34_P9) U115.8(TDO)
FMC_HPC1_TMS_BUF: J2.D33(TMS) U19.19(B3)
FMC_HPC1_VREF_A_M2C: C1331.1(CAP2) C1332.1(CAP2) J2.H1(VREF_A_M2C) R1023.1 R1024.1
FMC_VADJ_ON: J14.2(P2) R331.1 U25.2(B) U44.13(B6)
FMC_VADJ_ON_LS: U1.AL29(IO_L15P_T2L_N4_AD11P_43_AL29) U44.8(A6)
FMCP_HSPC_CLK0_M2C_N: J22.H5(CLK0_M2C_N) U1.AM32(IO_L13N_T2L_N1_GC_QBC_43_AM32)
FMCP_HSPC_CLK0_M2C_P: J22.H4(CLK0_M2C_P) U1.AL32(IO_L13P_T2L_N0_GC_QBC_43_AL32)
FMCP_HSPC_CLK1_M2C_N: J22.G3(CLK1_M2C_N) U1.P36(IO_L14N_T2L_N3_GC_45_P36)
FMCP_HSPC_CLK1_M2C_P: J22.G2(CLK1_M2C_P) U1.P35(IO_L14P_T2L_N2_GC_45_P35)
FMCP_HSPC_DP0_C2M_N: J22.C3(DP0_C2M_N) U1.AT43(MGTYTXN0_121_AT43)
FMCP_HSPC_DP0_C2M_P: J22.C2(DP0_C2M_P) U1.AT42(MGTYTXP0_121_AT42)
FMCP_HSPC_DP0_M2C_N: J22.C7(DP0_M2C_N) U1.AR46(MGTYRXN0_121_AR46)
FMCP_HSPC_DP0_M2C_P: J22.C6(DP0_M2C_P) U1.AR45(MGTYRXP0_121_AR45)
FMCP_HSPC_DP1_C2M_N: J22.A23(DP1_C2M_N) U1.AP43(MGTYTXN1_121_AP43)
FMCP_HSPC_DP1_C2M_P: J22.A22(DP1_C2M_P) U1.AP42(MGTYTXP1_121_AP42)
FMCP_HSPC_DP1_M2C_N: J22.A3(DP1_M2C_N) U1.AN46(MGTYRXN1_121_AN46)
FMCP_HSPC_DP1_M2C_P: J22.A2(DP1_M2C_P) U1.AN45(MGTYRXP1_121_AN45)
FMCP_HSPC_DP2_C2M_N: J22.A27(DP2_C2M_N) U1.AM43(MGTYTXN2_121_AM43)
FMCP_HSPC_DP2_C2M_P: J22.A26(DP2_C2M_P) U1.AM42(MGTYTXP2_121_AM42)
FMCP_HSPC_DP2_M2C_N: J22.A7(DP2_M2C_N) U1.AL46(MGTYRXN2_121_AL46)
FMCP_HSPC_DP2_M2C_P: J22.A6(DP2_M2C_P) U1.AL45(MGTYRXP2_121_AL45)
FMCP_HSPC_DP3_C2M_N: J22.A31(DP3_C2M_N) U1.AL41(MGTYTXN3_121_AL41)
FMCP_HSPC_DP3_C2M_P: J22.A30(DP3_C2M_P) U1.AL40(MGTYTXP3_121_AL40)
FMCP_HSPC_DP3_M2C_N: J22.A11(DP3_M2C_N) U1.AJ46(MGTYRXN3_121_AJ46)
FMCP_HSPC_DP3_M2C_P: J22.A10(DP3_M2C_P) U1.AJ45(MGTYRXP3_121_AJ45)
FMCP_HSPC_DP4_C2M_N: J22.A35(DP4_C2M_N) U1.T43(MGTYTXN0_126_T43)
FMCP_HSPC_DP4_C2M_P: J22.A34(DP4_C2M_P) U1.T42(MGTYTXP0_126_T42)
FMCP_HSPC_DP4_M2C_N: J22.A15(DP4_M2C_N) U1.W46(MGTYRXN0_126_W46)
FMCP_HSPC_DP4_M2C_P: J22.A14(DP4_M2C_P) U1.W45(MGTYRXP0_126_W45)
FMCP_HSPC_DP5_C2M_N: J22.A39(DP5_C2M_N) U1.P43(MGTYTXN1_126_P43)
FMCP_HSPC_DP5_C2M_P: J22.A38(DP5_C2M_P) U1.P42(MGTYTXP1_126_P42)
FMCP_HSPC_DP5_M2C_N: J22.A19(DP5_M2C_N) U1.U46(MGTYRXN1_126_U46)
FMCP_HSPC_DP5_M2C_P: J22.A18(DP5_M2C_P) U1.U45(MGTYRXP1_126_U45)
FMCP_HSPC_DP6_C2M_N: J22.B37(DP6_C2M_N) U1.M43(MGTYTXN2_126_M43)
FMCP_HSPC_DP6_C2M_P: J22.B36(DP6_C2M_P) U1.M42(MGTYTXP2_126_M42)
FMCP_HSPC_DP6_M2C_N: J22.B17(DP6_M2C_N) U1.R46(MGTYRXN2_126_R46)
FMCP_HSPC_DP6_M2C_P: J22.B16(DP6_M2C_P) U1.R45(MGTYRXP2_126_R45)
FMCP_HSPC_DP7_C2M_N: J22.B33(DP7_C2M_N) U1.K43(MGTYTXN3_126_K43)
FMCP_HSPC_DP7_C2M_P: J22.B32(DP7_C2M_P) U1.K42(MGTYTXP3_126_K42)
FMCP_HSPC_DP7_M2C_N: J22.B13(DP7_M2C_N) U1.N46(MGTYRXN3_126_N46)
FMCP_HSPC_DP7_M2C_P: J22.B12(DP7_M2C_P) U1.N45(MGTYRXP3_126_N45)
FMCP_HSPC_DP8_C2M_N: J22.B29(DP8_C2M_N) U1.AK43(MGTYTXN0_122_AK43)
FMCP_HSPC_DP8_C2M_P: J22.B28(DP8_C2M_P) U1.AK42(MGTYTXP0_122_AK42)
FMCP_HSPC_DP8_M2C_N: J22.B9(DP8_M2C_N) U1.AG46(MGTYRXN0_122_AG46)
FMCP_HSPC_DP8_M2C_P: J22.B8(DP8_M2C_P) U1.AG45(MGTYRXP0_122_AG45)
FMCP_HSPC_DP9_C2M_N: J22.B25(DP9_C2M_N) U1.AJ41(MGTYTXN1_122_AJ41)
FMCP_HSPC_DP9_C2M_P: J22.B24(DP9_C2M_P) U1.AJ40(MGTYTXP1_122_AJ40)
FMCP_HSPC_DP9_M2C_N: J22.B5(DP9_M2C_N) U1.AF44(MGTYRXN1_122_AF44)
FMCP_HSPC_DP9_M2C_P: J22.B4(DP9_M2C_P) U1.AF43(MGTYRXP1_122_AF43)
FMCP_HSPC_DP10_C2M_N: J22.Z25(DP10_C2M_N) U1.AG41(MGTYTXN2_122_AG41)
FMCP_HSPC_DP10_C2M_P: J22.Z24(DP10_C2M_P) U1.AG40(MGTYTXP2_122_AG40)
FMCP_HSPC_DP10_M2C_N: J22.Y11(DP10_M2C_N) U1.AE46(MGTYRXN2_122_AE46)
FMCP_HSPC_DP10_M2C_P: J22.Y10(DP10_M2C_P) U1.AE45(MGTYRXP2_122_AE45)
FMCP_HSPC_DP11_C2M_N: J22.Y27(DP11_C2M_N) U1.AE41(MGTYTXN3_122_AE41)
FMCP_HSPC_DP11_C2M_P: J22.Y26(DP11_C2M_P) U1.AE40(MGTYTXP3_122_AE40)
FMCP_HSPC_DP11_M2C_N: J22.Z13(DP11_M2C_N) U1.AD44(MGTYRXN3_122_AD44)
FMCP_HSPC_DP11_M2C_P: J22.Z12(DP11_M2C_P) U1.AD43(MGTYRXP3_122_AD43)
FMCP_HSPC_DP12_C2M_N: J22.Z29(DP12_C2M_N) U1.AC41(MGTYTXN0_125_AC41)
FMCP_HSPC_DP12_C2M_P: J22.Z28(DP12_C2M_P) U1.AC40(MGTYTXP0_125_AC40)
FMCP_HSPC_DP12_M2C_N: J22.Y15(DP12_M2C_N) U1.AC46(MGTYRXN0_125_AC46)
FMCP_HSPC_DP12_M2C_P: J22.Y14(DP12_M2C_P) U1.AC45(MGTYRXP0_125_AC45)
FMCP_HSPC_DP13_C2M_N: J22.Y31(DP13_C2M_N) U1.AA41(MGTYTXN1_125_AA41)
FMCP_HSPC_DP13_C2M_P: J22.Y30(DP13_C2M_P) U1.AA40(MGTYTXP1_125_AA40)
FMCP_HSPC_DP13_M2C_N: J22.Z17(DP13_M2C_N) U1.AB44(MGTYRXN1_125_AB44)
FMCP_HSPC_DP13_M2C_P: J22.Z16(DP13_M2C_P) U1.AB43(MGTYRXP1_125_AB43)
FMCP_HSPC_DP14_C2M_N: J22.M19(DP14_C2M_N) U1.W41(MGTYTXN2_125_W41)
FMCP_HSPC_DP14_C2M_P: J22.M18(DP14_C2M_P) U1.W40(MGTYTXP2_125_W40)
FMCP_HSPC_DP14_M2C_N: J22.Y19(DP14_M2C_N) U1.AA46(MGTYRXN2_125_AA46)
FMCP_HSPC_DP14_M2C_P: J22.Y18(DP14_M2C_P) U1.AA45(MGTYRXP2_125_AA45)
FMCP_HSPC_DP15_C2M_N: J22.M23(DP15_C2M_N) U1.U41(MGTYTXN3_125_U41)
FMCP_HSPC_DP15_C2M_P: J22.M22(DP15_C2M_P) U1.U40(MGTYTXP3_125_U40)
FMCP_HSPC_DP15_M2C_N: J22.Y23(DP15_M2C_N) U1.Y44(MGTYRXN3_125_Y44)
FMCP_HSPC_DP15_M2C_P: J22.Y22(DP15_M2C_P) U1.Y43(MGTYRXP3_125_Y43)
FMCP_HSPC_DP16_C2M_N: J22.M27(DP16_C2M_N) U1.H43(MGTYTXN0_127_H43)
FMCP_HSPC_DP16_C2M_P: J22.M26(DP16_C2M_P) U1.H42(MGTYTXP0_127_H42)
FMCP_HSPC_DP16_M2C_N: J22.Z33(DP16_M2C_N) U1.L46(MGTYRXN0_127_L46)
FMCP_HSPC_DP16_M2C_P: J22.Z32(DP16_M2C_P) U1.L45(MGTYRXP0_127_L45)
FMCP_HSPC_DP17_C2M_N: J22.M31(DP17_C2M_N) U1.F43(MGTYTXN1_127_F43)
FMCP_HSPC_DP17_C2M_P: J22.M30(DP17_C2M_P) U1.F42(MGTYTXP1_127_F42)
FMCP_HSPC_DP17_M2C_N: J22.Y35(DP17_M2C_N) U1.J46(MGTYRXN1_127_J46)
FMCP_HSPC_DP17_M2C_P: J22.Y34(DP17_M2C_P) U1.J45(MGTYRXP1_127_J45)
FMCP_HSPC_DP18_C2M_N: J22.M35(DP18_C2M_N) U1.D43(MGTYTXN2_127_D43)
FMCP_HSPC_DP18_C2M_P: J22.M34(DP18_C2M_P) U1.D42(MGTYTXP2_127_D42)
FMCP_HSPC_DP18_M2C_N: J22.Z37(DP18_M2C_N) U1.G46(MGTYRXN2_127_G46)
FMCP_HSPC_DP18_M2C_P: J22.Z36(DP18_M2C_P) U1.G45(MGTYRXP2_127_G45)
FMCP_HSPC_DP19_C2M_N: J22.M39(DP19_C2M_N) U1.B43(MGTYTXN3_127_B43)
FMCP_HSPC_DP19_C2M_P: J22.M38(DP19_C2M_P) U1.B42(MGTYTXP3_127_B42)
FMCP_HSPC_DP19_M2C_N: J22.Y39(DP19_M2C_N) U1.E46(MGTYRXN3_127_E46)
FMCP_HSPC_DP19_M2C_P: J22.Y38(DP19_M2C_P) U1.E45(MGTYRXP3_127_E45)
FMCP_HSPC_DP20_C2M_N: J22.Z9(DP20_C2M_N) U1.BD43(MGTYTXN0_120_BD43)
FMCP_HSPC_DP20_C2M_P: J22.Z8(DP20_C2M_P) U1.BD42(MGTYTXP0_120_BD42)
FMCP_HSPC_DP20_M2C_N: J22.M15(DP20_M2C_N) U1.BC46(MGTYRXN0_120_BC46)
FMCP_HSPC_DP20_M2C_P: J22.M14(DP20_M2C_P) U1.BC45(MGTYRXP0_120_BC45)
FMCP_HSPC_DP21_C2M_N: J22.Y7(DP21_C2M_N) U1.BB43(MGTYTXN1_120_BB43)
FMCP_HSPC_DP21_C2M_P: J22.Y6(DP21_C2M_P) U1.BB42(MGTYTXP1_120_BB42)
FMCP_HSPC_DP21_M2C_N: J22.M11(DP21_M2C_N) U1.BA46(MGTYRXN1_120_BA46)
FMCP_HSPC_DP21_M2C_P: J22.M10(DP21_M2C_P) U1.BA45(MGTYRXP1_120_BA45)
FMCP_HSPC_DP22_C2M_N: J22.Z5(DP22_C2M_N) U1.AY43(MGTYTXN2_120_AY43)
FMCP_HSPC_DP22_C2M_P: J22.Z4(DP22_C2M_P) U1.AY42(MGTYTXP2_120_AY42)
FMCP_HSPC_DP22_M2C_N: J22.M7(DP22_M2C_N) U1.AW46(MGTYRXN2_120_AW46)
FMCP_HSPC_DP22_M2C_P: J22.M6(DP22_M2C_P) U1.AW45(MGTYRXP2_120_AW45)
FMCP_HSPC_DP23_C2M_N: J22.Y3(DP23_C2M_N) U1.AV43(MGTYTXN3_120_AV43)
FMCP_HSPC_DP23_C2M_P: J22.Y2(DP23_C2M_P) U1.AV42(MGTYTXP3_120_AV42)
FMCP_HSPC_DP23_M2C_N: J22.M3(DP23_M2C_N) U1.AU46(MGTYRXN3_120_AU46)
FMCP_HSPC_DP23_M2C_P: J22.M2(DP23_M2C_P) U1.AU45(MGTYRXP3_120_AU45)
FMCP_HSPC_GBT0_0_C_N: C207.1(CAP2) U40.2(NQ0)
FMCP_HSPC_GBT0_0_C_P: C16.1(CAP2) U40.1(Q0)
FMCP_HSPC_GBT0_0_N: C207.2(CAP1) U1.AK39(MGTREFCLK0N_121_AK39)
FMCP_HSPC_GBT0_0_P: C16.2(CAP1) U1.AK38(MGTREFCLK0P_121_AK38)
FMCP_HSPC_GBT0_1_C_N: C209.1(CAP2) U40.4(NQ1)
FMCP_HSPC_GBT0_1_C_P: C208.1(CAP2) U40.3(Q1)
FMCP_HSPC_GBT0_1_N: C209.2(CAP1) U1.V39(MGTREFCLK0N_126_V39)
FMCP_HSPC_GBT0_1_P: C208.2(CAP1) U1.V38(MGTREFCLK0P_126_V38)
FMCP_HSPC_GBT1_0_C_N: C221.2(CAP1) U39.6(Q0_N)
FMCP_HSPC_GBT1_0_C_P: C220.2(CAP1) U39.5(Q0_P)
FMCP_HSPC_GBT1_0_N: C221.1(CAP2) U1.AH39(MGTREFCLK1N_121_AH39)
FMCP_HSPC_GBT1_0_P: C220.1(CAP2) U1.AH38(MGTREFCLK1P_121_AH38)
FMCP_HSPC_GBT1_1_C_N: C223.2(CAP1) U39.9(Q1_N)
FMCP_HSPC_GBT1_1_C_P: C222.2(CAP1) U39.8(Q1_P)
FMCP_HSPC_GBT1_1_N: C223.1(CAP2) U1.T39(MGTREFCLK1N_126_T39)
FMCP_HSPC_GBT1_1_P: C222.1(CAP2) U1.T38(MGTREFCLK1P_126_T38)
FMCP_HSPC_GBT1_2_C_N: C225.2(CAP1) U39.12(Q2_N)
FMCP_HSPC_GBT1_2_C_P: C224.2(CAP1) U39.11(Q2_P)
FMCP_HSPC_GBT1_2_N: C225.1(CAP2) U1.AD39(MGTREFCLK1N_122_AD39)
FMCP_HSPC_GBT1_2_P: C224.1(CAP2) U1.AD38(MGTREFCLK1P_122_AD38)
FMCP_HSPC_GBT1_3_C_N: C219.1(CAP2) U39.14(Q3_N)
FMCP_HSPC_GBT1_3_C_P: C218.1(CAP2) U39.13(Q3_P)
FMCP_HSPC_GBT1_3_N: C219.2(CAP1) U1.Y39(MGTREFCLK1N_125_Y39)
FMCP_HSPC_GBT1_3_P: C218.2(CAP1) U1.Y38(MGTREFCLK1P_125_Y38)
FMCP_HSPC_GBT1_4_C_N: C217.1(CAP2) U39.17(Q4_N)
FMCP_HSPC_GBT1_4_C_P: C214.1(CAP2) U39.16(Q4_P)
FMCP_HSPC_GBT1_4_N: C217.2(CAP1) U1.N41(MGTREFCLK1N_127_N41)
FMCP_HSPC_GBT1_4_P: C214.2(CAP1) U1.N40(MGTREFCLK1P_127_N40)
FMCP_HSPC_GBT1_5_C_N: C213.1(CAP2) U39.20(Q5_N)
FMCP_HSPC_GBT1_5_C_P: C212.1(CAP2) U39.19(Q5_P)
FMCP_HSPC_GBT1_5_N: C213.2(CAP1) U1.AM39(MGTREFCLK1N_120_AM39)
FMCP_HSPC_GBT1_5_P: C212.2(CAP1) U1.AM38(MGTREFCLK1P_120_AM38)
FMCP_HSPC_GBTCLK0_M2C_C_N: C14.2(CAP1) R195.1 U40.6(NCLK)
FMCP_HSPC_GBTCLK0_M2C_C_P: C13.2(CAP1) R195.2 U40.7(CLK)
FMCP_HSPC_GBTCLK0_M2C_N: C14.1(CAP2) J22.D5(GBTCLK0_M2C_N)
FMCP_HSPC_GBTCLK0_M2C_P: C13.1(CAP2) J22.D4(GBTCLK0_M2C_P)
FMCP_HSPC_GBTCLK1_M2C_C_N: C211.2(CAP1) R197.1 U39.1(CLK_N)
FMCP_HSPC_GBTCLK1_M2C_C_P: C210.2(CAP1) R197.2 U39.2(CLK_P)
FMCP_HSPC_GBTCLK1_M2C_N: C211.1(CAP2) J22.B21(GBTCLK1_M2C_N)
FMCP_HSPC_GBTCLK1_M2C_P: C210.1(CAP2) J22.B20(GBTCLK1_M2C_P)
FMCP_HSPC_GBTCLK2_M2C_C_N: C101.1(CAP2) U1.AF39(MGTREFCLK0N_122_AF39)
FMCP_HSPC_GBTCLK2_M2C_C_P: C100.1(CAP2) U1.AF38(MGTREFCLK0P_122_AF38)
FMCP_HSPC_GBTCLK2_M2C_N: C101.2(CAP1) J22.L13(GBTCLK2_M2C_N)
FMCP_HSPC_GBTCLK2_M2C_P: C100.2(CAP1) J22.L12(GBTCLK2_M2C_P)
FMCP_HSPC_GBTCLK3_M2C_C_N: C199.1(CAP2) U1.AB39(MGTREFCLK0N_125_AB39)
FMCP_HSPC_GBTCLK3_M2C_C_P: C198.1(CAP2) U1.AB38(MGTREFCLK0P_125_AB38)
FMCP_HSPC_GBTCLK3_M2C_N: C199.2(CAP1) J22.L9(GBTCLK3_M2C_N)
FMCP_HSPC_GBTCLK3_M2C_P: C198.2(CAP1) J22.L8(GBTCLK3_M2C_P)
FMCP_HSPC_GBTCLK4_M2C_C_N: C201.1(CAP2) U1.R41(MGTREFCLK0N_127_R41)
FMCP_HSPC_GBTCLK4_M2C_C_P: C200.1(CAP2) U1.R40(MGTREFCLK0P_127_R40)
FMCP_HSPC_GBTCLK4_M2C_N: C201.2(CAP1) J22.L5(GBTCLK4_M2C_N)
FMCP_HSPC_GBTCLK4_M2C_P: C200.2(CAP1) J22.L4(GBTCLK4_M2C_P)
FMCP_HSPC_GBTCLK5_M2C_C_N: C203.1(CAP2) U1.AN41(MGTREFCLK0N_120_AN41)
FMCP_HSPC_GBTCLK5_M2C_C_P: C202.1(CAP2) U1.AN40(MGTREFCLK0P_120_AN40)
FMCP_HSPC_GBTCLK5_M2C_N: C203.2(CAP1) J22.Z21(GBTCLK5_M2C_N)
FMCP_HSPC_GBTCLK5_M2C_P: C202.2(CAP1) J22.Z20(GBTCLK5_M2C_P)
FMCP_HSPC_H_PRSNT_M2C_B: J22.H2(PRSNT_M2C_L) R19.2 U26.4(OE) U44.16(B3) U109.17(B2)
FMCP_HSPC_H_PRSNT_M2C_B_LS: U1.AM33(IO_L12P_T1U_N10_GC_43_AM33) U44.5(A3)
FMCP_HSPC_HA00_CC_N: J22.F5(HA00_N_CC) U1.N13(IO_L13N_T2L_N1_GC_QBC_70_N13)
FMCP_HSPC_HA00_CC_P: J22.F4(HA00_P_CC) U1.N14(IO_L13P_T2L_N0_GC_QBC_70_N14)
FMCP_HSPC_HA01_CC_N: J22.E3(HA01_N_CC) U1.U15(IO_L7N_T1L_N1_QBC_AD13N_70_U15)
FMCP_HSPC_HA01_CC_P: J22.E2(HA01_P_CC) U1.V15(IO_L7P_T1L_N0_QBC_AD13P_70_V15)
FMCP_HSPC_HA02_N: J22.K8(HA02_N) U1.Y12(IO_L5N_T0U_N9_AD14N_70_Y12)
FMCP_HSPC_HA02_P: J22.K7(HA02_P) U1.AA12(IO_L5P_T0U_N8_AD14P_70_AA12)
FMCP_HSPC_HA03_N: J22.J7(HA03_N) U1.V12(IO_L3N_T0L_N5_AD15N_70_V12)
FMCP_HSPC_HA03_P: J22.J6(HA03_P) U1.W12(IO_L3P_T0L_N4_AD15P_70_W12)
FMCP_HSPC_HA04_N: J22.F8(HA04_N) U1.Y13(IO_L1N_T0L_N1_DBC_70_Y13)
FMCP_HSPC_HA04_P: J22.F7(HA04_P) U1.AA13(IO_L1P_T0L_N0_DBC_70_AA13)
FMCP_HSPC_HA05_N: J22.E7(HA05_N) U1.P14(IO_L14N_T2L_N3_GC_70_P14)
FMCP_HSPC_HA05_P: J22.E6(HA05_P) U1.R14(IO_L14P_T2L_N2_GC_70_R14)
FMCP_HSPC_HA06_N: J22.K11(HA06_N) U1.T13(IO_L12N_T1U_N11_GC_70_T13)
FMCP_HSPC_HA06_P: J22.K10(HA06_P) U1.U13(IO_L12P_T1U_N10_GC_70_U13)
FMCP_HSPC_HA07_N: J22.J10(HA07_N) U1.Y14(IO_L2N_T0L_N3_70_Y14)
FMCP_HSPC_HA07_P: J22.J9(HA07_P) U1.AA14(IO_L2P_T0L_N2_70_AA14)
FMCP_HSPC_HA08_N: J22.F11(HA08_N) U1.T11(IO_L10N_T1U_N7_QBC_AD4N_70_T11)
FMCP_HSPC_HA08_P: J22.F10(HA08_P) U1.U11(IO_L10P_T1U_N6_QBC_AD4P_70_U11)
FMCP_HSPC_HA09_N: J22.E10(HA09_N) U1.V14(IO_L6N_T0U_N11_AD6N_70_V14)
FMCP_HSPC_HA09_P: J22.E9(HA09_P) U1.W14(IO_L6P_T0U_N10_AD6P_70_W14)
FMCP_HSPC_HA10_N: J22.K14(HA10_N) U1.U16(IO_L8N_T1L_N3_AD5N_70_U16)
FMCP_HSPC_HA10_P: J22.K13(HA10_P) U1.V16(IO_L8P_T1L_N2_AD5P_70_V16)
FMCP_HSPC_HA11_N: J22.J13(HA11_N) U1.P12(IO_L18N_T2U_N11_AD2N_70_P12)
FMCP_HSPC_HA11_P: J22.J12(HA11_P) U1.R12(IO_L18P_T2U_N10_AD2P_70_R12)
FMCP_HSPC_HA12_N: J22.F14(HA12_N) U1.T15(IO_L9N_T1L_N5_AD12N_70_T15)
FMCP_HSPC_HA12_P: J22.F13(HA12_P) U1.T16(IO_L9P_T1L_N4_AD12P_70_T16)
FMCP_HSPC_HA13_N: J22.E13(HA13_N) U1.U12(IO_L4N_T0U_N7_DBC_AD7N_70_U12)
FMCP_HSPC_HA13_P: J22.E12(HA13_P) U1.V13(IO_L4P_T0U_N6_DBC_AD7P_70_V13)
FMCP_HSPC_HA14_N: J22.J16(HA14_N) U1.L11(IO_L22N_T3U_N7_DBC_AD0N_70_L11)
FMCP_HSPC_HA14_P: J22.J15(HA14_P) U1.M11(IO_L22P_T3U_N6_DBC_AD0P_70_M11)
FMCP_HSPC_HA15_N: J22.F17(HA15_N) U1.M12(IO_L19N_T3L_N1_DBC_AD9N_70_M12)
FMCP_HSPC_HA15_P: J22.F16(HA15_P) U1.M13(IO_L19P_T3L_N0_DBC_AD9P_70_M13)
FMCP_HSPC_HA16_N: J22.E16(HA16_N) U1.R13(IO_L11N_T1U_N9_GC_70_R13)
FMCP_HSPC_HA16_P: J22.E15(HA16_P) U1.T14(IO_L11P_T1U_N8_GC_70_T14)
FMCP_HSPC_HA17_CC_N: J22.K17(HA17_N_CC) U1.P11(IO_L16N_T2U_N7_QBC_AD3N_70_P11)
FMCP_HSPC_HA17_CC_P: J22.K16(HA17_P_CC) U1.R11(IO_L16P_T2U_N6_QBC_AD3P_70_R11)
FMCP_HSPC_HA18_N: J22.J19(HA18_N) U1.N15(IO_L15N_T2L_N5_AD11N_70_N15)
FMCP_HSPC_HA18_P: J22.J18(HA18_P) U1.P15(IO_L15P_T2L_N4_AD11P_70_P15)
FMCP_HSPC_HA19_N: J22.F20(HA19_N) U1.L13(IO_L20N_T3L_N3_AD1N_70_L13)
FMCP_HSPC_HA19_P: J22.F19(HA19_P) U1.L14(IO_L20P_T3L_N2_AD1P_70_L14)
FMCP_HSPC_HA20_N: J22.E19(HA20_N) U1.L15(IO_L17N_T2U_N9_AD10N_70_L15)
FMCP_HSPC_HA20_P: J22.E18(HA20_P) U1.M15(IO_L17P_T2U_N8_AD10P_70_M15)
FMCP_HSPC_HA21_N: J22.K20(HA21_N) U1.K13(IO_L23N_T3U_N9_70_K13)
FMCP_HSPC_HA21_P: J22.K19(HA21_P) U1.K14(IO_L23P_T3U_N8_70_K14)
FMCP_HSPC_HA22_N: J22.J22(HA22_N) U1.J12(IO_L24N_T3U_N11_70_J12)
FMCP_HSPC_HA22_P: J22.J21(HA22_P) U1.K12(IO_L24P_T3U_N10_70_K12)
FMCP_HSPC_HA23_N: J22.K23(HA23_N) U1.J11(IO_L21N_T3L_N5_AD8N_70_J11)
FMCP_HSPC_HA23_P: J22.K22(HA23_P) U1.K11(IO_L21P_T3L_N4_AD8P_70_K11)
FMCP_HSPC_IIC_SCL: J22.C30(SCL) R624.2 U80.7(SC1)
FMCP_HSPC_IIC_SDA: J22.C31(SDA) R623.2 U80.6(SD1)
FMCP_HSPC_LA00_CC_N: J22.G7(LA00_N_CC) U1.AL36(IO_L7N_T1L_N1_QBC_AD13N_43_AL36)
FMCP_HSPC_LA00_CC_P: J22.G6(LA00_P_CC) U1.AL35(IO_L7P_T1L_N0_QBC_AD13P_43_AL35)
FMCP_HSPC_LA01_CC_N: J22.D9(LA01_N_CC) U1.AL31(IO_L16N_T2U_N7_QBC_AD3N_43_AL31)
FMCP_HSPC_LA01_CC_P: J22.D8(LA01_P_CC) U1.AL30(IO_L16P_T2U_N6_QBC_AD3P_43_AL30)
FMCP_HSPC_LA02_N: J22.H8(LA02_N) U1.AK32(IO_L14N_T2L_N3_GC_43_AK32)
FMCP_HSPC_LA02_P: J22.H7(LA02_P) U1.AJ32(IO_L14P_T2L_N2_GC_43_AJ32)
FMCP_HSPC_LA03_N: J22.G10(LA03_N) U1.AT40(IO_L4N_T0U_N7_DBC_AD7N_43_AT40)
FMCP_HSPC_LA03_P: J22.G9(LA03_P) U1.AT39(IO_L4P_T0U_N6_DBC_AD7P_43_AT39)
FMCP_HSPC_LA04_N: J22.H11(LA04_N) U1.AT37(IO_L6N_T0U_N11_AD6N_43_AT37)
FMCP_HSPC_LA04_P: J22.H10(LA04_P) U1.AR37(IO_L6P_T0U_N10_AD6P_43_AR37)
FMCP_HSPC_LA05_N: J22.D12(LA05_N) U1.AR38(IO_L1N_T0L_N1_DBC_43_AR38)
FMCP_HSPC_LA05_P: J22.D11(LA05_P) U1.AP38(IO_L1P_T0L_N0_DBC_43_AP38)
FMCP_HSPC_LA06_N: J22.C11(LA06_N) U1.AT36(IO_L2N_T0L_N3_43_AT36)
FMCP_HSPC_LA06_P: J22.C10(LA06_P) U1.AT35(IO_L2P_T0L_N2_43_AT35)
FMCP_HSPC_LA07_N: J22.H14(LA07_N) U1.AP37(IO_L5N_T0U_N9_AD14N_43_AP37)
FMCP_HSPC_LA07_P: J22.H13(LA07_P) U1.AP36(IO_L5P_T0U_N8_AD14P_43_AP36)
FMCP_HSPC_LA08_N: J22.G13(LA08_N) U1.AK30(IO_L18N_T2U_N11_AD2N_43_AK30)
FMCP_HSPC_LA08_P: J22.G12(LA08_P) U1.AK29(IO_L18P_T2U_N10_AD2P_43_AK29)
FMCP_HSPC_LA09_N: J22.D15(LA09_N) U1.AK33(IO_L19N_T3L_N1_DBC_AD9N_43_AK33)
FMCP_HSPC_LA09_P: J22.D14(LA09_P) U1.AJ33(IO_L19P_T3L_N0_DBC_AD9P_43_AJ33)
FMCP_HSPC_LA10_N: J22.C15(LA10_N) U1.AR35(IO_L3N_T0L_N5_AD15N_43_AR35)
FMCP_HSPC_LA10_P: J22.C14(LA10_P) U1.AP35(IO_L3P_T0L_N4_AD15P_43_AP35)
FMCP_HSPC_LA11_N: J22.H17(LA11_N) U1.AJ31(IO_L17N_T2U_N9_AD10N_43_AJ31)
FMCP_HSPC_LA11_P: J22.H16(LA11_P) U1.AJ30(IO_L17P_T2U_N8_AD10P_43_AJ30)
FMCP_HSPC_LA12_N: J22.G16(LA12_N) U1.AH34(IO_L21N_T3L_N5_AD8N_43_AH34)
FMCP_HSPC_LA12_P: J22.G15(LA12_P) U1.AH33(IO_L21P_T3L_N4_AD8P_43_AH33)
FMCP_HSPC_LA13_N: J22.D18(LA13_N) U1.AJ36(IO_L20N_T3L_N3_AD1N_43_AJ36)
FMCP_HSPC_LA13_P: J22.D17(LA13_P) U1.AJ35(IO_L20P_T3L_N2_AD1P_43_AJ35)
FMCP_HSPC_LA14_N: J22.C19(LA14_N) U1.AH31(IO_L23N_T3U_N9_43_AH31)
FMCP_HSPC_LA14_P: J22.C18(LA14_P) U1.AG31(IO_L23P_T3U_N8_43_AG31)
FMCP_HSPC_LA15_N: J22.H20(LA15_N) U1.AG33(IO_L24N_T3U_N11_43_AG33)
FMCP_HSPC_LA15_P: J22.H19(LA15_P) U1.AG32(IO_L24P_T3U_N10_43_AG32)
FMCP_HSPC_LA16_N: J22.G19(LA16_N) U1.AH35(IO_L22N_T3U_N7_DBC_AD0N_43_AH35)
FMCP_HSPC_LA16_P: J22.G18(LA16_P) U1.AG34(IO_L22P_T3U_N6_DBC_AD0P_43_AG34)
FMCP_HSPC_LA17_CC_N: J22.D21(LA17_N_CC) U1.P34(IO_L13N_T2L_N1_GC_QBC_45_P34)
FMCP_HSPC_LA17_CC_P: J22.D20(LA17_P_CC) U1.R34(IO_L13P_T2L_N0_GC_QBC_45_R34)
FMCP_HSPC_LA18_CC_N: J22.C23(LA18_N_CC) U1.P31(IO_L10N_T1U_N7_QBC_AD4N_45_P31)
FMCP_HSPC_LA18_CC_P: J22.C22(LA18_P_CC) U1.R31(IO_L10P_T1U_N6_QBC_AD4P_45_R31)
FMCP_HSPC_LA19_N: J22.H23(LA19_N) U1.M33(IO_L22N_T3U_N7_DBC_AD0N_45_M33)
FMCP_HSPC_LA19_P: J22.H22(LA19_P) U1.N33(IO_L22P_T3U_N6_DBC_AD0P_45_N33)
FMCP_HSPC_LA20_N: J22.G22(LA20_N) U1.M32(IO_L23N_T3U_N9_45_M32)
FMCP_HSPC_LA20_P: J22.G21(LA20_P) U1.N32(IO_L23P_T3U_N8_45_N32)
FMCP_HSPC_LA21_N: J22.H26(LA21_N) U1.L35(IO_L24N_T3U_N11_45_L35)
FMCP_HSPC_LA21_P: J22.H25(LA21_P) U1.M35(IO_L24P_T3U_N10_45_M35)
FMCP_HSPC_LA22_N: J22.G25(LA22_N) U1.N35(IO_L20N_T3L_N3_AD1N_45_N35)
FMCP_HSPC_LA22_P: J22.G24(LA22_P) U1.N34(IO_L20P_T3L_N2_AD1P_45_N34)
FMCP_HSPC_LA23_N: J22.D24(LA23_N) U1.W32(IO_L1N_T0L_N1_DBC_45_W32)
FMCP_HSPC_LA23_P: J22.D23(LA23_P) U1.Y32(IO_L1P_T0L_N0_DBC_45_Y32)
FMCP_HSPC_LA24_N: J22.H29(LA24_N) U1.T35(IO_L6N_T0U_N11_AD6N_45_T35)
FMCP_HSPC_LA24_P: J22.H28(LA24_P) U1.T34(IO_L6P_T0U_N10_AD6P_45_T34)
FMCP_HSPC_LA25_N: J22.G28(LA25_N) U1.W34(IO_L3N_T0L_N5_AD15N_45_W34)
FMCP_HSPC_LA25_P: J22.G27(LA25_P) U1.Y34(IO_L3P_T0L_N4_AD15P_45_Y34)
FMCP_HSPC_LA26_N: J22.D27(LA26_N) U1.U33(IO_L2N_T0L_N3_45_U33)
FMCP_HSPC_LA26_P: J22.D26(LA26_P) U1.V32(IO_L2P_T0L_N2_45_V32)
FMCP_HSPC_LA27_N: J22.C27(LA27_N) U1.V34(IO_L5N_T0U_N9_AD14N_45_V34)
FMCP_HSPC_LA27_P: J22.C26(LA27_P) U1.V33(IO_L5P_T0U_N8_AD14P_45_V33)
FMCP_HSPC_LA28_N: J22.H32(LA28_N) U1.L36(IO_L17N_T2U_N9_AD10N_45_L36)
FMCP_HSPC_LA28_P: J22.H31(LA28_P) U1.M36(IO_L17P_T2U_N8_AD10P_45_M36)
FMCP_HSPC_LA29_N: J22.G31(LA29_N) U1.T36(IO_L4N_T0U_N7_DBC_AD7N_45_T36)
FMCP_HSPC_LA29_P: J22.G30(LA29_P) U1.U35(IO_L4P_T0U_N6_DBC_AD7P_45_U35)
FMCP_HSPC_LA30_N: J22.H35(LA30_N) U1.M38(IO_L18N_T2U_N11_AD2N_45_M38)
FMCP_HSPC_LA30_P: J22.H34(LA30_P) U1.N38(IO_L18P_T2U_N10_AD2P_45_N38)
FMCP_HSPC_LA31_N: J22.G34(LA31_N) U1.N37(IO_L16N_T2U_N7_QBC_AD3N_45_N37)
FMCP_HSPC_LA31_P: J22.G33(LA31_P) U1.P37(IO_L16P_T2U_N6_QBC_AD3P_45_P37)
FMCP_HSPC_LA32_N: J22.H38(LA32_N) U1.K33(IO_L21N_T3L_N5_AD8N_45_K33)
FMCP_HSPC_LA32_P: J22.H37(LA32_P) U1.L33(IO_L21P_T3L_N4_AD8P_45_L33)
FMCP_HSPC_LA33_N: J22.G37(LA33_N) U1.K34(IO_L19N_T3L_N1_DBC_AD9N_45_K34)
FMCP_HSPC_LA33_P: J22.G36(LA33_P) U1.L34(IO_L19P_T3L_N0_DBC_AD9P_45_L34)
FMCP_HSPC_PG_M2C: J22.F1(PG_M2C) R308.2 U44.17(B2)
FMCP_HSPC_PG_M2C_LS: U1.AM34(IO_L12N_T1U_N11_GC_43_AM34) U44.4(A2)
FMCP_HSPC_PRSNT_M2C_B_SYSCTLR: U109.4(A2) U111.R13(IO_L17N_T2_34_R13)
FMCP_HSPC_REFCLK_C2M_N: J22.L21(REFCLK_C2M_N) U1.AP33(IO_L10N_T1U_N7_QBC_AD4N_43_AP33)
FMCP_HSPC_REFCLK_C2M_P: J22.L20(REFCLK_C2M_P) U1.AN33(IO_L10P_T1U_N6_QBC_AD4P_43_AN33)
FMCP_HSPC_REFCLK_M2C_N: J22.L25(REFCLK_M2C_N) U1.AL34(IO_L11N_T1U_N9_GC_43_AL34)
FMCP_HSPC_REFCLK_M2C_P: J22.L24(REFCLK_M2C_P) U1.AK34(IO_L11P_T1U_N8_GC_43_AK34)
FMCP_HSPC_SYNC_C2M_N: J22.L17(SYNC_C2M_N) U1.AN35(IO_L8N_T1L_N3_AD5N_43_AN35)
FMCP_HSPC_SYNC_C2M_P: J22.L16(SYNC_C2M_P) U1.AN34(IO_L8P_T1L_N2_AD5P_43_AN34)
FMCP_HSPC_SYNC_M2C_N: J22.L29(SYNC_M2C_N) U1.AN36(IO_L9N_T1L_N5_AD12N_43_AN36)
FMCP_HSPC_SYNC_M2C_P: J22.L28(SYNC_M2C_P) U1.AM36(IO_L9P_T1L_N4_AD12P_43_AM36)
FMCP_HSPC_TCK_BUF: J22.D29(TCK) U19.17(B5)
FMCP_HSPC_TDO_HPC1_TDI: J2.D30(TDI) J22.D31(TDO) U26.2(B) U132.1(A)
FMCP_HSPC_TMS_BUF: J22.D33(TMS) U19.20(B2)
FMCP_HSPC_VREF_A_M2C: C4.1(CAP2) C856.1(CAP2) C858.1(CAP2) J22.H1(VREF_A_M2C) R3.1 R796.1 R798.1
FMCP_HSPC_Z_PRSNT_M2C_B: J22.Z1(HSPC_PRSNT_M2C_L) R934.2 U44.14(B5)
FMCP_HSPC_Z_PRSNT_M2C_B_LS: U1.AM29(IO_L15N_T2L_N5_AD11N_43_AM29) U44.7(A5)
FPGA_DONE: Q2.1(GATE) R236.2 R554.2 U1.AE12(DONE_0_AE12)
FPGA_EMCCLK: R563.2 U1.AL20(IO_L24P_T3U_N10_EMCCLK_65_AL20)
FPGA_EMCCLK_R: R563.1 U122.14(CLK2A)
FPGA_INIT_B: R6.2 R553.2 R1328.1 U1.AC12(INIT_B_0_AC12) U53.4(B)
FPGA_M0: R133.1 R1083.1 SW16.4 U1.U10(M0_0_U10)
FPGA_M0_R: R133.2 U111.M11(IO_L21N_T3_DQS_34_M11)
FPGA_M1: R135.1 R1084.1 SW16.3 U1.Y11(M1_0_Y11)
FPGA_M1_R: R135.2 U111.M10(IO_L21P_T3_DQS_34_M10)
FPGA_M2: R83.1 R1085.1 SW16.2 U1.W11(M2_0_W11)
FPGA_M2_R: R83.2 U111.R8(IO_L20N_T3_34_R8)
FPGA_PROG_B: R53.2 R140.1 SW4.1(P1) SW4.2(P2) U1.AH11(PROGRAM_B_0_AH11) U111.N14(IO_L7N_T1_34_N14)
FPGA_SYSMON_VCC: C2.1(CAP2) C1578.1(CAP2) L13.1 U1.AB18(VCCADC_AB18)
FPGA_TDO_FMC_TDI: U1.AD13(TDO_0_AD13) U19.3(A1)
FPGA_TDO_FMC_TDI_BUF: J22.D30(TDI) U19.21(B1) U26.1(A)
FPGA_VBATT: B1.1(P) R115.2 U1.AT11(VBATT_AT11)
GPIO_DIP_SW1: R51.1 SW12.1 U1.B17(IO_L19N_T3L_N1_DBC_AD9N_73_B17)
GPIO_DIP_SW2: R50.1 SW12.2 U1.G16(IO_T2U_N12_73_G16)
GPIO_DIP_SW3: R41.1 SW12.3 U1.J16(IO_L7N_T1L_N1_QBC_AD13N_73_J16)
GPIO_DIP_SW4: R40.1 SW12.4 U1.D21(IO_T3U_N12_72_D21)
GPIO_LED0: Q16.1(GATE) R124.1 U1.AT32(IO_L19N_T3L_N1_DBC_AD9N_40_AT32)
GPIO_LED1: Q15.1(GATE) R123.1 U1.AV34(IO_T2U_N12_40_AV34)
GPIO_LED2: Q14.1(GATE) R122.1 U1.AY30(IO_T1U_N12_40_AY30)
GPIO_LED3: Q13.1(GATE) R121.1 U1.BB32(IO_L7N_T1L_N1_QBC_AD13N_40_BB32)
GPIO_LED4: Q12.1(GATE) R120.1 U1.BF32(IO_L1N_T0L_N1_DBC_40_BF32)
GPIO_LED5: Q11.1(GATE) R119.1 U1.AU37(IO_T3U_N12_42_AU37)
GPIO_LED6: Q10.1(GATE) R118.1 U1.AV36(IO_L19N_T3L_N1_DBC_AD9N_42_AV36)
GPIO_LED7: Q8.1(GATE) R117.1 U1.BA37(IO_L13N_T2L_N1_GC_QBC_42_BA37)
GPIO_SW_C: R46.1 SW7.3(P3) SW7.4(P4) U1.BD23(IO_L3P_T0L_N4_AD15P_64_BD23) U111.B12(PS_MIO48_501_B12)
GPIO_SW_E: R48.1 SW9.3(P3) SW9.4(P4) U1.BE23(IO_L3N_T0L_N5_AD15N_64_BE23) U111.B14(PS_MIO36_501_B14)
GPIO_SW_N: R49.1 SW10.3(P3) SW10.4(P4) U1.BB24(IO_L5P_T0U_N8_AD14P_64_BB24) U111.A13(PS_MIO38_501_A13)
GPIO_SW_S: R47.1 SW17.3(P3) SW17.4(P4) U1.BE22(IO_L4P_T0U_N6_DBC_AD7P_64_BE22) U111.C14(PS_MIO37_501_C14)
GPIO_SW_W: R45.1 SW6.3(P3) SW6.4(P4) U1.BF22(IO_L4N_T0U_N7_DBC_AD7N_64_BF22) U111.D14(PS_MIO39_501_D14)
IIC_EEPROM_SCL: R628.2 U12.6(SCL) U80.11(SC3)
IIC_EEPROM_SDA: R627.2 U12.5(SDA) U80.10(SD3)
IIC_MAIN_SCL: R683.2 U1.AM24(IO_L24N_T3U_N11_64_AM24) U28.22(SCL) U80.22(SCL) U111.A15(PS_MIO28_501_A15)
IIC_MAIN_SDA: R682.2 U1.AL24(IO_L24P_T3U_N10_64_AL24) U28.23(SDA) U80.23(SDA) U111.D11(PS_MIO29_501_D11)
IIC_MUX_RESET_B: R72.2 U1.AL25(IO_T3U_N12_64_AL25) U28.3(RESET_B) U80.3(RESET_B)
INA_PMBUS_ALERT: U8.3(ALERT) U23.3(ALERT) U27.3(ALERT) U29.3(ALERT) U35.3(ALERT) U36.3(ALERT) U37.3(ALERT)
INA_PMBUS_SCL: R630.2 U8.5(SCL) U23.5(SCL) U27.5(SCL) U29.2(A0) U29.5(SCL) U35.5(SCL) U36.5(SCL) U37.5(SCL) U80.14(SC4)
INA_PMBUS_SDA: R629.2 U8.1(A1) U8.4(SDA) U23.4(SDA) U27.2(A0) U27.4(SDA) U29.4(SDA) U35.4(SDA) U36.4(SDA) U37.4(SDA) U80.13(SD4)
INPUT_GND: C298.2(CAP1) C358.2(CAP1) C549.2(CAP1) C871.2(CAP1) J12.1(P1) J15.2(NC_A) J15.3(GND_A) J15.6(GND_B) Q4.2(SOURCE) R637.2 R640.2 SW1.3(P3) SW1.SH1(P4) SW1.SH2(P5) U15.2(GND) U16.3(PSG)
JTAG_TCK: J3.6(P6) R211.2 R573.1 R810.1 U1.AE13(TCK_0_AE13) U19.7(A5) U19.8(A6)
JTAG_TDI: J3.10(P10) R574.1 R811.1 U1.AD15(TDI_0_AD15)
JTAG_TMS: J3.4(P4) R212.2 R575.1 R812.1 U1.AF15(TMS_0_AF15) U19.4(A2) U19.5(A3)
MASTER_SW_12V: Q4.1(GATE) R638.1 SW1.2(P2)
MAXIM_CABLE_B: J39.2(P2) Q27.3(DRAIN) R327.2 U109.18(B1)
MAXIM_CABLE_B_SYSCTLR: U109.3(A1) U111.R11(IO_L16N_T2_34_R11)
MAXIM_CABLE_LS_B: Q27.2(SOURCE) R105.2 U1.BF40(IO_L7N_T1L_N1_QBC_AD13N_42_BF40)
MGT223_REFCLK1_N: C244.2(CAP1) U1.J8(MGTREFCLK1N_233_J8)
MGT226_CLK0_N: C241.1(CAP2) J30.1(SIG)
MGT226_CLK0_P: C243.1(CAP2) J31.1(SIG)
MGT226_REFCLK0_N: C241.2(CAP1) U1.AG8(MGTREFCLK0N_226_AG8)
MGT226_REFCLK0_P: C243.2(CAP1) U1.AG9(MGTREFCLK0P_226_AG9)
MGT233_CLK1_N: C244.1(CAP2) J32.1(SIG)
MGT233_CLK1_P: C245.1(CAP2) J33.1(SIG)
MGT233_REFCLK1_P: C245.2(CAP1) U1.J9(MGTREFCLK1P_233_J9)
MGT_SI570_CLOCK1_C_N: C10.1(CAP2) U1.AJ8(MGTREFCLK1N_225_AJ8)
MGT_SI570_CLOCK1_C_P: C9.1(CAP2) U1.AJ9(MGTREFCLK1P_225_AJ9)
MGT_SI570_CLOCK1_N: C10.2(CAP1) U104.12(Q1_N)
MGT_SI570_CLOCK1_P: C9.2(CAP1) U104.11(Q1_P)
MGT_SI570_CLOCK2_C_N: C1398.1(CAP2) U1.R8(MGTREFCLK0N_232_R8)
MGT_SI570_CLOCK2_C_P: C1397.1(CAP2) U1.R9(MGTREFCLK0P_232_R9)
MGT_SI570_CLOCK2_N: C1398.2(CAP1) U104.14(Q2_N)
MGT_SI570_CLOCK2_P: C1397.2(CAP1) U104.13(Q2_P)
MGT_SI570_CLOCK3_C_N: C89.1(CAP2) U1.L8(MGTREFCLK0N_233_L8)
MGT_SI570_CLOCK3_C_P: C88.1(CAP2) U1.L9(MGTREFCLK0P_233_L9)
MGT_SI570_CLOCK3_N: C89.2(CAP1) U104.16(Q3_N)
MGT_SI570_CLOCK3_P: C88.2(CAP1) U104.15(Q3_P)
MGTAVCC: C1419.1(CAP2) C1732.1(CAP2) L89.2 R114.2 R1204.2
MGTAVCC_A3_IN: C1698.1(CAP2) C1723.2(CAP1) R1227.1 R1274.2 U166.30(A3_IN)
MGTAVCC_FPGA: C590.1(CAP2) C596.1(CAP2) C602.1(CAP2) C614.1(CAP2) C618.1(CAP2) C622.1(CAP2) C628.1(CAP2) C630.1(CAP2) C632.1(CAP2) C902.1(CAP2) C903.1(CAP2) C1474.1(CAP2) C1478.1(CAP2) C1480.1(CAP2) C1504.1(CAP2) C1505.1(CAP2) C1516.1(CAP2) C1517.1(CAP2) C1520.1(CAP2) C1547.1(CAP2) C1548.1(CAP2) C1549.1(CAP2) C1550.1(CAP2) C1733.1(CAP2) C1734.1(CAP2) C1735.1(CAP2) C1736.1(CAP2) C1737.1(CAP2) C1738.1(CAP2) C1739.1(CAP2) C1740.1(CAP2) D38.1(CATHODE) J109.1(P1) R113.2 R1204.1 U1.AA10(MGTAVCC_RN_AA10) U1.AA36(MGTAVCC_LN_AA36) U1.AB9(MGTAVCC_RN_AB9) U1.AB37(MGTAVCC_LN_AB37) U1.AC10(MGTAVCC_RN_AC10) U1.AC36(MGTAVCC_LS_AC36) U1.AC39(MGTAVCC_LN_AC39) U1.AD11(MGTAVCC_RN_AD11) U1.AD37(MGTAVCC_LS_AD37) U1.AE10(MGTAVCC_RS_AE10) U1.AE36(MGTAVCC_LS_AE36) U1.AF11(MGTAVCC_RS_AF11) U1.AF37(MGTAVCC_LS_AF37) U1.AG10(MGTAVCC_RS_AG10) U1.AG37(MGTAVCC_LS_AG37) U1.AH8(MGTAVCC_RS_AH8) U1.AJ10(MGTAVCC_RS_AJ10) U1.AJ38(MGTAVCC_LS_AJ38) U1.AK9(MGTAVCC_RS_AK9) U1.AL10(MGTAVCC_RS_AL10) U1.AL39(MGTAVCC_LS_AL39) U1.AM8(MGTAVCC_RS_AM8) U1.AN10(MGTAVCC_RS_AN10) U1.AP9(MGTAVCC_RS_AP9) U1.AP40(MGTAVCC_LS_AP40) U1.AR10(MGTAVCC_RS_AR10) U1.AT8(MGTAVCC_RS_AT8) U1.K9(MGTAVCC_RN_K9) U1.M8(MGTAVCC_RN_M8) U1.P9(MGTAVCC_RN_P9) U1.P40(MGTAVCC_LN_P40) U1.U38(MGTAVCC_LN_U38) U1.V37(MGTAVCC_LN_V37) U1.W10(MGTAVCC_RN_W10) U1.W36(MGTAVCC_LN_W36) U1.Y8(MGTAVCC_RN_Y8) U1.Y37(MGTAVCC_LN_Y37) Z132.2(NET2)
MGTAVCC_FPGA_SNS_N: U166.35(SENSE_N) Z133.1(NET1)
MGTAVCC_FPGA_SNS_P: U37.8(VBUS) U166.36(SENSE_P) Z132.1(NET1)
MGTAVCC_FPGA_VIN: C158.1(CAP2) R113.1 U37.9(VIN_N)
MGTAVCC_ISENSE2: R1227.2 R1271.2 U163.15(ISENSE)
MGTAVCC_PGOOD: D11.1(CATHODE) RP3.8 U51.7(A5) U166.24(PWRGD)
MGTAVCC_PWM2: U163.13(PWM) U166.17(PWM2)
MGTAVCC_SLAVE_1V8: C1620.1(CAP2) C1675.1(CAP2) C1676.1(CAP2) C1681.1(CAP2) L98.1 R1212.1 R1232.1 U163.11(VCC)
MGTAVCC_TS_FAULTB: C1718.1(CAP2) R1279.1 U166.19(TS_FAULTB)
MGTAVCC_VDD_MASTER: C1603.1(CAP2) C1674.1(CAP2) C1676.2(CAP1) R1200.1 R1232.2 U166.8(VDD)
MGTAVCC_VIN: C158.2(CAP1) R114.1 U37.10(VIN_P)
MGTAVCC_VIN_UV: C1717.1(CAP2) R1218.2 R1221.1 U166.14(VIN_UV)
MGTAVCC_VX2: C1704.1(CAP2) L89.1 U163.6(VX) U163.7(VX_1) U163.8(VX_2) U163.9(VX_3)
MGTAVTT: C1743.1(CAP2) C1744.1(CAP2) L88.2 R112.2 R1203.2
MGTAVTT_A3_IN: C1694.1(CAP2) C1722.2(CAP1) R1226.1 R1273.2 U165.30(A3_IN)
MGTAVTT_FPGA: C589.1(CAP2) C595.1(CAP2) C601.1(CAP2) C615.1(CAP2) C619.1(CAP2) C623.1(CAP2) C1475.1(CAP2) C1477.1(CAP2) C1479.1(CAP2) C1481.1(CAP2) C1506.1(CAP2) C1515.1(CAP2) C1518.1(CAP2) C1519.1(CAP2) C1741.1(CAP2) C1742.1(CAP2) C1745.1(CAP2) C1746.1(CAP2) C1747.1(CAP2) C1748.1(CAP2) C1749.1(CAP2) C1750.1(CAP2) C1751.1(CAP2) C1752.1(CAP2) D37.1(CATHODE) J108.1(P1) R111.2 R175.2 R176.2 R1088.2 R1203.1 R1326.2 U1.A5(MGTAVTTRCAL_RN_A5) U1.A42(MGTAVTT_LN_A42) U1.AA6(MGTAVTT_RS_AA6) U1.AB40(MGTAVTT_LN_AB40) U1.AC7(MGTAVTT_RS_AC7) U1.AD41(MGTAVTT_LS_AD41) U1.AE6(MGTAVTT_RS_AE6) U1.AF40(MGTAVTT_LS_AF40) U1.AG7(MGTAVTT_RS_AG7) U1.AH41(MGTAVTT_LS_AH41) U1.AH43(MGTAVTT_LS_AH43) U1.AJ6(MGTAVTT_RS_AJ6) U1.AJ42(MGTAVTT_LS_AJ42) U1.AK40(MGTAVTT_LS_AK40) U1.AL4(MGTAVTT_RS_AL4) U1.AL7(MGTAVTT_RS_AL7) U1.AL43(MGTAVTT_LS_AL43) U1.AM5(MGTAVTT_RS_AM5) U1.AM41(MGTAVTT_LS_AM41) U1.AN6(MGTAVTT_RS_AN6) U1.AN42(MGTAVTT_LS_AN42) U1.AP4(MGTAVTT_RS_AP4) U1.AR7(MGTAVTT_RS_AR7) U1.AR43(MGTAVTT_LS_AR43) U1.AT5(MGTAVTT_RS_AT5) U1.AU6(MGTAVTT_RS_AU6) U1.AU42(MGTAVTT_LS_AU42) U1.AV4(MGTAVTT_RS_AV4) U1.AW43(MGTAVTT_LS_AW43) U1.AY5(MGTAVTT_RS_AY5) U1.B3(MGTAVTT_RN_B3) U1.B5(MGTAVTT_RN_B5) U1.B44(MGTAVTT_LN_B44) U1.BA42(MGTAVTT_LS_BA42) U1.BB4(MGTAVTT_RS_BB4) U1.BC43(MGTAVTT_LS_BC43) U1.BD3(MGTAVTTRCAL_RS_BD3) U1.BD5(MGTAVTT_RS_BD5) U1.BE3(MGTAVTT_RS_BE3) U1.BE42(MGTAVTT_LS_BE42) U1.BE44(MGTAVTT_LS_BE44) U1.BF4(MGTAVTT_RS_BF4) U1.BF42(MGTAVTTRCAL_LS_BF42) U1.C43(MGTAVTT_LN_C43) U1.C45(MGTAVTT_LN_C45) U1.D4(MGTAVTT_RN_D4) U1.E42(MGTAVTT_LN_E42) U1.F5(MGTAVTT_RN_F5) U1.G7(MGTAVTT_RN_G7) U1.G43(MGTAVTT_LN_G43) U1.H4(MGTAVTT_RN_H4) U1.J6(MGTAVTT_RN_J6) U1.J42(MGTAVTT_LN_J42) U1.K5(MGTAVTT_RN_K5) U1.L7(MGTAVTT_RN_L7) U1.L40(MGTAVTTRCAL_LN_L40) U1.L43(MGTAVTT_LN_L43) U1.M4(MGTAVTT_RN_M4) U1.N5(MGTAVTT_RN_N5) U1.N6(MGTAVTT_RN_N6) U1.N42(MGTAVTT_LN_N42) U1.R7(MGTAVTT_RN_R7) U1.R43(MGTAVTT_LN_R43) U1.T41(MGTAVTT_LN_T41) U1.U6(MGTAVTT_RN_U6) U1.U42(MGTAVTT_LN_U42) U1.V40(MGTAVTT_LN_V40) U1.V43(MGTAVTT_LN_V43) U1.W7(MGTAVTT_RN_W7) U1.Y41(MGTAVTT_LN_Y41) Z130.2(NET2)
MGTAVTT_FPGA_SNS_N: U165.35(SENSE_N) Z131.1(NET1)
MGTAVTT_FPGA_SNS_P: U36.8(VBUS) U165.36(SENSE_P) Z130.1(NET1)
MGTAVTT_FPGA_VIN: C155.1(CAP2) R111.1 U36.9(VIN_N)
MGTAVTT_ISENSE2: R1226.2 R1270.2 U162.15(ISENSE)
MGTAVTT_PGOOD: D14.1(CATHODE) RP3.7 U5.7(SHDN_B) U51.8(A6) U165.24(PWRGD) U167.7(SHDN_B)
MGTAVTT_PWM2: U162.13(PWM) U165.17(PWM2)
MGTAVTT_SLAVE_1V8: C1617.1(CAP2) C1669.1(CAP2) C1670.1(CAP2) C1680.1(CAP2) L97.1 R1211.1 R1231.1 U162.11(VCC)
MGTAVTT_TS_FAULTB: C1716.1(CAP2) R1278.1 U165.19(TS_FAULTB)
MGTAVTT_VDD_MASTER: C1598.1(CAP2) C1668.1(CAP2) C1670.2(CAP1) R1199.1 R1231.2 U165.8(VDD)
MGTAVTT_VIN: C155.2(CAP1) R112.1 U36.10(VIN_P)
MGTAVTT_VIN_UV: C1715.1(CAP2) R1217.2 R1220.1 U165.14(VIN_UV)
MGTAVTT_VX2: C1703.1(CAP2) L88.1 U162.6(VX) U162.7(VX_1) U162.8(VX_2) U162.9(VX_3)
MGTRREF_121: R175.1 U1.BF43(MGTRREF_LS_BF43)
MGTRREF_126: R176.1 U1.L41(MGTRREF_LN_L41)
MGTRREF_226: R1088.1 U1.BD2(MGTRREF_RS_BD2)
MGTRREF_231: R1326.1 U1.A4(MGTRREF_RN_A4)
MGTVCCAUX_L: C711.1(CAP2) C713.1(CAP2) C924.1(CAP2) C1476.1(CAP2) C1483.1(CAP2) C1484.1(CAP2) C1485.1(CAP2) D39.1(CATHODE) R172.2 R1290.1 U1.AA38(MGTVCCAUX_LN_AA38) U1.AE38(MGTVCCAUX_LS_AE38) U1.AG39(MGTVCCAUX_LS_AG39) U1.W39(MGTVCCAUX_LN_W39)
MGTVCCAUX_PGOOD: D12.1(CATHODE) RP3.6 U5.6(RST_B) U51.9(A7) U167.6(RST_B)
