# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
5340N1586: length 7.7
  TOP w0.254: v2(212.56,81.96) 212.6,81.96 213.24,82.59 U11.12
  TOP w0.381: v1(209.17,80.99) 209.02,81.15 208.44,81.15 C150.1
  BOTTOM w0.152: v1(209.17,80.99) 210.01,80.15 212.1,80.15 212.56,80.6 R167.2 v2(212.56,81.96)
5340N1587: length 3.6
  TOP w0.216: C232.1 v2(216.88,82.16) 216.21,82.16 U11.16
  BOTTOM w0.152: C232.1 v2(216.88,82.16)
5340N1593: length 2
  TOP w0.216: C231.2 211.06,84.29 211.15,84.38 U11.10
5340N2428: length 2.9
  TOP w0.152: v1(208.27,82.58) 208.55,82.86 C233.2
  BOTTOM w0.152: R170.1 208.73,83.04 v1(208.27,82.58)
CLK_125MHZ_N: length 105.7
  TOP w0.104: v1(165.77,15.74) 166.11,16.08 166.11,16.23 166.01,16.33 165.66,16.33 165.42,16.57 165.42,16.81 165.29,16.94 U122.17 ; U1.AY23 v2(135.24,64.84)
  20_SIG7 w0.076: 142.15,64.2 142.13,64.2 142.09,64.24 136.96,64.24 136.64,64.56 136.64,65.65 136.34,65.95 135.31,65.95 135.24,65.88 v2(135.24,64.84)
  20_SIG7 w0.089: v1(165.77,15.74) 166.09,16.06 166.09,28.18 168.24,30.33 168.24,52.74 167.54,53.44 156.87,53.44 152.63,57.68 152.63,60.43 151.98,61.08 149.28,61.08 146.15,64.2 142.15,64.2
  BOTTOM w0.104: v2(135.24,64.84) 135.24,65.68 135.4,65.84 135.7,65.84 136.06,66.2 142.99,66.2 144.56,64.63 144.56,63.68 147.73,60.51 150.49,60.51 150.87,60.13 R188.1 R186.2 R150.1
CLK_125MHZ_P: length 105.5
  TOP w0.104: v1(166.69,15.74) 166.34,16.09 166.34,16.32 166.1,16.56 165.76,16.56 165.65,16.66 165.65,16.81 165.79,16.94 U122.18 ; U1.AY24 v2(135.24,66.84)
  20_SIG7 w0.076: v2(135.24,66.84) 135.24,66.23 135.31,66.15 136.42,66.15 136.84,65.74 136.84,64.65 137.04,64.44 142.09,64.44 142.13,64.48 142.15,64.48
  20_SIG7 w0.089: v1(166.69,15.74) 166.37,16.06 166.37,28.07 168.52,30.21 168.52,52.86 167.65,53.72 156.99,53.72 152.91,57.8 152.91,60.54 152.09,61.36 149.39,61.36 146.27,64.48 142.15,64.48
  BOTTOM w0.104: v2(135.24,66.84) 135.24,66.18 135.34,66.07 135.61,66.07 135.97,66.43 143.09,66.43 144.79,64.73 144.79,63.77 147.82,60.74 150.5,60.74 150.89,61.13 R187.1 R185.2 R150.2
COMBINED_PGOOD: length 264.4
  TOP w0.381: D7.1 v1(26.73,91.05)
  05_SIG2 w0.381: v1(43.69,154.58) 44.38,153.9 44.38,150.09 42.98,148.69 40.39,148.69 39.4,147.7 39.4,143.87 38.13,142.6 35.18,142.6 34.09,141.5 34.09,133.45 34.9,132.64 34.9,129.31 29.24,123.65 29.24,118.87 v1(27.05,116.69)
  20_SIG7 w0.381: v1(43.69,154.58) 44.37,155.27 46.66,155.27 47.67,156.28 47.67,167.01 49.82,169.15 53.47,169.15 57.65,173.33 182.48,173.33 187.02,168.78 188.54,168.78 v1(190.97,166.35) 193.99,169.37 v1(195.15,169.37) ; v1(26.73,91.05) 26.73,93.19 27.89,94.36 35.05,94.36 36.53,95.83 36.53,105.13 35.3,106.35 35.3,113.87 34.49,114.68 33.73,114.68 32.59,115.82 30.73,115.82 29.92,116.64 29.92,117.07 29.29,117.7 28.07,117.7 v1(27.05,116.69)
  BOTTOM w0.381: U109.15 v1(27.05,116.69) ; U71.2 v1(190.97,166.35)
  vias: v1(197.69,169.37) v1(200.23,169.37) v1(202.77,169.37) v1(205.31,169.37)
COMBINED_PGOOD_LS: length 72.8
  TOP w0.152: U111.R10 v5(9.9,132.57) ; D7.2 v1(26.92,87.35)
  05_SIG2 w0.173: v1(27.56,122.22) 27.56,121.97 24.83,119.24 24.83,103.37 25.91,102.29 25.91,101.02 26.31,100.61 26.31,98.5 25.27,97.46 25.27,93.19 26.17,92.3 26.17,88.11 v1(26.92,87.35)
  18_SIG6 w0.089: v5(9.9,132.57) 9.37,132.03 9.37,128.44 9.66,128.15 11.01,128.15 11.33,127.83 11.33,126.89 12.83,125.39 12.83,122.02 14.35,120.51 25.84,120.51 v1(27.56,122.22)
  BOTTOM w0.152: D7.2 v1(26.92,87.35) 26.5,87.78 J78.3 ; v1(27.56,122.22) 27.05,122.73 U109.6
CPU_RESET: length 149.7
  TOP w0.381: U1.L19 v2(105.24,60.84) ; v1(139.81,98.52) 138.31,97.01 127.78,97.01 126.81,97.98 126.81,100.81 126.86,100.86 126.86,100.88 128.24,102.26 128.24,108.96 127.39,109.82 124.94,109.82 124.19,110.56 117.44,110.56 116.95,111.06 116.95,112.24 116.53,112.65 109.14,112.65 106.43,115.37 106.43,123.32 103.8,125.95 103.8,127.19 104.5,127.89 104.5,131.47 104.88,131.85 SW5.4 107.93,131.85 v1(108.31,131.47) 115,131.47 SW5.3
  05_SIG2 w0.229: v2(105.24,60.84) 105.53,60.84 106.03,61.34 117.86,61.34 118.23,61.71 118.23,76.68 118.89,77.34 128.51,77.34 128.74,77.57 128.74,78.11 128.97,78.34 130.47,78.34 130.74,78.61 130.74,80.09 130.99,80.34 131.48,80.34 131.74,80.6 131.74,81.06 132.02,81.34 132.52,81.34 132.74,81.56 132.74,82.13 132.95,82.34 133.49,82.34 133.74,82.59 133.74,83.17 133.91,83.34 134.5,83.34 134.74,83.58 134.74,84.04 134.98,84.29 135.47,84.29 135.75,84.57 135.75,86.02 136.08,86.34 136.43,86.34 136.74,86.65 136.74,87.08 137,87.34 138.51,87.34 138.77,87.61 138.77,89.48
  05_SIG2 w0.381: 138.77,89.48 139.01,89.72 139.01,97.72 v1(139.81,98.52)
  BOTTOM w0.381: R52.1 108.28,131.5 v1(108.31,131.47)
DDR4_C1_A0: length 156.1
  TOP w0.152: v2(98.24,55.84) 98.74,56.34 U1.D14
  TOP w0.279: R238.2 v1(79.07,100.38)
  07_SIG3 w0.173: v4(69.96,37.44) 68.76,39.49 68.76,46.91 69.56,48.61 69.56,51.14 v4(69.96,51.54) 69.56,51.94 69.56,57.41 70.68,58.53 71.08,58.53 71.35,58.8 71.35,60.14 71.2,60.3 70.86,60.3 70.71,60.45 70.71,60.66 70.86,60.81 71.2,60.81 71.35,60.97 71.35,61.61 70.98,61.98 70.01,61.98 69.56,62.43 69.56,65.24 v4(69.96,65.64) 69.56,66.04 69.56,79.33 v4(69.96,79.73) 69.56,80.13 69.56,88.94 69.66,89.04 70.05,89.04 70.14,89.13 70.14,89.8 70.01,89.92 69.65,89.92 69.56,90.01 69.56,93.43 v4(69.96,93.83)
  20_SIG7 w0.089: v2(98.24,55.84) 98.24,55.75 98.74,55.25 98.74,54.64 99.03,54.34 99.53,54.34 99.72,54.15 99.72,51.61 99.99,51.34 100.36,51.34 100.74,50.96 100.74,42.57 ; v4(69.96,37.44) 69.56,37.04 68.19,37.04
  20_SIG7 w0.157: 100.74,42.57 100.74,42 99.77,41.03 99.77,35.76 98.82,34.81 97.63,34.81 96.68,33.87 96.68,31.96 95.44,30.71 83.25,30.71 82.69,31.26 69.63,31.26 67.33,33.56 67.33,36.18 68.19,37.04
  BOTTOM w0.152: 81.61,94.77 70.89,94.77 v4(69.96,93.83) U62.P3 ; U64.P3 v4(69.96,51.54) ; U63.P3 v4(69.96,79.73) ; U61.P3 v4(69.96,65.64) ; U60.P3 v4(69.96,37.44)
  BOTTOM w0.279: v1(79.07,100.38) 79.66,100.98 83.86,100.98 84.15,100.69 84.15,96.65 82.27,94.77 81.61,94.77
DDR4_C1_A1: length 148.1
  TOP w0.152: v2(96.24,56.84) 96.74,57.34 U1.B15
  TOP w0.279: R239.2 78.05,104.31 77.81,104.07 v1(77.48,104.07)
  03_SIG1 w0.173: v4(69.96,96.23) U62.P7 70.36,98.8 70.73,99.17 70.73,99.36
  03_SIG1 w0.292: 70.73,99.36 70.73,99.37 70.73,100.82 71.88,101.98 71.88,102.39 72.36,102.87 72.36,104.14 73.53,105.31 76.65,105.31 77.48,104.48 v1(77.48,104.07)
  14_SIG4 w0.089: v2(96.24,56.84) 95.74,56.34 95,56.34 94.89,56.23 94.39,56.23 ; v4(69.96,39.84) 70.37,39.43 70.97,39.43 71.52,39.98 71.52,41.16 72.02,41.66 72.02,41.66 72.2,41.84 72.52,41.84 72.76,42.08 72.76,42.53
  14_SIG4 w0.157: 72.76,42.53 73.16,42.93 73.16,43.46 73.04,43.59 72.32,43.59 72.19,43.71 72.19,43.96 72.32,44.09 73.04,44.09 73.16,44.21 73.16,45.04 73.04,45.17 72.23,45.17 72.11,45.29 72.11,45.54 72.23,45.67 73.04,45.67 73.16,45.79 73.16,46.93 73.31,47.08 73.62,47.08 73.76,46.95 73.76,43.2 73.89,43.08 74.13,43.08 74.26,43.2 74.26,46.5 74.38,46.62 74.63,46.62 74.76,46.5 74.76,43.2 74.88,43.08 75.13,43.08 75.25,43.2 75.25,44.41 75.38,44.53 76.39,44.53 76.51,44.65 76.51,44.9 76.39,45.03 75.38,45.03 75.25,45.15 75.25,45.4 75.38,45.53 76.39,45.53 76.51,45.65 76.51,45.9 76.39,46.02 75.38,46.02 75.25,46.15 75.25,46.5 75.38,46.62 76.86,46.62 77,46.48 77,45.67 77.13,45.54 77.54,45.54 77.67,45.67 77.67,47.13 77.94,47.4 79.95,47.4 80.07,47.52 80.07,47.72 80.2,47.84 80.45,47.84 80.57,47.72 80.57,47.52 80.7,47.4 81.33,47.4 84.95,51.02 85.51,51.02 90.97,56.47 93.21,56.47 93.45,56.23 94.39,56.23
  16_SIG5 w0.089: v4(69.96,39.84) 70.36,40.24 70.36,41.61 70.12,41.84 69.79,41.84 69.56,42.08 69.56,42.41 67.67,44.29 67.67,47.11 67.84,47.28 68.17,47.28 68.34,47.45 68.34,47.8 68.17,47.97 67.84,47.97 67.67,48.15 67.67,49.02 68.19,49.54 68.52,49.54 68.76,49.77 68.76,50.1 68.99,50.34 69.32,50.34 69.56,50.57 69.56,53.54 v4(69.96,53.94) 69.56,54.34 69.56,54.92 69.54,54.92 69.32,55.14 68.99,55.14 68.76,55.38 68.76,58.65 68.58,58.83 68.35,58.83 68.18,59 68.18,59.34 68.35,59.52 68.58,59.52 68.76,59.69 68.76,60.04 68.58,60.21 68.35,60.21 68.18,60.38 68.18,60.73 68.35,60.9 68.58,60.9 68.76,61.07 68.76,61.42 68.58,61.59 68.35,61.59 68.18,61.76 68.18,62.11 68.35,62.28 68.58,62.28 68.76,62.45 68.76,65 68.99,65.24 69.32,65.24 69.56,65.47 69.56,67.64 v4(69.96,68.04) 69.56,68.43 69.56,74.36 69.69,74.5 69.69,75.43 69.56,75.56 69.56,81.73 v4(69.96,82.13) 69.56,82.53 69.56,83.19 69.41,83.33 68.92,83.33 68.76,83.49 68.76,86.03 68.67,86.12 68.49,86.12 68.4,86.21 68.4,86.48 68.49,86.56 68.67,86.56 68.76,86.65 68.76,89.21 69.56,90.01 69.56,95.83 v4(69.96,96.23)
  BOTTOM w0.152: U61.P7 v4(69.96,68.04) ; U64.P7 v4(69.96,53.94) ; U62.P7 v4(69.96,96.23) ; U63.P7 v4(69.96,82.13) ; U60.P7 v4(69.96,39.84)
DDR4_C1_A2: length 149.7
  TOP w0.152: U1.B16 96.74,58.34 v2(96.24,57.84)
  TOP w0.279: R255.2 83.64,100.53 v1(83.51,100.4)
  07_SIG3 w0.173: v4(69.16,37.44) 67.96,38.64 67.96,45.66 68.01,45.71 68.28,45.71 68.37,45.8 68.37,46.28 68.27,46.38 68.05,46.38 67.96,46.47 67.96,47.79 68.76,48.59 68.76,51.14 v4(69.16,51.54) 68.76,51.94 68.76,56.87 68.52,57.11 68.06,57.11 67.88,57.28 67.88,58.71 68.21,59.03 68.64,59.03 68.74,59.13 68.74,60.8 68.65,60.89 67.74,60.89 67.65,60.98 67.65,62.06 67.87,62.28 68.54,62.28 68.76,62.5 68.76,65.24 v4(69.16,65.64) 68.76,66.04 68.76,79.33 v4(69.16,79.73) 68.76,80.13 68.76,88.62 68.67,88.71 68.24,88.71 68.11,88.84 68.11,89.65 68.19,89.74 68.67,89.74 68.76,89.83 68.76,93.43 v4(69.16,93.83)
  16_SIG5 w0.089: v2(96.24,57.84) 96.53,57.84 97.03,58.34 97.44,58.34 97.74,58.05 97.74,57.64 98.03,57.34 99.44,57.34 99.74,57.05 99.74,56.72 99.74,56.64 100.03,56.34 100.12,56.34 100.12,56.34 100.44,56.34 100.74,56.05 100.74,55.72 100.74,55.64 101.03,55.34 101.12,55.34 101.12,55.34 101.44,55.34 101.74,55.05 101.74,54.64 101.44,54.34 101.03,54.34 100.74,54.05 100.74,53.74 100.74,42.54 100.61,42.41 ; v4(69.16,37.44) 69.42,37.44 69.56,37.3 69.56,35.68 69.79,35.44 81.36,35.44 81.53,35.28 81.61,35.28
  16_SIG5 w0.157: 100.61,42.41 92.57,34.37 90.78,34.37 90.33,34.82 90.33,36.36 89.15,37.54 87.09,37.54 86.16,36.62 86.16,35.25 85.16,34.25 84,34.25 82.97,35.28 81.61,35.28
  BOTTOM w0.152: U64.R3 v4(69.16,51.54) ; U62.R3 v4(69.16,93.83) 69.16,94.68 69.83,95.36 81.61,95.36 ; U61.R3 v4(69.16,65.64) ; U63.R3 v4(69.16,79.73) ; U60.R3 v4(69.16,37.44)
  BOTTOM w0.279: 81.61,95.36 83.51,97.26 v1(83.51,100.4)
DDR4_C1_A3: length 141.5
  TOP w0.152: v2(97.24,55.84) 97.74,56.34 U1.C14
  TOP w0.279: R254.2 74.49,100.53 74.64,100.38 v1(74.71,100.38)
  05_SIG2 w0.173: v1(74.71,100.38) 74.71,99.84 74.09,99.21 73.18,99.21 72.76,98.79 72.76,97.66 72.52,97.43 71.96,97.43 v4(70.76,96.23)
  16_SIG5 w0.089: v2(97.24,55.84) 96.74,55.34 96.74,43.57 ; 82.3,37.9 80.07,37.9 79.89,38.07 79.89,38.61 79.72,38.78 79.37,38.78 79.2,38.61 79.2,38.07 79.03,37.9 78.68,37.9 78.51,38.07 78.51,38.93 78.35,39.1 78,39.1 77.82,38.92 77.82,38.07 77.65,37.9 77.3,37.9 77.13,38.07 77.13,38.93 76.96,39.1 76.62,39.1 76.44,38.92 76.44,38.07 76.27,37.9 75.92,37.9 75.75,38.07 75.75,38.93 75.58,39.1 75.24,39.1 75.06,38.92 75.06,38.07 74.88,37.9 74.6,37.9 73.74,37.04 71.39,37.04 71.16,37.28 71.16,37.79 70.76,38.2 v4(70.76,39.84) 71.16,40.24 71.16,43.02 70.95,43.23 70.07,43.23 69.6,43.7 69.6,44.95 69.77,45.13 70.28,45.13 70.46,45.3 70.46,45.64 70.28,45.82 69.77,45.82 69.6,45.99 69.6,46.31 69.79,46.5 70.14,46.5 70.27,46.63 70.27,48 70.4,48.13 70.92,48.13 71.16,48.37 71.16,53.54 v4(70.76,53.94) 71.16,54.34 71.16,57.45 70.98,57.63 70.24,57.63 70.07,57.8 70.07,58.14 70.24,58.32 70.98,58.32 71.16,58.49 71.16,60.8 71.01,60.94 70.6,60.94 70.36,61.18 70.36,63.4 70.59,63.64 70.92,63.64 71.16,63.87 71.16,67.64 v4(70.76,68.04) 71.16,68.43 71.16,81.73 v4(70.76,82.13) 71.16,82.53 71.16,85.32 70.64,85.84 70.2,85.84 70.03,86.01 70.03,86.36 70.2,86.53 70.64,86.53 70.81,86.7 70.81,90.92 71.16,91.26 71.16,93.99 70.76,94.39 v4(70.76,96.23)
  16_SIG5 w0.157: 82.3,37.9 82.4,37.9 82.6,38.1 83.07,38.1 83.29,37.87 83.29,37.52 83.83,36.99 84.17,36.99 84.89,37.71 84.89,38.22 84,39.11 84,39.53 84.63,40.16 85.01,40.16 85.91,39.26 94.12,39.26 95.11,40.26 95.11,44.18 95.24,44.31 95.63,44.31 95.73,44.21 95.73,40.61 95.97,40.37 96.55,40.37 96.74,40.55 96.74,43.57
  BOTTOM w0.152: U64.N7 v4(70.76,53.94) ; U60.N7 v4(70.76,39.84) ; U61.N7 v4(70.76,68.04) ; U63.N7 v4(70.76,82.13) ; U62.N7 v4(70.76,96.23)
DDR4_C1_A4: length 145.3
  TOP w0.152: U1.C15 97.74,57.34 v2(97.24,56.84)
  TOP w0.279: R252.2 v1(76.53,100.38)
  07_SIG3 w0.173: v4(70.76,93.83) 71.28,94.36 71.28,97.35 71.83,97.9 71.83,98.74 72.17,99.09 74.24,99.09 74.52,99.36
  07_SIG3 w0.292: v1(76.53,100.38) 76.53,99.78 76.38,99.64 74.8,99.64 74.52,99.36
  18_SIG6 w0.089: v4(70.76,93.83) 71.16,93.43 71.16,91.06 70.81,90.71 70.81,89.73 70.98,89.55 71.42,89.55 71.59,89.38 71.59,89.04 71.42,88.86 70.98,88.86 70.81,88.69 70.81,86.32 71.16,85.98 71.16,81.16 70.76,80.77 v4(70.76,79.73) 70.76,79.5 71.16,79.1 71.16,75.56 71.07,75.47 70.94,75.47 70.85,75.38 70.85,75.12 70.94,75.03 71.07,75.03 71.16,74.94 71.16,66.81 70.76,66.41 v4(70.76,65.64) 70.76,65.42 71.16,65.03 71.16,63.87 71.39,63.63 71.72,63.63 71.96,63.4 71.96,61.95 72.82,61.08 72.82,59.38 72.69,59.24 72.42,59.24 72.25,59.42 72.25,59.59 72.05,59.79 71.71,59.79 71.55,59.64 71.55,58.54 71.16,58.14 71.16,53.4 70.76,53 v4(70.76,51.54) 70.76,51.32 71.16,50.92 71.16,46.64 71.33,46.47 72.54,46.47 72.71,46.3 72.71,45.95 72.54,45.78 71.33,45.78 71.16,45.61 71.16,39.57 70.76,39.17 v4(70.76,37.44)
  20_SIG7 w0.089: 67.96,36.01 68.19,36.24 70.12,36.24 70.36,36.48 70.36,37.04 v4(70.76,37.44) ; 99.74,42.72 99.74,51.04 99.44,51.33 98.93,51.33 98.74,51.53 98.74,54.08 98.47,54.34 98.03,54.34 97.74,54.64 97.74,56.05 97.24,56.55 v2(97.24,56.84)
  20_SIG7 w0.157: 67.96,36.01 67.96,34.84 68.12,34.67 68.12,33.9 69.96,32.06 84.63,32.06 85.19,31.51 93.01,31.51 94.06,32.56 94.06,34.63 94.47,35.04 94.89,35.04 95.17,34.76 95.61,34.76 96.05,35.2 96.05,35.52 95.71,35.87 95.71,36.28 96.12,36.69 96.54,36.69 96.86,36.37 98.06,36.37 98.76,37.07 98.76,41.34 99.74,42.32 99.74,42.72
  BOTTOM w0.152: U64.N3 v4(70.76,51.54) ; U60.N3 v4(70.76,37.44) ; U63.N3 v4(70.76,79.73) ; U61.N3 v4(70.76,65.64) ; U62.N3 v4(70.76,93.83)
DDR4_C1_A5: length 137.2
  TOP w0.152: v2(95.24,54.84) 95.74,55.34 U1.A13
  TOP w0.279: R253.2 v1(75.51,103.97)
  07_SIG3 w0.173: 71.4,99.36 71.23,99.2 71.23,98.42 71.04,98.23 70.36,98.23 v4(69.96,97.83) U62.P8 70.36,90.34 70.45,90.25 70.95,90.25 71.06,90.14 71.06,88.96 70.91,88.81 70.44,88.81 70.2,88.57 70.2,86.02 70.36,85.87 70.36,84.13 v4(69.96,83.73) 70.36,83.33 70.36,73.56 70.69,73.23 70.69,72.42 70.36,72.08 70.36,70.04 v4(69.96,69.64) U61.P8 70.36,62.81 70.66,62.5 71.67,62.5 71.96,62.21 71.96,61.01 72.11,60.86 72.29,60.86 72.44,60.7 72.44,60.49 72.29,60.34 72.11,60.34 71.96,60.19 71.96,58.12 71.83,58 70.75,58 70.36,57.6 70.36,55.94 v4(69.96,55.54) U64.P8 70.36,45.35 70.56,45.15 70.56,43.97 70.36,43.77 70.36,41.84 v4(69.96,41.44)
  07_SIG3 w0.292: v1(75.51,103.97) 74.91,103.37 74.91,101.64 74.08,100.81 74.08,100.03 73.8,99.75 71.78,99.75 71.4,99.36
  20_SIG7 w0.089: v4(69.96,41.44) 70.36,41.04 70.92,41.04 71.35,40.62 71.35,39.07 72.76,37.66 72.76,37.28 72.99,37.04 73.46,37.04 73.8,36.7 73.8,35.83 74.19,35.44 81.61,35.44
  20_SIG7 w0.157: 81.61,35.44 83.99,35.44 91.52,42.98 91.52,43.34 91.22,43.63 89.29,43.63 89.04,43.88 89.04,44.55 89.29,44.8 91.16,44.8 91.46,45.09 91.46,45.68 91.16,45.97 89.29,45.97 89.04,46.22 89.04,46.89 89.29,47.14 91.16,47.14 91.46,47.43 91.46,48.02 91.16,48.31 89.29,48.31 89.04,48.56 89.04,49.23 89.29,49.48 91.16,49.48 91.46,49.77 91.46,50.35 91.16,50.64 89.29,50.64 89.04,50.89 89.04,51.56 89.29,51.81 91.16,51.81 91.46,52.1 91.46,53.15 93.15,54.84 v2(95.24,54.84)
  BOTTOM w0.152: U64.P8 v4(69.96,55.54) ; U62.P8 v4(69.96,97.83) ; U61.P8 v4(69.96,69.64) ; U60.P8 v4(69.96,41.44) ; U63.P8 v4(69.96,83.73)
DDR4_C1_A6: length 148.7
  TOP w0.152: v2(95.24,55.84) 95.74,56.34 U1.A14
  TOP w0.279: R241.2 79.32,104.26 v1(79.67,103.91)
  03_SIG1 w0.173: 74.74,99.36 74.36,98.98 74.36,95.79 72.87,94.31 72.76,94.19 72.76,93.66 72.52,93.43 72.19,93.43 72.19,93.43 71.96,93.19 71.96,93.19 71.96,92.86 71.72,92.63 71.39,92.63 71.16,92.39 71.16,92.06 70.92,91.83 70.36,91.83 v4(69.96,92.23)
  03_SIG1 w0.292: 74.74,99.36 75.22,99.84 75.22,101.03 75.91,101.73 76.88,101.73 78.81,103.66 79.41,103.66 v1(79.67,103.91)
  18_SIG6 w0.089: v4(69.96,92.23) 69.56,91.83 69.56,90.74 68.76,89.94 68.76,78.77 68.99,78.53 69.32,78.53 69.72,78.13 v4(69.96,78.13) 69.56,77.73 69.56,77.03 68.76,76.23 68.76,64.67 68.99,64.43 69.32,64.43 69.72,64.04 v4(69.96,64.04) 69.56,63.63 69.56,61.9 69.68,61.78 69.92,61.78 70.15,61.55 70.15,61.03 69.88,60.76 69.25,60.76 68.76,60.26 68.76,53.61 68.59,53.44 68.11,53.44 67.94,53.27 67.94,52.12 68.07,51.99 68.48,51.99 68.76,51.72 68.76,50.57 68.99,50.34 69.32,50.34 69.72,49.94 v4(69.96,49.94) 69.56,49.54 69.56,48.75 67.61,46.8 67.61,41.22 67.78,41.04 68.62,41.04 68.76,40.9 68.76,39.65 67.97,38.87 67.97,38.48 68.76,37.69 68.76,36.48 68.99,36.24 69.32,36.24 69.72,35.84 v4(69.96,35.84)
  20_SIG7 w0.089: 71.16,34.88 71.16,35.21 70.92,35.44 70.36,35.44 v4(69.96,35.84) ; 94.79,54.21 94.92,54.34 95.44,54.34 95.74,54.64 95.74,55.05 95.24,55.55 v2(95.24,55.84)
  20_SIG7 w0.157: 71.16,34.88 71.92,34.12 83.91,34.12 88.81,39.01 89.22,39.01 90.48,37.76 90.89,37.76 91.3,38.17 91.3,38.59 90.05,39.84 90.05,40.25 90.46,40.67 90.88,40.67 92.13,39.41 92.54,39.41 92.96,39.83 92.96,40.24 91.7,41.49 91.7,41.91 92.12,42.32 92.53,42.32 93.78,41.07 94.19,41.07 94.61,41.48 94.61,41.89 93.35,43.15 93.35,43.56 93.6,43.81 93.6,44.32 93.31,44.61 92.57,44.61 92.28,44.91 92.28,45.49 92.57,45.78 93.31,45.78 93.6,46.08 93.6,46.66 93.31,46.95 92.57,46.95 92.28,47.24 92.28,47.83 92.57,48.12 93.39,48.12 93.68,48.41 93.68,49 93.39,49.29 92.57,49.29 92.28,49.58 92.28,50.16 92.57,50.46 93.31,50.46 93.6,50.75 93.6,53.03 94.79,54.21
  BOTTOM w0.152: U62.P2 v4(69.96,92.23) ; U64.P2 v4(69.96,49.94) ; U61.P2 v4(69.96,64.04) ; U63.P2 v4(69.96,78.13) ; U60.P2 v4(69.96,35.84)
DDR4_C1_A7: length 147.8
  TOP w0.152: U1.A15 95.74,57.34 v2(95.24,56.84)
  TOP w0.279: R240.2 80.16,101.32 79.94,101.1 v1(79.94,100.38)
  05_SIG2 w0.173: 72.53,99.36 71.96,98.8 71.96,98.46 70.92,97.43 U62.R8 v4(69.16,97.83)
  05_SIG2 w0.292: v1(79.94,100.38) 79.32,101 74.46,101 74.07,100.61 74.07,100.17 73.73,99.83 72.99,99.83 72.53,99.36
  14_SIG4 w0.089: v2(95.24,56.84) 94.49,56.84 94.39,56.95 ; 71.76,46.19 71.76,41.83 70.98,41.04 69.55,41.04 v4(69.16,41.44)
  14_SIG4 w0.157: 71.76,46.19 74.17,48.6 74.54,48.6 74.67,48.48 74.67,47.3 74.79,47.18 75.04,47.18 75.16,47.3 75.16,48.48 75.29,48.6 75.54,48.6 75.66,48.48 75.66,47.3 75.79,47.18 76.04,47.18 76.16,47.3 76.16,48.48 76.28,48.6 76.53,48.6 76.66,48.48 76.66,47.3 76.78,47.18 77.03,47.18 77.16,47.3 77.16,48.48 77.28,48.6 78,48.6 78.12,48.48 78.12,48.01 78.25,47.89 78.49,47.89 78.62,48.01 78.62,48.48 78.74,48.6 81.46,48.6 82.07,49.2 82.07,52.33 82.28,52.54 83.07,52.54 83.34,52.27 83.34,51.23 83.59,50.98 83.95,50.98 84.18,51.21 84.18,52.39 84.33,52.54 84.8,52.54 85.01,52.76 85.01,53.19 84.8,53.41 84.23,53.41 83.76,53.87 82.96,53.87 82.49,53.41 81.9,53.41 81.68,53.62 81.68,55.22 81.87,55.4 86,55.4 86.21,55.19 86.21,53.8 86.46,53.54 87.09,53.54 87.61,54.06 87.61,56.51 87.84,56.74 88.23,56.74 88.47,56.51 88.47,55.89 88.7,55.65 89.14,55.65 89.33,55.85 89.33,57.12 89.62,57.4 93.93,57.4 94.39,56.95
  20_SIG7 w0.089: v4(69.16,97.83) 68.76,97.43 68.76,90.33 68.59,90.16 68.28,90.16 68.1,89.99 68.1,89.64 68.28,89.47 68.59,89.47 68.76,89.3 68.76,88.71 68.59,88.54 68.28,88.54 68.1,88.36 68.1,88.02 68.28,87.85 68.59,87.85 68.76,87.67 68.76,84.13 v4(69.16,83.73) 69.56,83.33 69.56,76.21 69.47,76.12 69.37,76.12 69.28,76.03 69.28,75.77 69.37,75.68 69.47,75.68 69.56,75.59 69.56,75.32 69.47,75.23 69.37,75.23 69.28,75.14 69.28,74.88 69.37,74.79 69.47,74.79 69.56,74.7 69.56,73.17 69.22,72.83 69.22,71.92 69.56,71.59 69.56,70.03 v4(69.16,69.64) 68.76,69.23 68.76,68.57 68.62,68.43 68.06,68.43 67.57,67.95 67.57,60.27 67.81,60.03 67.81,59.22 67.98,59.05 68.66,59.05 68.84,58.87 68.84,58.52 68.68,58.36 67.98,58.36 67.81,58.19 67.81,57.51 68.76,56.57 68.76,55.94 v4(69.16,55.54) 68.76,55.14 68.76,53.03 66.4,50.67 66.4,45.31 67.85,43.86 67.85,43.73 67.59,43.46 67.59,43.34 67.77,43.15 67.9,43.15 68.17,43.42 68.29,43.42 68.76,42.95 68.76,41.84 v4(69.16,41.44)
  BOTTOM w0.152: U64.R8 v4(69.16,55.54) ; U60.R8 v4(69.16,41.44) ; U61.R8 v4(69.16,69.64) ; U62.R8 v4(69.16,97.83) ; U63.R8 v4(69.16,83.73)
DDR4_C1_A8: length 158.8
  TOP w0.152: U1.A16 95.74,58.34 v2(95.24,57.84)
  TOP w0.279: R245.2 v1(83.13,103.95)
  03_SIG1 w0.173: 69.56,99.36 69.56,92.86 69.16,92.46 v4(69.16,92.23)
  03_SIG1 w0.292: v1(83.13,103.95) 81.91,105.17 79.2,105.17 78.39,105.98 72.52,105.98 71.01,104.47 71.01,102.58 69.56,101.13 69.56,99.36
  16_SIG5 w0.089: v4(69.16,35.84) 69.16,35.64 69.56,35.24 69.56,34.95 69.7,34.69 69.85,34.59 ; 101.58,42.25 101.74,42.41 101.74,53.05 102.03,53.34 102.19,53.34 102.19,53.34 102.44,53.34 102.74,53.63 102.74,55.05 102.44,55.34 102.03,55.34 101.74,55.64 101.74,55.64 101.74,56.05 101.45,56.34 101.03,56.34 100.74,56.64 100.74,56.65 100.74,57.03 100.74,57.04 100.74,57.05 100.44,57.34 100.09,57.34 100.08,57.34 100.03,57.34 99.74,57.64 99.74,58.05 99.44,58.34 98.07,58.34 98.03,58.34 97.74,58.64 97.74,59.02 97.74,59.02 97.74,59.05 97.44,59.34 97.03,59.34 96.74,59.05 96.74,58.68 96.74,58.68 96.74,58.64 96.44,58.34 96.4,58.34 96.4,58.34 96.03,58.34 95.53,57.84 v2(95.24,57.84)
  16_SIG5 w0.157: 101.58,42.25 92.9,33.57 91.33,33.57 91.17,33.42 83.25,33.42 81.63,34.08 70.62,34.08 69.85,34.59
  18_SIG6 w0.089: v4(69.16,35.84) 68.95,35.84 68.55,36.24 68.19,36.24 65.81,38.62 65.81,41.3 66.29,41.77 66.29,44.09 66.58,44.38 66.7,44.38 67.07,44.75 67.07,45.17 66.29,45.96 66.29,46.51 68.76,48.97 68.76,49.54 v4(69.16,49.94) 68.95,49.94 68.55,50.34 68.11,50.34 67.94,50.51 67.94,51.17 67.56,51.54 67.56,57.01 67.74,57.18 67.97,57.18 68.15,57.35 68.15,57.7 67.97,57.87 67.74,57.87 67.56,58.05 67.56,58.39 67.74,58.56 67.97,58.56 68.15,58.74 68.15,59.08 67.97,59.25 67.74,59.25 67.56,59.43 67.56,60.08 67.94,60.46 67.94,61.99 68.76,62.81 68.76,63.63 v4(69.16,64.04) 68.95,64.04 68.55,64.44 68.19,64.44 67.94,64.69 67.94,76.06 68.76,76.88 68.76,77.73 v4(69.16,78.13) 68.92,78.13 68.52,78.53 68.19,78.53 67.96,78.77 67.96,90.09 68.76,90.89 68.76,91.83 v4(69.16,92.23)
  BOTTOM w0.152: U64.R2 v4(69.16,49.94) ; U62.R2 v4(69.16,92.23) ; U63.R2 v4(69.16,78.13) ; U61.R2 v4(69.16,64.04) ; U60.R2 v4(69.16,35.84)
DDR4_C1_A9: length 157.1
  TOP w0.152: U1.B12 v2(96.24,53.84)
  TOP w0.279: v1(84.59,104.03) 84.4,104.22 R244.2
  03_SIG1 w0.173: 68.65,99.36 68.76,99.26 68.76,96.63 v4(69.16,96.23)
  03_SIG1 w0.292: v1(84.59,104.03) 84.19,104.03 82.37,105.84 79.48,105.84 78.67,106.65 71.41,106.65 69.78,105.03 69.78,102.49 68.36,101.06 68.36,99.66 68.65,99.36
  07_SIG3 w0.173: 94.39,52.77 94.95,53.34 95.74,53.34 v2(96.24,53.84) ; 73.56,42.77 73.56,39.68 73.32,39.44 72.84,39.44 71.58,38.18 70.82,38.18 v4(69.16,39.84)
  07_SIG3 w0.292: 73.56,42.77 73.56,44.22 73.73,44.39 75.62,44.39 75.79,44.56 75.79,44.8 75.62,44.97 73.73,44.97 73.56,45.14 73.56,45.39 73.73,45.56 75.62,45.56 75.79,45.73 75.79,45.97 75.62,46.14 73.73,46.14 73.56,46.31 73.56,46.55 73.73,46.73 75.62,46.73 75.79,46.9 75.79,47.14 75.62,47.31 73.73,47.31 73.56,47.48 73.56,47.89 74,48.33 76.3,48.33 76.47,48.16 76.47,45.43 76.64,45.26 76.89,45.26 77.06,45.43 77.06,48.16 77.23,48.33 81.84,48.33 82.47,48.96 82.47,49.2 82.04,49.64 82.04,49.88 82.21,50.05 82.45,50.05 82.89,49.62 83.13,49.62 83.94,50.43 83.94,50.67 83.33,51.29 83.33,51.53 83.5,51.7 83.74,51.7 84.25,51.19 85.68,51.19 87.09,52.59 94.2,52.59 94.39,52.77
  16_SIG5 w0.089: 67.56,42.29 68.01,41.84 69.32,41.84 69.56,41.61 69.56,40.24 v4(69.16,39.84) ; 67.56,49.72 68.18,50.34 68.52,50.34 68.76,50.58 68.76,53.54 v4(69.16,53.94) 68.76,54.34 67.91,54.34 67.72,54.53 67.72,57.1 67.81,57.19 68.29,57.19 68.38,57.28 68.38,57.55 68.29,57.63 67.81,57.63 67.72,57.72 67.72,58.08 67.81,58.16 68.11,58.16 68.2,58.25 68.2,58.52 68.11,58.61 67.81,58.61 67.72,58.7 67.72,64.76 68.19,65.23 68.52,65.23 68.76,65.47 68.76,67.64 v4(69.16,68.04) 68.76,68.43 68.76,74.69 68.85,74.78 69.08,74.78 69.17,74.87 69.17,75.14 69.08,75.23 68.85,75.23 68.76,75.31 68.76,81.73 v4(69.16,82.13) 68.76,82.53 68.13,82.53 67.95,82.71 67.95,89.19 68.76,90 68.76,95.83 v4(69.16,96.23)
  16_SIG5 w0.157: 67.56,49.72 66.43,48.59 66.43,44.76 67.24,43.96 67.24,42.61 67.56,42.29
  BOTTOM w0.152: U61.R7 v4(69.16,68.04) ; U64.R7 v4(69.16,53.94) ; U62.R7 v4(69.16,96.23) ; U63.R7 v4(69.16,82.13) ; U60.R7 v4(69.16,39.84)
DDR4_C1_A10: length 144.7
  TOP w0.152: U1.C12 v2(97.24,53.84)
  TOP w0.279: R243.2 76.78,104.08 v1(76.7,103.99)
  03_SIG1 w0.173: v4(71.56,93.83) 71.56,98.66 71.88,98.98 71.88,99.36
  03_SIG1 w0.292: v1(76.7,103.99) 76.7,103.95 76.01,103.26 75.02,103.26 74.21,102.46 73.34,102.46 71.88,101.01 71.88,99.36
  07_SIG3 w0.173: 74.36,42.51 74.36,39.68 74.03,39.34 74.03,38.17 73.79,37.94 72.05,37.94 v4(71.56,37.44) ; 94.39,50.45 94.48,50.45 94.65,50.62 94.65,52.03 94.96,52.34 96.44,52.34 96.74,52.64 96.74,53.34 v2(97.24,53.84)
  07_SIG3 w0.292: 94.39,50.45 94.25,50.45 94.1,50.6 94.1,51.7 93.93,51.87 93.62,51.87 93.46,51.71 93.46,50.27 93.3,50.11 92.99,50.11 92.83,50.27 92.83,51.71 92.67,51.87 92.36,51.87 92.2,51.71 92.2,50.27 92.04,50.11 91.73,50.11 91.57,50.27 91.57,51.71 91.41,51.87 91.1,51.87 90.94,51.71 90.94,50.27 90.79,50.11 90.47,50.11 90.31,50.27 90.31,51.71 90.16,51.87 89.84,51.87 89.68,51.71 89.68,50.27 89.53,50.11 89.21,50.11 89.05,50.27 89.05,51.71 88.9,51.87 88.58,51.87 88.42,51.71 88.42,50.39 88.25,50.22 88.03,50.22 86.96,51.29 86.74,51.29 86.52,51.07 86.52,50.84 87.59,49.77 87.59,49.55 87.36,49.33 87.12,49.33 86.48,49.97 86.26,49.97 86.04,49.75 86.04,49.52 86.7,48.87 86.7,48.66 85.91,47.87 85.43,47.87 84.33,48.97 84.05,48.97 83.83,48.75 83.83,48.55 84.16,48.23 84.16,47.82 83.86,47.52 82.06,47.52 81.99,47.59 80.09,47.59 79.72,47.22 79.48,47.22 79.05,47.65 78.81,47.65 78.64,47.48 78.64,47.23 79.07,46.81 79.07,46.56 78.9,46.39 78.66,46.39 78.23,46.82 77.99,46.82 77.82,46.65 77.82,46.41 78.24,45.98 78.24,45.74 75.6,43.1 74.78,43.1 74.36,42.67 74.36,42.51
  16_SIG5 w0.089: v4(71.56,93.83) 71.96,93.43 71.96,90.92 71.78,90.75 71.33,90.75 71.17,90.58 71.17,90.24 71.35,90.05 71.78,90.05 71.96,89.88 71.96,88.46 71.74,88.24 71.74,79.92 v4(71.56,79.73) 71.96,79.33 71.96,66.03 v4(71.56,65.64) 71.96,65.24 71.96,62.46 71.78,62.29 70.99,62.29 70.82,62.12 70.82,61.77 70.99,61.6 71.78,61.6 71.96,61.43 71.96,58.02 71.78,57.85 71.69,57.85 71.52,57.68 71.52,57.33 71.69,57.16 71.78,57.16 71.96,56.99 71.96,56.64 71.78,56.47 71.69,56.47 71.52,56.3 71.52,55.95 71.69,55.78 71.78,55.78 71.96,55.61 71.96,51.94 v4(71.56,51.54) 71.96,51.14 71.96,47.4 71.78,47.23 71.32,47.23 71.15,47.05 71.15,46.71 71.32,46.54 71.78,46.54 71.96,46.36 71.96,46.02 71.78,45.84 71.32,45.84 71.15,45.67 71.15,45.33 71.32,45.15 71.78,45.15 71.96,44.98 71.96,44.64 71.78,44.46 71.32,44.46 71.15,44.29 71.15,43.94 71.32,43.77 71.78,43.77 71.96,43.6 71.96,39.5 71.56,39.1 v4(71.56,37.44)
  BOTTOM w0.152: U60.M3 v4(71.56,37.44) ; U63.M3 v4(71.56,79.73) ; U64.M3 v4(71.56,51.54) ; U61.M3 v4(71.56,65.64) ; U62.M3 v4(71.56,93.83)
DDR4_C1_A11: length 164
  TOP w0.152: U1.B13 96.74,55.34 v2(96.24,54.84)
  TOP w0.279: v1(85.92,100.4) 85.92,101.07 R242.2
  18_SIG6 w0.089: v4(68.36,35.84) 67.34,35.84 64.68,38.51 64.68,43.25 65.52,44.09 65.52,47.1 v4(68.36,49.94) 67.93,49.94 65.57,52.3 65.57,54.35 65.89,54.67 65.89,55.83 65.02,56.7 65.02,59.07 67.48,61.52 67.48,63.16 v4(68.36,64.04) 68.05,64.04 66.92,65.17 66.92,76.7 v4(68.36,78.13) 67.83,78.13 67.46,78.5 67.46,91.33 v4(68.36,92.23)
  20_SIG7 w0.089: 69.56,34.88 69.56,35.2 69.32,35.44 68.76,35.44 v4(68.36,35.84) ; v2(96.24,54.84) 96.74,54.34 97.44,54.34 97.74,54.05 97.74,50.56 97.95,50.35 98.14,50.35 98.14,50.35 98.54,50.35 98.74,50.15 98.74,42.77
  20_SIG7 w0.157: 98.74,42.77 98.74,42.41 97.76,41.43 97.76,40.05 97.15,39.44 96.77,39.44 95.49,40.71 95.08,40.71 94.67,40.3 94.67,39.89 95.57,38.98 95.57,38.56 95.16,38.15 94.75,38.15 93.84,39.06 93.43,39.06 93.02,38.65 93.02,38.24 94.34,36.91 94.34,36.5 93.92,36.09 93.51,36.09 92.19,37.41 91.78,37.41 91.36,37 91.36,36.58 92.68,35.26 92.68,34.56 92.29,34.17 90.53,34.17 89.8,33.43 85.07,33.43 84.5,32.86 71.57,32.86 69.56,34.88
  BOTTOM w0.152: U64.T2 v4(68.36,49.94) ; U63.T2 v4(68.36,78.13) ; U62.T2 v4(68.36,92.23) 67.97,92.23 67.56,92.63 ; U61.T2 v4(68.36,64.04) ; U60.T2 v4(68.36,35.84)
  BOTTOM w0.279: v1(85.92,100.4) 84.36,101.96 66.87,101.96 65.61,100.7 65.61,97.58 66.88,96.32 66.88,93.32 67.56,92.63
DDR4_C1_A12: length 140.2
  TOP w0.152: v2(97.24,54.84) 97.74,55.34 U1.C13
  TOP w0.279: v1(68.96,100.31) 69.16,100.51 R247.2
  05_SIG2 w0.173: 67.56,99.36 67.57,99.36 ; 67.56,96.2 67.99,95.78 71.91,95.78 v4(72.36,96.23)
  05_SIG2 w0.292: 67.57,99.36 68.51,100.31 v1(68.96,100.31) ; 67.56,99.36 67.22,99.02 67.22,96.55 67.56,96.2
  07_SIG3 w0.173: v4(72.36,39.84) U60.M7 71.96,53.54 v4(72.36,53.94) 72.76,54.34 72.76,57.34 73.34,57.93 74.83,57.93 75.3,58.4 75.3,59.71 74.96,60.05 74.96,61.65 74.64,61.96 73.83,61.96 73.63,62.16 73.63,65.77 72.36,67.04 v4(72.36,68.04) 71.68,68.71 71.68,70.46 71.27,70.87 71.27,76.35 71.96,77.04 71.96,81.73 v4(72.36,82.13) 71.74,82.75 71.74,85.47 70.74,86.47 70.74,87.98 71.59,88.83 71.59,90.12 71.96,90.49 71.96,95.83 v4(72.36,96.23)
  20_SIG7 w0.089: v2(97.24,54.84) 96.74,55.34 96.03,55.34 95.74,55.64 95.74,56.05 95.44,56.34 94.91,56.34 ; 82.19,37.04 74.33,37.04 72.36,39.01 v4(72.36,39.84)
  20_SIG7 w0.157: 82.19,37.04 84.38,37.04 84.63,37.29 84.63,37.65 84.21,38.07 84.21,38.49 84.63,38.9 85.04,38.9 85.46,38.48 85.82,38.48 86.16,38.82 86.16,39.23 85.81,39.57 85.81,39.99 86.23,40.4 86.64,40.4 86.98,40.06 87.4,40.06 88.18,40.84 88.18,41.44 87.88,41.73 85.67,41.73 85.37,42.02 85.37,42.61 85.67,42.9 87.88,42.9 88.18,43.19 88.18,43.77 87.88,44.07 86.12,44.07 85.83,44.36 85.83,44.94 86.12,45.23 87.88,45.23 88.18,45.53 88.18,46.11 87.88,46.4 85.67,46.4 85.37,46.69 85.37,47.28 85.67,47.57 87.88,47.57 88.18,47.86 88.18,48.45 87.88,48.74 86.27,48.74 85.98,49.03 85.98,49.62 86.27,49.91 87.88,49.91 88.18,50.2 88.18,51.83 92.69,56.34 94.91,56.34
  BOTTOM w0.152: U62.M7 v4(72.36,96.23) ; U63.M7 v4(72.36,82.13) ; U64.M7 v4(72.36,53.94) ; U61.M7 v4(72.36,68.04) ; U60.M7 v4(72.36,39.84)
DDR4_C1_A13: length 155.1
  TOP w0.152: v2(98.24,56.84) 98.74,57.34 U1.D15
  TOP w0.279: R256.2 84.65,100.5 v1(84.76,100.4)
  16_SIG5 w0.089: 81.61,36.24 70.59,36.24 70.36,36.48 70.36,37.61 69.71,38.26 69.14,38.26 68.76,38.64 68.76,41.04 v4(68.36,41.44) ; 99.74,42.7 99.74,53.93 99.74,54.05 100.03,54.34 100.15,54.34 100.15,54.34 100.44,54.34 100.74,54.64 100.74,55.05 100.44,55.34 100.03,55.34 99.74,55.64 99.74,55.74 99.74,56.05 99.44,56.34 98.98,56.34 98.48,56.84 v2(98.24,56.84)
  16_SIG5 w0.14: 99.62,42.27 99.74,42.38 99.74,42.7
  16_SIG5 w0.157: 81.61,36.24 81.73,36.13 83.25,36.13 84.27,35.11 84.81,35.11 85.24,35.54 85.24,36.83 86.78,38.37 89.85,38.37 91.14,37.08 91.14,35.57 91.54,35.17 92.2,35.17 92.99,35.96 92.99,36.37 91.76,37.6 91.76,38.01 92.17,38.42 92.58,38.42 93.81,37.2 94.22,37.2 95.18,38.15 95.18,38.56 95.07,38.66 95.07,39.08 95.49,39.49 95.9,39.49 96,39.39 96.41,39.39 98.85,41.82 99.17,41.82 99.62,42.27
  20_SIG7 w0.089: v4(68.36,41.44) 67.98,41.44 66.78,42.65 66.78,42.87 67.11,43.21 67.11,43.43 66.78,43.76 66.56,43.76 66.22,43.43 66,43.43 65.56,43.87 65.56,50.88 67.5,52.82 67.5,54.68 v4(68.36,55.54) 67.34,56.56 67.34,59.45 66.9,59.88 66.9,60.45 66.75,60.6 66.35,60.6 66.19,60.76 66.19,61.23 66.35,61.39 66.75,61.39 66.9,61.55 66.9,64.19 66.75,64.35 66.53,64.35 66.37,64.5 66.37,64.98 66.53,65.13 66.75,65.13 66.9,65.29 66.9,69.03 67.51,69.64 v4(68.36,69.64) 68.76,70.03 68.76,72.17 68.63,72.29 68.63,73.14 68.76,73.26 68.76,83.33 v4(68.36,83.73) 67.62,84.47 67.62,94.95 67.79,95.12 68.15,95.12 68.32,95.29 68.32,95.64 68.15,95.81 67.79,95.81 67.62,95.98 67.62,97.09 v4(68.36,97.83)
  BOTTOM w0.152: U62.T8 v4(68.36,97.83) 67.77,98.42 67.77,99.03 68.1,99.36 ; U64.T8 v4(68.36,55.54) ; U61.T8 v4(68.36,69.64) ; U60.T8 v4(68.36,41.44) ; U63.T8 v4(68.36,83.73)
  BOTTOM w0.279: 68.1,99.36 68.33,99.59 76.76,99.59 78.63,101.46 84.06,101.46 84.76,100.76 v1(84.76,100.4)
DDR4_C1_A14_WE_B: length 151.9
  TOP w0.152: v2(102.24,55.84) 102.74,56.34 U1.H14
  TOP w0.279: v1(66.94,100.34) 66.87,100.41 R249.2
  14_SIG4 w0.089: 99.74,42.57 99.74,43.03 99.73,43.03 99.73,43.05 99.44,43.34 99.42,43.34 99.42,43.34 99.03,43.34 98.74,43.64 98.74,43.65 98.73,43.66 98.73,44.07 99.01,44.34 100.44,44.34 100.74,44.64 100.74,45.05 101.03,45.34 101.36,45.34 101.36,45.34 101.44,45.34 101.73,45.64 101.73,47.02 101.74,47.03 101.74,47.05 102.04,47.34 102.49,47.34 102.74,47.6 102.74,49.05 103.03,49.34 103.55,49.34 103.74,49.53 103.74,49.64 103.74,50.05 104.03,50.34 104.5,50.34 104.74,50.58 104.74,51.06 105.02,51.34 105.52,51.34 105.74,51.56 105.74,53.05 105.44,53.34 105.03,53.34 104.74,53.64 104.74,54.05 104.44,54.34 104.03,54.34 103.74,54.64 103.74,55.05 103.44,55.34 102.74,55.34 v2(102.24,55.84) ; v4(72.36,92.23) 72.36,92.04 71.95,91.64 71.95,91.26 71.72,91.03 68.19,91.03 67.79,91.43 67.79,99.36 ; v4(72.36,35.84) 72.11,35.84 71.96,35.69 71.96,34.64 72.01,34.59
  14_SIG4 w0.157: 67.79,99.36 67.79,99.49 v1(66.94,100.34) ; 72.01,34.59 72.29,34.31 72.62,34.31 74.7,32.23 77.97,32.23 78.67,31.54 80.38,31.54 81.05,30.87 84.26,30.87 84.58,31.19 84.58,31.36 84.79,31.57 85.22,31.57 85.44,31.35 85.44,30.95 85.64,30.76 86.29,30.76 86.41,30.88 86.41,31.43 86.57,31.59 87.15,31.59 87.28,31.46 87.28,30.88 87.41,30.76 88.43,30.76 88.66,30.99 88.66,31.22 88.54,31.34 88.04,31.34 87.91,31.47 87.91,31.75 88.06,31.9 89.03,31.9 89.18,31.75 89.18,31.6 89.36,31.42 89.79,31.42 90.37,32 90.37,32.23 90.25,32.35 90.25,32.57 98.29,40.61 98.29,40.79 97.69,41.39 97.69,41.56 97.87,41.74 98.05,41.74 98.7,41.09 98.85,41.09 99.02,41.27 99.02,41.47 98.7,41.79 98.7,41.97 98.88,42.15 99.05,42.15 99.53,41.66 99.73,41.66 100.11,42.05 100.11,42.2 99.74,42.57
  18_SIG6 w0.089: v4(72.36,35.84) 71.96,36.24 71.96,42.91 73.18,44.13 74.5,44.13 74.92,44.55 74.92,46.9 74.23,47.58 73.21,47.58 72.76,48.03 72.76,49.54 v4(72.36,49.94) 72.76,50.34 72.76,50.9 72.52,51.14 72.19,51.14 71.96,51.37 71.96,57.5 72.27,57.81 73.36,57.81 74.06,58.51 74.06,61.56 73.56,62.07 73.56,63.4 73.32,63.63 72.96,63.63 72.56,64.04 v4(72.36,64.04) 72.76,64.43 72.76,65 72.52,65.24 72.19,65.24 71.96,65.47 71.96,75.71 72.76,76.51 72.76,77.73 v4(72.36,78.13) 72.76,78.53 72.76,79.1 72.52,79.33 72.19,79.33 71.96,79.57 71.96,86.73 73.34,88.11 73.34,89.65 72.76,90.24 72.76,91.83 v4(72.36,92.23)
  BOTTOM w0.152: U63.L2 v4(72.36,78.13) ; U62.L2 v4(72.36,92.23) ; U64.L2 v4(72.36,49.94) ; U61.L2 v4(72.36,64.04) ; U60.L2 v4(72.36,35.84)
DDR4_C1_A15_CAS_B: length 145.2
  TOP w0.152: v2(102.24,56.84) 102.74,57.34 U1.H15
  TOP w0.279: R250.2 v1(69.16,103.77)
  14_SIG4 w0.089: 71.15,34.68 71.15,34.59 ; v4(72.36,97.83) 70.82,99.36 ; 100.74,41.99 100.74,43.93 101.15,44.34 101.31,44.34 101.73,44.76 101.73,45.05 102.01,45.32 102.01,45.32 102.03,45.34 102.41,45.34 102.42,45.34 102.46,45.34 102.73,45.62 102.73,47.04 103.03,47.34 103.44,47.34 103.73,47.64 103.73,49.18 103.9,49.34 104.36,49.34 104.44,49.35 104.73,49.64 104.73,49.71 104.73,49.72 104.73,50.04 105.03,50.34 105.49,50.34 105.74,50.59 105.74,50.63 105.74,50.64 105.74,51.05 106.03,51.34 106.38,51.34 106.74,51.7 106.74,52.95 106.35,53.34 106.05,53.34 105.74,53.66 105.74,53.94 105.33,54.34 105.12,54.34 104.74,54.72 104.74,54.93 104.33,55.34 104.12,55.34 103.74,55.72 103.74,55.92 103.32,56.34 102.74,56.34 v2(102.24,56.84)
  14_SIG4 w0.124: v4(72.36,41.44) 71.92,41.01 71.92,39.36 71.58,39.02 70.72,39.02 70.36,38.65 70.36,35.68 70.6,35.44 70.92,35.44 71.15,35.21 71.15,34.68
  14_SIG4 w0.157: 100.74,41.99 92.11,33.36 92.11,32.78 92.11,32.77 92.11,32.77 91.79,32.45 91.79,32.45 89.42,30.09 80.79,30.09 80.59,29.89 79.38,29.89 77.7,31.57 74.26,31.57 72.92,32.91 72.74,32.91 71.15,34.5 71.15,34.59 ; 70.82,99.36 70.73,99.45 70.73,100.91 69.82,101.82 69.82,103.11 69.16,103.77 v1(69.16,103.77)
  20_SIG7 w0.089: v4(72.36,97.83) U62.M8 71.96,95.09 71.16,94.29 71.16,89.12 71.68,88.59 71.68,86.82 71.51,86.65 70.99,86.65 70.82,86.47 70.82,86.13 70.99,85.95 71.51,85.95 71.68,85.78 71.68,84.41 v4(72.36,83.73) U63.M8 71.96,75.87 72.05,75.78 72.15,75.78 72.24,75.69 72.24,75.43 72.15,75.34 72.05,75.34 71.96,75.25 71.96,74.98 72.05,74.89 72.15,74.89 72.24,74.8 72.24,74.54 72.15,74.45 72.05,74.45 71.96,74.36 71.96,70.04 v4(72.36,69.64) U61.M8 71.96,67.44 70.36,65.84 70.36,62.53 71.8,61.09 71.8,60.75 71.63,60.58 71.39,60.58 71.21,60.41 71.21,60.06 71.39,59.89 71.63,59.89 71.8,59.72 71.8,59.37 71.63,59.2 71.39,59.2 71.21,59.03 71.21,58.68 71.39,58.51 71.63,58.51 71.8,58.34 71.8,56.1 v4(72.36,55.54) U64.M8 71.96,53.38 70.36,51.78 70.36,49.77 70.12,49.54 69.79,49.54 69.56,49.3 69.56,48.63 68.32,47.39 68.32,46.99 71.54,43.77 71.54,42.26 v4(72.36,41.44)
  BOTTOM w0.152: U61.M8 v4(72.36,69.64) ; U60.M8 v4(72.36,41.44) ; U64.M8 v4(72.36,55.54) ; U63.M8 v4(72.36,83.73) ; U62.M8 v4(72.36,97.83)
DDR4_C1_A16_RAS_B: length 140.6
  TOP w0.152: U1.F15 100.74,57.34 v2(100.24,56.84)
  TOP w0.279: v1(71.29,100.36) 71.19,100.46 R564.2
  14_SIG4 w0.089: 72.29,99.36 72.75,98.9 72.75,98.23 v4(73.16,97.83)
  14_SIG4 w0.157: 72.29,99.36 v1(71.29,100.36)
  20_SIG7 w0.089: 94.39,57.34 97.44,57.34 97.74,57.05 97.74,56.64 98.03,56.34 98.44,56.34 98.74,56.05 98.74,55.64 99.03,55.34 100.44,55.34 100.74,55.64 100.74,56.34 v2(100.24,56.84) ; 72.83,39.18 72.76,39.25 72.76,41.04 v4(73.16,41.44) 72.76,41.84 72.76,42.46 72.07,43.15 72.07,44.09 69.98,46.18 69.98,46.85 70.67,47.53 70.91,47.53 71.2,47.24 71.45,47.24 71.69,47.48 71.69,47.73 71.4,48.02 71.4,48.26 71.96,48.82 71.96,52.2 72.76,53 U64.L8 v4(73.16,55.54) 72.76,55.94 72.76,57.8 73,58.04 73,59.87 72.83,60.04 72.63,60.04 72.46,60.21 72.46,60.56 72.63,60.73 72.83,60.73 73,60.91 73,62.21 72.71,62.51 71.36,62.51 71.16,62.71 71.16,65.88 72.76,67.48 U61.L8 v4(73.16,69.64) 72.76,70.04 72.76,71 73.03,71.28 73.03,73.25 72.76,73.52 U63.L8 v4(73.16,83.73) 72.76,84.13 72.76,86.14 73.29,86.67 73.29,89.25 71.96,90.58 71.96,94.19 72.76,94.99 U62.L8 v4(73.16,97.83)
  20_SIG7 w0.157: 72.83,39.18 73.71,38.3 81.92,38.3 84.53,40.91 84.53,43.29 84.95,43.71 84.95,44.77 84.53,45.2 84.53,50.42 85.19,51.08 85.83,51.08 87.53,52.78 87.53,53.2 86.13,54.6 86.13,55.01 86.54,55.42 86.96,55.42 88.36,54.02 88.77,54.02 89.18,54.44 89.18,54.85 87.34,56.69 87.34,57.03 87.91,57.6 88.09,57.6 90.01,55.67 90.42,55.67 90.84,56.09 90.84,56.5 87.57,59.77 87.57,60.21 87.98,60.62 88.37,60.62 91.65,57.34 94.39,57.34
  BOTTOM w0.152: U63.L8 v4(73.16,83.73) ; U62.L8 v4(73.16,97.83) ; U64.L8 v4(73.16,55.54) ; U61.L8 v4(73.16,69.64) ; U60.L8 v4(73.16,41.44)
DDR4_C1_ACT_B: length 148.2
  TOP w0.152: v2(99.24,54.84) 99.74,55.34 U1.E13
  TOP w0.279: R567.2 66.87,104.06 66.9,104.04 v1(66.99,104.04)
  05_SIG2 w0.173: v4(72.36,93.83) 71.77,94.42 68.39,94.42 67.56,95.25
  05_SIG2 w0.292: v1(66.99,104.04) 66.99,103.04 65.62,101.66 65.62,97.93 66.55,97 66.55,96.27 67.28,95.53 67.56,95.25
  16_SIG5 w0.089: 94.39,46.11 94.62,46.34 95.47,46.34 95.74,46.61 95.74,46.74 95.74,46.74 95.74,56.05 96.03,56.34 97.44,56.34 97.74,56.05 97.74,55.74 97.74,55.53 97.92,55.34 98.44,55.34 98.94,54.84 v2(99.24,54.84) ; v4(72.36,93.83) 72.76,93.43 72.76,89.7 74.38,88.08 74.38,86.86 72.76,85.24 72.76,80.13 v4(72.36,79.73) U63.L3 72.76,74.85 73.09,74.52 73.09,70.93 72.76,70.6 72.76,66.04 v4(72.36,65.64) 72.76,65.23 73.87,65.23 74.18,64.92 74.18,63.69 73.07,62.59 73.07,62.31 72.9,62.14 72.49,62.14 72.32,61.97 72.32,61.62 72.49,61.45 72.9,61.45 73.07,61.28 73.07,60.81 72.87,60.61 72.87,59.95 73.07,59.74 73.07,57.16 72.76,56.84 72.76,51.94 v4(72.36,51.54) U64.L3 72.76,48.4 72.93,48.23 73.39,48.23 73.57,48.06 73.57,47.71 73.39,47.54 72.93,47.54 72.76,47.36 72.76,47.02 72.93,46.85 73.39,46.85 73.57,46.67 73.57,46.33 73.39,46.16 72.93,46.16 72.76,45.98 72.76,45.46 73.46,44.76 73.46,43.41 73.29,43.24 72.92,43.24 72.76,43.08 72.76,39.12 72.36,38.72 v4(72.36,37.44) 74.33,39.42 79.56,39.42 80.37,38.61 81.61,38.61
  16_SIG5 w0.157: 94.39,46.11 94.23,45.95 92.78,45.95 92.46,45.63 92.46,45.07 92.73,44.8 93.82,44.8 94.04,44.58 94.04,43.28 93.68,42.92 93.34,42.92 91.65,44.61 91.23,44.61 90.82,44.2 90.82,43.78 92.6,42.01 93.08,41.53 94.11,41.53 94.38,41.25 94.38,40.72 94.06,40.4 92.55,40.4 89.99,42.96 89.58,42.96 89.17,42.55 89.17,42.13 90.43,40.86 90.43,40.65 89.93,40.15 89.5,40.15 88.34,41.31 87.93,41.31 87.17,40.55 87.17,40.41 86.88,40.11 86.29,40.11 86,40.41 86,40.76 85.71,41.05 83.55,41.05 83.25,40.75 83.25,39.94 81.92,38.61 81.61,38.61
  BOTTOM w0.152: U60.L3 v4(72.36,37.44) ; U64.L3 v4(72.36,51.54) ; U61.L3 v4(72.36,65.64) ; U62.L3 v4(72.36,93.83) ; U63.L3 v4(72.36,79.73)
DDR4_C1_ALERT_B: length 147.2
  TOP w0.152: U1.R17 109.74,59.34 v2(109.24,58.84)
  TOP w0.279: R258.2 72.97,104.02 v1(73.14,103.85)
  07_SIG3 w0.173: 69.58,99.36 69.58,99.01 v4(69.96,98.63)
  07_SIG3 w0.292: v1(73.14,103.85) 72.53,103.85 72.39,103.71 72.39,102.42 72.11,102.13 69.93,102.13 69.57,101.77 69.57,99.38 69.58,99.36
  14_SIG4 w0.089: v4(69.96,42.24) 70.35,41.84 70.92,41.84 71.15,42.08 71.15,42.82 ; 94.39,60.34 107.57,60.34 107.72,60.19 107.72,59.55 107.94,59.34 109.03,59.34 109.24,59.13 v2(109.24,58.84)
  14_SIG4 w0.157: 94.39,60.34 94.3,60.34 93.52,59.57 86.64,59.57 86.05,58.97 84.51,58.97 83.41,60.07 78.75,60.07 78.59,59.92 78.59,59.43 78.43,59.27 77.96,59.27 77.8,59.43 77.8,59.92 77.65,60.07 77.17,60.07 77.02,59.92 77.02,59.43 76.86,59.27 76.39,59.27 76.23,59.43 76.23,59.92 76.07,60.07 75.6,60.07 75.44,59.92 75.44,59.43 75.28,59.27 74.81,59.27 74.65,59.43 74.65,59.92 74.5,60.07 74.02,60.07 73.87,59.92 73.87,59.43 73.71,59.27 73.24,59.27 73.08,59.43 73.08,59.92 72.92,60.07 69.39,60.07 67.59,58.27 67.59,46.39 71.15,42.82
  16_SIG5 w0.089: v4(69.96,98.63) 70.36,98.23 70.36,89.82 69.34,88.81 69.34,88.16 69.52,87.98 69.74,87.98 69.91,87.81 69.91,87.47 69.74,87.29 69.52,87.29 69.34,87.12 69.34,85.15 v4(69.96,84.53) U63.P9 70.36,75.81 70.61,75.56 70.61,74.77 70.53,74.68 70.3,74.68 70.21,74.59 70.21,74.32 70.3,74.24 70.53,74.24 70.61,74.15 70.61,71.09 v4(69.96,70.44) 70.36,70.03 70.36,64.67 70.12,64.43 69.79,64.43 69.56,64.2 69.56,62.9 69.26,62.61 69.26,60.76 69.43,60.58 70.37,60.58 70.54,60.41 70.54,60.07 70.37,59.89 69.43,59.89 69.26,59.72 69.26,58.68 69.47,58.47 69.47,57.82 69.26,57.6 69.26,57.04 v4(69.96,56.34) U64.P9 70.36,48.87 70.05,48.56 69.19,48.56 68.9,48.28 68.9,46.66 68.73,46.48 68.23,46.48 68.06,46.31 68.06,45.97 68.23,45.79 68.73,45.79 68.9,45.62 68.9,43.73 69.96,42.68 v4(69.96,42.24)
  BOTTOM w0.152: U64.P9 v4(69.96,56.34) ; U63.P9 v4(69.96,84.53) ; U60.P9 v4(69.96,42.24) ; U62.P9 v4(69.96,98.63) ; U61.P9 v4(69.96,70.44)
DDR4_C1_BA0: length 149
  TOP w0.152: v2(101.24,56.84) 101.74,57.34 U1.G15
  TOP w0.279: R237.2 75.51,100.53 75.67,100.37 v1(75.75,100.37)
  14_SIG4 w0.089: 94.39,41.47 95.48,42.57 95.66,42.57 95.82,42.4 96.01,42.4 96.19,42.57 96.19,42.74 96.11,42.81 96.11,42.95 96.73,43.57 96.73,44.04 97.03,44.34 97.44,44.34 97.73,44.64 97.73,44.64 97.74,44.65 97.74,45.05 98.03,45.34 98.5,45.34 98.73,45.57 98.73,47.14 98.94,47.34 100.43,47.34 100.43,47.34 100.44,47.34 100.73,47.64 100.73,47.65 100.73,49.05 101.03,49.34 101.44,49.34 101.73,49.64 101.73,50.04 102.03,50.34 102.54,50.34 102.74,50.54 102.74,51.1 102.98,51.34 103.49,51.34 103.74,51.59 103.74,53.05 103.44,53.34 103.03,53.34 102.74,53.64 102.74,54.05 102.44,54.34 102.03,54.34 101.74,54.64 101.74,56.34 v2(101.24,56.84) ; v4(70.76,35.84) 71.16,36.24 71.16,38.51 71.32,38.67 71.71,38.67 71.84,38.54 71.84,38.09 71.95,37.97 72.38,37.97 72.54,38.13 72.54,39.18 72.67,39.31 74.47,39.31 74.64,39.14 74.64,38.62 74.5,38.47 73.26,38.47 73.11,38.32 73.11,38.05 73.22,37.94 73.45,37.94 73.56,37.83 73.56,36.8 74.31,36.05 74.31,34.59 ; v4(70.76,92.23) 71.15,91.83 71.72,91.83 71.96,92.07 71.96,94.16 72.44,94.64 73.15,94.64 74.36,95.85 74.36,98.98 74.75,99.36
  14_SIG4 w0.157: 74.31,34.59 75.34,33.57 78.52,33.57 79.22,32.87 80.93,32.87 81.6,32.2 82.76,32.2 84.01,33.46 85.05,33.46 85.27,33.67 85.27,34.81 85.48,35.03 85.92,35.03 86.13,34.81 86.13,33.67 86.35,33.46 89.09,33.46 90.27,34.64 90.27,37.36 94.39,41.47 ; 74.75,99.36 v1(75.75,100.37)
  18_SIG6 w0.089: v4(70.76,35.84) 70.76,36.08 70.36,36.48 70.36,42.41 70.47,42.52 70.47,45.49 70.3,45.66 69.08,45.66 68.9,45.83 68.9,46.18 69.08,46.35 70.3,46.35 70.47,46.52 70.47,48.86 70.36,48.97 70.36,49.3 70.76,49.7 v4(70.76,49.94) 70.76,50.17 70.36,50.57 70.36,58.43 70.73,58.79 70.98,58.79 71.15,58.97 71.15,59.31 70.98,59.49 70.7,59.49 70.53,59.66 70.53,60.08 70.74,60.29 71.88,60.29 72.18,60.59 72.18,61.03 71.85,61.35 71.31,61.35 71.16,61.51 71.16,63.4 70.76,63.8 v4(70.76,64.04) 70.76,64.27 70.36,64.67 70.36,70.95 70.49,71.08 70.49,72.97 69.93,73.54 69.93,74.34 70.07,74.49 70.07,75.16 69.93,75.31 69.93,75.85 70.36,76.28 70.36,77.5 70.76,77.9 v4(70.76,78.13) 70.76,78.37 70.36,78.77 70.36,85.34 70.19,85.52 70.15,85.52 69.98,85.69 69.98,86.04 70.15,86.21 70.19,86.21 70.36,86.38 70.36,86.73 70.19,86.9 70.15,86.9 69.98,87.07 69.98,87.42 70.15,87.59 70.19,87.59 70.36,87.76 70.36,88.11 70.19,88.28 70.15,88.28 69.98,88.45 69.98,88.8 70.15,88.97 70.19,88.97 70.36,89.14 70.36,91.83 v4(70.76,92.23)
  BOTTOM w0.152: U63.N2 v4(70.76,78.13) ; U60.N2 v4(70.76,35.84) ; U62.N2 v4(70.76,92.23) ; U61.N2 v4(70.76,64.04) ; U64.N2 v4(70.76,49.94)
DDR4_C1_BA1: length 144.5
  TOP w0.152: v2(101.24,54.84) 101.74,55.34 U1.G13
  TOP w0.279: v1(71.72,103.81) 71.95,104.05 R257.2
  05_SIG2 w0.173: v4(70.76,97.83) 71.37,98.45 71.37,99.05 71.69,99.36
  05_SIG2 w0.292: v1(71.72,103.81) 71.44,103.81 71.05,103.42 71.05,101.84 71.87,101.01 71.87,99.55 71.69,99.36
  14_SIG4 w0.089: v4(70.76,41.44) 70.95,41.44 71.46,41.95 71.46,44.28 ; 94.39,57.99 95.03,57.34 100.48,57.34 100.74,57.09 100.74,55.34 v2(101.24,54.84)
  14_SIG4 w0.157: 71.46,44.28 67.93,47.8 67.93,56.92 69.2,58.19 69.91,58.19 70.07,58.03 70.07,57.47 70.23,57.31 70.54,57.31 70.7,57.47 70.7,58.03 70.86,58.19 71.17,58.19 71.33,58.03 71.33,57.47 71.49,57.31 71.8,57.31 71.96,57.47 71.96,58.03 72.12,58.19 72.43,58.19 72.59,58.03 72.59,57.47 72.75,57.31 73.06,57.31 73.22,57.47 73.22,58.03 73.38,58.19 73.69,58.19 73.85,58.03 73.85,57.47 74.01,57.31 74.32,57.31 74.48,57.47 74.48,58.03 74.64,58.19 74.95,58.19 75.11,58.03 75.11,57.47 75.27,57.31 75.58,57.31 75.74,57.47 75.74,58.03 75.89,58.19 76.21,58.19 76.37,58.03 76.37,57.47 76.52,57.31 76.84,57.31 77,57.47 77,58.03 77.15,58.19 77.47,58.19 77.63,58.03 77.63,57.47 77.78,57.31 78.1,57.31 78.26,57.47 78.26,58.03 78.41,58.19 78.73,58.19 78.89,58.03 78.89,57.47 79.04,57.31 79.36,57.31 79.52,57.47 79.52,58.03 79.67,58.19 79.99,58.19 80.15,58.03 80.15,57.64 80.3,57.48 80.62,57.48 80.78,57.64 80.78,58.03 80.93,58.19 81.9,58.19 83.52,56.57 85.95,56.57 87.5,58.12 94.26,58.12 94.39,57.99
  20_SIG7 w0.089: v4(70.76,41.44) 70.76,41.68 70.36,42.08 70.36,42.8 69.47,43.68 69.26,43.68 69.07,43.87 69.07,44.09 68.86,44.29 68.73,44.29 68.57,44.13 68.44,44.13 68.25,44.32 68.25,44.44 68.42,44.61 68.42,44.74 67.08,46.07 67.08,50.13 68.09,51.14 68.52,51.14 68.76,51.37 68.76,51.79 70.36,53.39 70.36,55.14 v4(70.76,55.54) 70.36,55.94 69.79,55.94 69.56,56.17 69.56,59.02 67.94,60.63 67.94,61.33 68.21,61.59 68.21,62.19 67.94,62.46 67.94,66.14 69.56,67.76 69.56,69.03 69.76,69.24 70.36,69.24 v4(70.76,69.64) 70.36,70.04 70.36,71.25 70.59,71.48 70.59,73.12 70.36,73.36 70.36,83.33 v4(70.76,83.73) 70.36,84.13 69.79,84.13 69.56,84.37 69.56,86.48 69.8,86.72 69.8,87.34 69.56,87.59 69.56,94.65 70.36,95.45 70.36,97.43 v4(70.76,97.83)
  BOTTOM w0.152: U62.N8 v4(70.76,97.83) ; U60.N8 v4(70.76,41.44) ; U64.N8 v4(70.76,55.54) ; U61.N8 v4(70.76,69.64) ; U63.N8 v4(70.76,83.73)
DDR4_C1_BG0: length 148
  TOP w0.152: U1.H13 102.74,55.34 v2(102.24,54.84)
  TOP w0.279: R246.2 72.21,100.61 v1(72.47,100.35)
  14_SIG4 w0.089: 97.73,42.41 97.73,44.04 98.03,44.34 98.44,44.34 98.74,44.64 98.74,45.05 99.03,45.34 99.51,45.34 99.74,45.57 99.74,45.64 99.74,46.05 100.03,46.34 100.04,46.34 100.04,46.34 100.47,46.34 100.73,46.61 100.73,47.04 101.03,47.34 101.57,47.34 101.73,47.51 101.73,49.05 102.03,49.34 102.53,49.34 102.74,49.55 102.74,49.64 102.74,50.11 102.97,50.34 103.52,50.34 103.73,50.55 103.73,51.14 103.94,51.34 104.51,51.34 104.74,51.57 104.74,53.16 104.56,53.34 104.03,53.34 103.74,53.64 103.74,54.05 103.44,54.34 102.76,54.34 102.26,54.84 v2(102.24,54.84) ; 73.46,99.36 73.55,99.27 73.55,96.06 72.74,95.25 71.93,95.25 71.15,94.47 71.15,92.63 v4(71.56,92.23) ; v4(71.56,35.84) 71.95,36.24 73.44,36.24 73.55,36.12 73.55,34.59
  14_SIG4 w0.157: 73.46,99.36 v1(72.47,100.35) ; 97.73,42.41 97.5,42.17 97.18,42.17 96.98,41.98 96.98,40.46 96.85,40.34 96.68,40.34 96.68,40.33 95.65,41.36 95.34,41.36 95.04,41.05 95.04,40.75 96.06,39.72 96.06,39.41 95.76,39.11 95.45,39.11 94.43,40.13 94.12,40.13 93.82,39.83 93.82,39.52 94.84,38.5 94.84,38.19 94.54,37.89 94.23,37.89 93.2,38.91 92.9,38.91 92.59,38.61 92.59,38.3 93.62,37.27 93.62,36.97 93.32,36.66 93.01,36.66 91.98,37.69 91.68,37.69 91.37,37.39 91.37,37.08 92.4,36.05 92.4,35.75 89.39,32.73 84.48,32.73 83.28,31.54 81.32,31.54 80.66,32.2 78.94,32.2 78.25,32.9 74.98,32.9 73.55,34.32 73.55,34.59
  18_SIG6 w0.089: v4(71.56,92.23) 71.96,91.83 71.96,89.92 72.14,89.73 72.14,88.46 71.68,88 71.68,87.46 71.58,87.36 71.58,80.68 71.16,80.26 71.16,79.57 71.39,79.33 71.72,79.33 71.96,79.1 71.96,78.53 v4(71.56,78.13) 71.96,77.73 71.96,76.59 71.55,76.18 71.55,66.58 71.16,66.19 71.16,65.47 71.39,65.24 71.72,65.24 71.96,65 71.96,64.43 v4(71.56,64.04) 71.76,64.04 72.16,63.63 72.52,63.63 72.76,63.4 72.76,61.86 73.55,61.07 73.55,58.73 73.05,58.23 71.87,58.23 71.55,57.91 71.55,53.17 71.16,52.77 71.16,51.37 71.39,51.14 71.72,51.14 71.96,50.9 71.96,50.34 v4(71.56,49.94) 71.96,49.54 71.96,47.8 72.67,47.08 73.75,47.08 74.29,46.53 74.29,44.91 74.08,44.69 73.15,44.69 71.53,43.07 71.53,38.96 71.16,38.59 71.16,36.24 v4(71.56,35.84)
  BOTTOM w0.152: U62.M2 v4(71.56,92.23) ; U61.M2 v4(71.56,64.04) ; U63.M2 v4(71.56,78.13) ; U64.M2 v4(71.56,49.94) ; U60.M2 v4(71.56,35.84)
DDR4_C1_CK_C: length 155.3
  TOP w0.145: 74.39,94.54 74.37,94.56 74.01,94.56 73.56,95.01 73.56,97.43 v4(73.96,97.83) ; U1.E14 99.74,56.34 v2(99.24,55.84)
  TOP w0.188: R566.1 82.31,94.21 81.82,94.21 81.5,94.54 74.39,94.54 74.39,94.54
  20_SIG7 w0.102: 73.66,48.69 73.66,47.55 73.52,47.41 72.28,47.41 72,47.14 72,46.69 72.33,46.37 73.52,46.37 73.66,46.23 73.66,45.96 73.52,45.82 73.42,45.82 73.12,45.52 73.12,45.06 73.41,44.78 73.52,44.78 73.66,44.64 73.66,42.98 ; 73.81,62.79 73.81,62.76 73.82,62.75 73.82,60.48 74.08,60.23 75.32,60.23 75.47,60.07 75.47,59.75 75.25,59.52 74.05,59.52 73.79,59.26 73.79,57.11 73.78,57.1 73.78,57.07 ; 73.69,90.98 73.69,90.08 73.87,89.89 73.87,89.05 74.15,88.78 74.47,88.78 74.6,88.64 74.6,88.37 74.47,88.23 74.14,88.23 73.87,87.96 73.87,85.3 73.86,85.29 73.86,85.27 ; 73.71,76.89 73.71,76.23 73.92,76.01 74.15,76.01 74.25,75.91 74.25,75.61 74.15,75.5 73.92,75.5 73.69,75.27 73.69,71.17
  20_SIG7 w0.107: 73.73,76.91 73.71,76.89 ; v2(99.24,55.84) 99.53,55.84 99.64,55.95 99.64,58.02 99.41,58.24 94.46,58.24 94.41,58.19 94.39,58.19 ; 73.75,48.79 73.66,48.69
  20_SIG7 w0.108: 73.81,62.79 73.81,65.6 73.54,65.87 73.54,66.28 73.8,66.53 73.8,67.49 73.58,67.71 73.58,69.26 v4(73.96,69.64) 73.56,70.03 73.56,70.82 73.69,70.95 73.69,71.17 ; v4(73.96,97.83) 73.55,97.42 73.55,95.98 73.71,95.82 73.71,91 73.69,90.98 ; 73.73,76.91 73.71,81.79 73.58,81.91 73.58,83.36 v4(73.96,83.73) 73.58,84.11 73.58,84.77 73.86,85.05 73.86,85.27 ; 82.2,39.64 82.18,39.63 82.14,39.63 81.37,38.86 73.81,38.86 73.56,39.1 73.56,41.05 v4(73.96,41.44) 73.56,41.84 73.56,42.81 73.66,42.91 73.66,42.98 ; 73.78,57.07 73.78,56.86 73.58,56.67 73.58,55.91 v4(73.96,55.54) 73.56,55.14 73.56,53.73 73.75,53.54 73.75,48.79
  20_SIG7 w0.14: 82.2,39.64 83.16,40.61 83.16,44.03 82.45,44.74 75.09,44.74 74.95,44.88 74.95,46.7 75.12,46.87 83.08,46.87 83.77,47.57 83.77,62.15 84.13,62.51 85.63,62.51 86.32,61.82 93.19,61.82 93.4,61.61 93.4,58.78 93.98,58.19 94.39,58.19
  BOTTOM w0.145: v4(73.96,41.44) U60.K8 ; U62.K8 v4(73.96,97.83) ; v4(73.96,83.73) U63.K8 ; v4(73.96,55.54) U64.K8 ; v4(73.96,69.64) U61.K8
