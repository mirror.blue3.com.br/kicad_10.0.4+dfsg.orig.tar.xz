# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
MH_250H125
  round 6.35 hole 3.175: 1(0,0)
MT40A256M16GE-083E
  round 0.406 smd: A1(3.2,-6) A2(2.4,-6) A3(1.6,-6) A7(-1.6,-6) A8(-2.4,-6) A9(-3.2,-6) B1(3.2,-5.2) B2(2.4,-5.2) B3(1.6,-5.2) B7(-1.6,-5.2) B8(-2.4,-5.2) B9(-3.2,-5.2) C1(3.2,-4.4) C2(2.4,-4.4) C3(1.6,-4.4) C7(-1.6,-4.4) C8(-2.4,-4.4) C9(-3.2,-4.4) D1(3.2,-3.6) D2(2.4,-3.6) D3(1.6,-3.6) D7(-1.6,-3.6) D8(-2.4,-3.6) D9(-3.2,-3.6) E1(3.2,-2.8) E2(2.4,-2.8) E3(1.6,-2.8) E7(-1.6,-2.8) E8(-2.4,-2.8) E9(-3.2,-2.8) F1(3.2,-2) F2(2.4,-2) F3(1.6,-2) F7(-1.6,-2) F8(-2.4,-2) F9(-3.2,-2) G1(3.2,-1.2) G2(2.4,-1.2) G3(1.6,-1.2) G7(-1.6,-1.2) G8(-2.4,-1.2) G9(-3.2,-1.2) H1(3.2,-0.4) H2(2.4,-0.4) H3(1.6,-0.4) H7(-1.6,-0.4) H8(-2.4,-0.4) H9(-3.2,-0.4) J1(3.2,0.4) J2(2.4,0.4) J3(1.6,0.4) J7(-1.6,0.4) J8(-2.4,0.4) J9(-3.2,0.4) K1(3.2,1.2) K2(2.4,1.2) K3(1.6,1.2) K7(-1.6,1.2) K8(-2.4,1.2) K9(-3.2,1.2) L1(3.2,2) L2(2.4,2) L3(1.6,2) L7(-1.6,2) L8(-2.4,2) L9(-3.2,2) M1(3.2,2.8) M2(2.4,2.8) M3(1.6,2.8) M7(-1.6,2.8) M8(-2.4,2.8) M9(-3.2,2.8) N1(3.2,3.6) N2(2.4,3.6) N3(1.6,3.6) N7(-1.6,3.6) N8(-2.4,3.6) N9(-3.2,3.6) P1(3.2,4.4) P2(2.4,4.4) P3(1.6,4.4) P7(-1.6,4.4) P8(-2.4,4.4) P9(-3.2,4.4) R1(3.2,5.2) R2(2.4,5.2) R3(1.6,5.2) R7(-1.6,5.2) R8(-2.4,5.2) R9(-3.2,5.2) T1(3.2,6) T2(2.4,6) T3(1.6,6) T7(-1.6,6) T8(-2.4,6) T9(-3.2,6)
MURATA_BNX01
  rect 1.829x1.829 hole 1.219: 1(1.25,2.5)
  round 1.829 hole 1.219: 3(-3.75,2.5) 5(-3.75,-2.5) 6(-1.25,0) 7(3.75,0) 8(1.25,-2.5)
ON_AMP_FSI_Z38_20Z6_10
  round 1.549 hole 1.549 unplated: (-8.4,-8.625) (8.4,-8.625)
  rect 0.356x1.803 smd: 1(-7,-1.255) 2(-6.2,-1.255) 3(-5.4,-1.255) 4(-4.6,-1.255) 5(-3.8,-1.255) 6(-3,-1.255) 7(-2.2,-1.255) 8(-1.4,-1.255) 9(-0.6,-1.255) 10(0.2,-1.255) 11(1,-1.255) 12(1.8,-1.255) 13(2.6,-1.255) 14(3.4,-1.255) 15(4.2,-1.255) 16(5,-1.255) 17(5.8,-1.255) 18(6.6,-1.255) 19(7.4,-1.255) 20(7,1.255) 21(6.2,1.255) 22(5.4,1.255) 23(4.6,1.255) 24(3.8,1.255) 25(3,1.255) 26(2.2,1.255) 27(1.4,1.255) 28(0.6,1.255) 29(-0.2,1.255) 30(-1,1.255) 31(-1.8,1.255) 32(-2.6,1.255) 33(-3.4,1.255) 34(-4.2,1.255) 35(-5,1.255) 36(-5.8,1.255) 37(-6.6,1.255) 38(-7.4,1.255)
PCIE_16LANE_EDGE
  rect 0.711x3.2 smd: A1(0,0.495) B17(18,0.495) B31(32,0.495)
  rect 0.711x4.191 smd: A2(1,0) A3(2,0) A4(3,0) A5(4,0) A6(5,0) A7(6,0) A8(7,0) A9(8,0) A10(9,0) A11(10,0) A12(13,0) A13(14,0) A14(15,0) A15(16,0) A16(17,0) A17(18,0) A18(19,0) A19(20,0) A20(21,0) A21(22,0) A22(23,0) A23(24,0) A24(25,0) A25(26,0) A26(27,0) A27(28,0) A28(29,0) A29(30,0) A30(31,0) A31(32,0) A32(33,0) A33(34,0) A34(35,0) A35(36,0) A36(37,0) A37(38,0) A38(39,0) A39(40,0) A40(41,0) A41(42,0) A42(43,0) A43(44,0) A44(45,0) A45(46,0) A46(47,0) A47(48,0) A48(49,0) A49(50,0) A50(51,0) A51(52,0) A52(53,0) A53(54,0) A54(55,0) A55(56,0) A56(57,0) A57(58,0) A58(59,0) A59(60,0) A60(61,0) A61(62,0) A62(63,0) A63(64,0) A64(65,0) A65(66,0) A66(67,0) A67(68,0) A68(69,0) A69(70,0) A70(71,0) A71(72,0) A72(73,0) A73(74,0) A74(75,0) A75(76,0) A76(77,0) A77(78,0) A78(79,0) A79(80,0) A80(81,0) A81(82,0) A82(83,0) B1(0,0) B2(1,0) B3(2,0) B4(3,0) B5(4,0) B6(5,0) B7(6,0) B8(7,0) B9(8,0) B10(9,0) B11(10,0) B12(13,0) B13(14,0) B14(15,0) B15(16,0) B16(17,0) B18(19,0) B19(20,0) B20(21,0) B21(22,0) B22(23,0) B23(24,0) B24(25,0) B25(26,0) B26(27,0) B27(28,0) B28(29,0) B29(30,0) B30(31,0) B32(33,0) B33(34,0) B34(35,0) B35(36,0) B36(37,0) B37(38,0) B38(39,0) B39(40,0) B40(41,0) B41(42,0) B42(43,0) B43(44,0) B44(45,0) B45(46,0) B46(47,0) B47(48,0) B48(49,0) B49(50,0) B50(51,0) B51(52,0) B52(53,0) B53(54,0) B54(55,0) B55(56,0) B56(57,0) B57(58,0) B58(59,0) B59(60,0) B60(61,0) B61(62,0) B62(63,0) B63(64,0) B64(65,0) B65(66,0) B66(67,0) B67(68,0) B68(69,0) B69(70,0) B70(71,0) B71(72,0) B72(73,0) B73(74,0) B74(75,0) B75(76,0) B76(77,0) B77(78,0) B78(79,0) B79(80,0) B80(81,0) B81(82,0) B82(83,0)
PWR_56
  rect 0.635x1.27 smd: 1(-1.905,-2.67) 2(-0.635,-2.67) 3(0.635,-2.67) 4(1.905,-2.67) 5(1.905,2.67) 6(0.635,2.67) 7(-0.635,2.67) 8(-1.905,2.67)
PWRCLIP_33
  rect 0.787x0.432 smd: 1(-1.471,0.975) 2(-1.471,0.325) 3(-1.471,-0.325) 4(-1.471,-0.975) 5(1.471,-0.975) 6(1.471,-0.325) 7(1.471,0.325) 8(1.471,0.975)
  rect 1.6x0.864 smd: 9(0,1.016)
  rect 1.6x1.651 smd: 10(0,-0.559)
QFN16_SI_3X3MM
  rect 0.813x0.305 smd: 1(-1.5,0.75) 2(-1.5,0.25) 3(-1.5,-0.25) 4(-1.5,-0.75) 9(1.5,-0.75) 10(1.5,-0.25) 11(1.5,0.25) 12(1.5,0.75)
  rect 0.305x0.813 smd: 5(-0.75,-1.5) 6(-0.25,-1.5) 7(0.25,-1.5) 8(0.75,-1.5) 13(0.75,1.5) 14(0.25,1.5) 15(-0.25,1.5) 16(-0.75,1.5)
  rect 1.727x1.727 smd: 17(0,0)
QFN24_4X4MM
  rect 0.813x0.279 smd: 1(-1.95,1.25) 2(-1.95,0.75) 3(-1.95,0.25) 4(-1.95,-0.25) 5(-1.95,-0.75) 6(-1.95,-1.25) 13(1.95,-1.25) 14(1.95,-0.75) 15(1.95,-0.25) 16(1.95,0.25) 17(1.95,0.75) 18(1.95,1.25)
  rect 0.279x0.813 smd: 7(-1.25,-1.95) 8(-0.75,-1.95) 9(-0.25,-1.95) 10(0.25,-1.95) 11(0.75,-1.95) 12(1.25,-1.95) 19(1.25,1.95) 20(0.75,1.95) 21(0.25,1.95) 22(-0.25,1.95) 23(-0.75,1.95) 24(-1.25,1.95)
  rect 2.591x2.591 smd: 25(0,0)
QFN36_6X6MM
  rect 0.889x0.279 smd: 1(-2.71,2) 2(-2.71,1.5) 3(-2.71,1) 4(-2.71,0.5) 5(-2.71,0) 6(-2.71,-0.5) 7(-2.71,-1) 8(-2.71,-1.5) 9(-2.71,-2) 19(2.71,-2) 20(2.71,-1.5) 21(2.71,-1) 22(2.71,-0.5) 23(2.71,0) 24(2.71,0.5) 25(2.71,1) 26(2.71,1.5) 27(2.71,2)
  rect 0.279x0.889 smd: 10(-2,-2.71) 11(-1.5,-2.71) 12(-1,-2.71) 13(-0.5,-2.71) 14(0,-2.71) 15(0.5,-2.71) 16(1,-2.71) 17(1.5,-2.71) 18(2,-2.71) 28(2,2.71) 29(1.5,2.71) 30(1,2.71) 31(0.5,2.71) 32(0,2.71) 33(-0.5,2.71) 34(-1,2.71) 35(-1.5,2.71) 36(-2,2.71)
  rect 3.988x3.988 smd: 37(0,0)
QFN_24
  rect 0.61x0.305 smd: 1(-2.019,1.25) 2(-2.019,0.75) 3(-2.019,0.25) 4(-2.019,-0.25) 5(-2.019,-0.75) 6(-2.019,-1.25) 13(2.019,-1.25) 14(2.019,-0.75) 15(2.019,-0.25) 16(2.019,0.25) 17(2.019,0.75) 18(2.019,1.25)
  rect 0.305x0.61 smd: 7(-1.25,-2.019) 8(-0.75,-2.019) 9(-0.25,-2.019) 10(0.25,-2.019) 11(0.75,-2.019) 12(1.25,-2.019) 19(1.25,2.019) 20(0.75,2.019) 21(0.25,2.019) 22(-0.25,2.019) 23(-0.75,2.019) 24(-1.25,2.019)
  rect 2.489x2.489 smd: 25(0,0)
QFN_36_C
  oval 1.041x0.305 smd: 1(-2.9,2) 2(-2.9,1.5) 3(-2.9,1) 4(-2.9,0.5) 5(-2.9,0) 6(-2.9,-0.5) 7(-2.9,-1) 8(-2.9,-1.5) 9(-2.9,-2) 19(2.9,-2) 20(2.9,-1.5) 21(2.9,-1) 22(2.9,-0.5) 23(2.9,0) 24(2.9,0.5) 25(2.9,1) 26(2.9,1.5) 27(2.9,2)
  oval 0.305x1.041 smd: 10(-2,-2.9) 11(-1.5,-2.9) 12(-1,-2.9) 13(-0.5,-2.9) 14(0,-2.9) 15(0.5,-2.9) 16(1,-2.9) 17(1.5,-2.9) 18(2,-2.9) 28(2,2.9) 29(1.5,2.9) 30(1,2.9) 31(0.5,2.9) 32(0,2.9) 33(-0.5,2.9) 34(-1,2.9) 35(-1.5,2.9) 36(-2,2.9)
  rect 4.242x4.242 smd: 37(0,0)
QFN_RSW_10
  rect 0.203x0.813 smd: 1(-0.2,-0.701) 2(0.2,-0.701) 6(0.2,0.701) 7(-0.2,0.701)
  rect 0.813x0.203 smd: 3(0.9,-0.4) 4(0.9,0) 5(0.9,0.4) 8(-0.9,0.4) 9(-0.9,0) 10(-0.9,-0.4)
RES_CSS2775
  rect 3.175x6.858 smd: 1(-2.248,0) 2(2.248,0)
RES_WSLP_1206
  rect 1.575x1.778 smd: 1(-1.168,0) 2(1.168,0)
RP_EXB_0603X4
  rect 1.016x0.406 smd: 1(-0.8,1.2) 2(-0.8,0.4) 3(-0.8,-0.4) 4(-0.8,-1.2) 5(0.8,-1.2) 6(0.8,-0.4) 7(0.8,0.4) 8(0.8,1.2)
SAMTEC_TSW_106_22_S_RA
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(0,-2.54) 3(0,-5.08) 4(0,-7.62) 5(0,-10.16) 6(0,-12.7)
SC70_5
  rect 1.27x0.381 smd: 1(-0.953,0.65) 2(-0.953,0) 3(-0.953,-0.65) 4(0.953,-0.65) 5(0.953,0.65)
SC70_6
  rect 1.016x0.406 smd: 1(-1.1,0.658) 2(-1.1,0) 3(-1.1,-0.658) 4(1.1,-0.658) 5(1.1,0) 6(1.1,0.658)
SI570
  rect 1.702x2.159 smd: 1(-2.54,-2.095) 2(0,-2.095) 3(2.54,-2.095) 4(2.54,2.095) 5(0,2.095) 6(-2.54,2.095)
  rect 1.549x1.295 smd: 7(-2.845,0) 8(2.845,0)
SO16_50P300X413
  rect 2.032x0.635 smd: 1(-4.686,4.445) 2(-4.686,3.175) 3(-4.686,1.905) 4(-4.686,0.635) 5(-4.686,-0.635) 6(-4.686,-1.905) 7(-4.686,-3.175) 8(-4.686,-4.445) 9(4.686,-4.445) 10(4.686,-3.175) 11(4.686,-1.905) 12(4.686,-0.635) 13(4.686,0.635) 14(4.686,1.905) 15(4.686,3.175) 16(4.686,4.445)
SOC_2104_1MM_IRON
  round 2.184 hole 2.21 unplated: (-30.375,30) (-30.375,0) (-30.375,-30) (-0.375,30) (-0.375,-30) (29.625,30) (29.625,0) (29.625,-30)
  round 0.864 hole 0.864 unplated: (-30.375,-19.84) (29.625,24.92)
  round 0.61 smd: (-22.5,22.5) (-22.5,21.5) (-22.5,-21.5) (-22.5,-22.5) (-21.5,22.5) (-21.5,-22.5) (21.5,22.5) (21.5,-22.5) (22.5,22.5) (22.5,21.5) (22.5,-21.5) (22.5,-22.5) A3(-20.5,22.5) A4(-19.5,22.5) A5(-18.5,22.5) A6(-17.5,22.5) A7(-16.5,22.5) A8(-15.5,22.5) A9(-14.5,22.5) A10(-13.5,22.5) A11(-12.5,22.5) A12(-11.5,22.5) A13(-10.5,22.5) A14(-9.5,22.5) A15(-8.5,22.5) A16(-7.5,22.5) A17(-6.5,22.5) A18(-5.5,22.5) A19(-4.5,22.5) A20(-3.5,22.5) A21(-2.5,22.5) A22(-1.5,22.5) A23(-0.5,22.5) A24(0.5,22.5) A25(1.5,22.5) A26(2.5,22.5) A27(3.5,22.5) A28(4.5,22.5) A29(5.5,22.5) A30(6.5,22.5) A31(7.5,22.5) A32(8.5,22.5) A33(9.5,22.5) A34(10.5,22.5) A35(11.5,22.5) A36(12.5,22.5) A37(13.5,22.5) A38(14.5,22.5) A39(15.5,22.5) A40(16.5,22.5) A41(17.5,22.5) A42(18.5,22.5) A43(19.5,22.5) A44(20.5,22.5) AA1(-22.5,2.5) AA2(-21.5,2.5) AA3(-20.5,2.5) AA4(-19.5,2.5) AA5(-18.5,2.5) AA6(-17.5,2.5) AA7(-16.5,2.5) AA8(-15.5,2.5) AA9(-14.5,2.5) AA10(-13.5,2.5) AA11(-12.5,2.5) AA12(-11.5,2.5) AA13(-10.5,2.5) AA14(-9.5,2.5) AA15(-8.5,2.5) AA16(-7.5,2.5) AA17(-6.5,2.5) AA18(-5.5,2.5) AA19(-4.5,2.5) AA20(-3.5,2.5) AA21(-2.5,2.5) AA22(-1.5,2.5) AA23(-0.5,2.5) AA24(0.5,2.5) AA25(1.5,2.5) AA26(2.5,2.5) AA27(3.5,2.5) AA28(4.5,2.5) AA29(5.5,2.5) AA30(6.5,2.5) AA31(7.5,2.5) AA32(8.5,2.5) AA33(9.5,2.5) AA34(10.5,2.5) AA35(11.5,2.5) AA36(12.5,2.5) AA37(13.5,2.5) AA38(14.5,2.5) AA39(15.5,2.5) AA40(16.5,2.5) AA41(17.5,2.5) AA42(18.5,2.5) AA43(19.5,2.5) AA44(20.5,2.5) AA45(21.5,2.5) AA46(22.5,2.5) AB1(-22.5,1.5) AB2(-21.5,1.5) AB3(-20.5,1.5) AB4(-19.5,1.5) AB5(-18.5,1.5) AB6(-17.5,1.5) AB7(-16.5,1.5) AB8(-15.5,1.5) AB9(-14.5,1.5) AB10(-13.5,1.5) AB11(-12.5,1.5) AB12(-11.5,1.5) AB13(-10.5,1.5) AB14(-9.5,1.5) AB15(-8.5,1.5) AB16(-7.5,1.5) AB17(-6.5,1.5) AB18(-5.5,1.5) AB19(-4.5,1.5) AB20(-3.5,1.5) AB21(-2.5,1.5) AB22(-1.5,1.5) AB23(-0.5,1.5) AB24(0.5,1.5) AB25(1.5,1.5) AB26(2.5,1.5) AB27(3.5,1.5) AB28(4.5,1.5) AB29(5.5,1.5) AB30(6.5,1.5) AB31(7.5,1.5) AB32(8.5,1.5) AB33(9.5,1.5) AB34(10.5,1.5) AB35(11.5,1.5) AB36(12.5,1.5) AB37(13.5,1.5) AB38(14.5,1.5) AB39(15.5,1.5) AB40(16.5,1.5) AB41(17.5,1.5) AB42(18.5,1.5) AB43(19.5,1.5) AB44(20.5,1.5) AB45(21.5,1.5) AB46(22.5,1.5) AC1(-22.5,0.5) AC2(-21.5,0.5) AC3(-20.5,0.5) AC4(-19.5,0.5) AC5(-18.5,0.5) AC6(-17.5,0.5) AC7(-16.5,0.5) AC8(-15.5,0.5) AC9(-14.5,0.5) AC10(-13.5,0.5) AC11(-12.5,0.5) AC12(-11.5,0.5) AC13(-10.5,0.5) AC14(-9.5,0.5) AC15(-8.5,0.5) AC16(-7.5,0.5) AC17(-6.5,0.5) AC18(-5.5,0.5) AC19(-4.5,0.5) AC20(-3.5,0.5) AC21(-2.5,0.5) AC22(-1.5,0.5) AC23(-0.5,0.5) AC24(0.5,0.5) AC25(1.5,0.5) AC26(2.5,0.5) AC27(3.5,0.5) AC28(4.5,0.5) AC29(5.5,0.5) AC30(6.5,0.5) AC31(7.5,0.5) AC32(8.5,0.5) AC33(9.5,0.5) AC34(10.5,0.5) AC35(11.5,0.5) AC36(12.5,0.5) AC37(13.5,0.5) AC38(14.5,0.5) AC39(15.5,0.5) AC40(16.5,0.5) AC41(17.5,0.5) AC42(18.5,0.5) AC43(19.5,0.5) AC44(20.5,0.5) AC45(21.5,0.5) AC46(22.5,0.5) AD1(-22.5,-0.5) AD2(-21.5,-0.5) AD3(-20.5,-0.5) AD4(-19.5,-0.5) AD5(-18.5,-0.5) AD6(-17.5,-0.5) AD7(-16.5,-0.5) AD8(-15.5,-0.5) AD9(-14.5,-0.5) AD10(-13.5,-0.5) AD11(-12.5,-0.5) AD12(-11.5,-0.5) AD13(-10.5,-0.5) AD14(-9.5,-0.5) AD15(-8.5,-0.5) AD16(-7.5,-0.5) AD17(-6.5,-0.5) AD18(-5.5,-0.5) AD19(-4.5,-0.5) AD20(-3.5,-0.5) AD21(-2.5,-0.5) AD22(-1.5,-0.5) AD23(-0.5,-0.5) AD24(0.5,-0.5) AD25(1.5,-0.5) AD26(2.5,-0.5) AD27(3.5,-0.5) AD28(4.5,-0.5) AD29(5.5,-0.5) AD30(6.5,-0.5) AD31(7.5,-0.5) AD32(8.5,-0.5) AD33(9.5,-0.5) AD34(10.5,-0.5) AD35(11.5,-0.5) AD36(12.5,-0.5) AD37(13.5,-0.5) AD38(14.5,-0.5) AD39(15.5,-0.5) AD40(16.5,-0.5) AD41(17.5,-0.5) AD42(18.5,-0.5) AD43(19.5,-0.5) AD44(20.5,-0.5) AD45(21.5,-0.5) AD46(22.5,-0.5) AE1(-22.5,-1.5) AE2(-21.5,-1.5) AE3(-20.5,-1.5) AE4(-19.5,-1.5) AE5(-18.5,-1.5) AE6(-17.5,-1.5) AE7(-16.5,-1.5) AE8(-15.5,-1.5) AE9(-14.5,-1.5) AE10(-13.5,-1.5) AE11(-12.5,-1.5) AE12(-11.5,-1.5) AE13(-10.5,-1.5) AE14(-9.5,-1.5) AE15(-8.5,-1.5) AE16(-7.5,-1.5) AE17(-6.5,-1.5) AE18(-5.5,-1.5) AE19(-4.5,-1.5) AE20(-3.5,-1.5) AE21(-2.5,-1.5) AE22(-1.5,-1.5) AE23(-0.5,-1.5) AE24(0.5,-1.5) AE25(1.5,-1.5) AE26(2.5,-1.5) AE27(3.5,-1.5) AE28(4.5,-1.5) AE29(5.5,-1.5) AE30(6.5,-1.5) AE31(7.5,-1.5) AE32(8.5,-1.5) AE33(9.5,-1.5) AE34(10.5,-1.5) AE35(11.5,-1.5) AE36(12.5,-1.5) AE37(13.5,-1.5) AE38(14.5,-1.5) AE39(15.5,-1.5) AE40(16.5,-1.5) AE41(17.5,-1.5) AE42(18.5,-1.5) AE43(19.5,-1.5) AE44(20.5,-1.5) AE45(21.5,-1.5) AE46(22.5,-1.5) AF1(-22.5,-2.5) AF2(-21.5,-2.5) AF3(-20.5,-2.5) AF4(-19.5,-2.5) AF5(-18.5,-2.5) AF6(-17.5,-2.5) AF7(-16.5,-2.5) AF8(-15.5,-2.5) AF9(-14.5,-2.5) AF10(-13.5,-2.5) AF11(-12.5,-2.5) AF12(-11.5,-2.5) AF13(-10.5,-2.5) AF14(-9.5,-2.5) AF15(-8.5,-2.5) AF16(-7.5,-2.5) AF17(-6.5,-2.5) AF18(-5.5,-2.5) AF19(-4.5,-2.5) AF20(-3.5,-2.5) AF21(-2.5,-2.5) AF22(-1.5,-2.5) AF23(-0.5,-2.5) AF24(0.5,-2.5) AF25(1.5,-2.5) AF26(2.5,-2.5) AF27(3.5,-2.5) AF28(4.5,-2.5) AF29(5.5,-2.5) AF30(6.5,-2.5) AF31(7.5,-2.5) AF32(8.5,-2.5) AF33(9.5,-2.5) AF34(10.5,-2.5) AF35(11.5,-2.5) AF36(12.5,-2.5) AF37(13.5,-2.5) AF38(14.5,-2.5) AF39(15.5,-2.5) AF40(16.5,-2.5) AF41(17.5,-2.5) AF42(18.5,-2.5) AF43(19.5,-2.5) AF44(20.5,-2.5) AF45(21.5,-2.5) AF46(22.5,-2.5) AG1(-22.5,-3.5) AG2(-21.5,-3.5) AG3(-20.5,-3.5) AG4(-19.5,-3.5) AG5(-18.5,-3.5) AG6(-17.5,-3.5) AG7(-16.5,-3.5) AG8(-15.5,-3.5) AG9(-14.5,-3.5) AG10(-13.5,-3.5) AG11(-12.5,-3.5) AG12(-11.5,-3.5) AG13(-10.5,-3.5) AG14(-9.5,-3.5) AG15(-8.5,-3.5) AG16(-7.5,-3.5) AG17(-6.5,-3.5) AG18(-5.5,-3.5) AG19(-4.5,-3.5) AG20(-3.5,-3.5) AG21(-2.5,-3.5) AG22(-1.5,-3.5) AG23(-0.5,-3.5) AG24(0.5,-3.5) AG25(1.5,-3.5) AG26(2.5,-3.5) AG27(3.5,-3.5) AG28(4.5,-3.5) AG29(5.5,-3.5) AG30(6.5,-3.5) AG31(7.5,-3.5) AG32(8.5,-3.5) AG33(9.5,-3.5) AG34(10.5,-3.5) AG35(11.5,-3.5) AG36(12.5,-3.5) AG37(13.5,-3.5) AG38(14.5,-3.5) AG39(15.5,-3.5) AG40(16.5,-3.5) AG41(17.5,-3.5) AG42(18.5,-3.5) AG43(19.5,-3.5) AG44(20.5,-3.5) AG45(21.5,-3.5) AG46(22.5,-3.5) AH1(-22.5,-4.5) AH2(-21.5,-4.5) AH3(-20.5,-4.5) AH4(-19.5,-4.5) AH5(-18.5,-4.5) AH6(-17.5,-4.5) AH7(-16.5,-4.5) AH8(-15.5,-4.5) AH9(-14.5,-4.5) AH10(-13.5,-4.5) AH11(-12.5,-4.5) AH12(-11.5,-4.5) AH13(-10.5,-4.5) AH14(-9.5,-4.5) AH15(-8.5,-4.5) AH16(-7.5,-4.5) AH17(-6.5,-4.5) AH18(-5.5,-4.5) AH19(-4.5,-4.5) AH20(-3.5,-4.5) AH21(-2.5,-4.5) AH22(-1.5,-4.5) AH23(-0.5,-4.5) AH24(0.5,-4.5) AH25(1.5,-4.5) AH26(2.5,-4.5) AH27(3.5,-4.5) AH28(4.5,-4.5) AH29(5.5,-4.5) AH30(6.5,-4.5) AH31(7.5,-4.5) AH32(8.5,-4.5) AH33(9.5,-4.5) AH34(10.5,-4.5) AH35(11.5,-4.5) AH36(12.5,-4.5) AH37(13.5,-4.5) AH38(14.5,-4.5) AH39(15.5,-4.5) AH40(16.5,-4.5) AH41(17.5,-4.5) AH42(18.5,-4.5) AH43(19.5,-4.5) AH44(20.5,-4.5) AH45(21.5,-4.5) AH46(22.5,-4.5) AJ1(-22.5,-5.5) AJ2(-21.5,-5.5) AJ3(-20.5,-5.5) AJ4(-19.5,-5.5) AJ5(-18.5,-5.5) AJ6(-17.5,-5.5) AJ7(-16.5,-5.5) AJ8(-15.5,-5.5) AJ9(-14.5,-5.5) AJ10(-13.5,-5.5) AJ11(-12.5,-5.5) AJ12(-11.5,-5.5) AJ13(-10.5,-5.5) AJ14(-9.5,-5.5) AJ15(-8.5,-5.5) AJ16(-7.5,-5.5) AJ17(-6.5,-5.5) AJ18(-5.5,-5.5) AJ19(-4.5,-5.5) AJ20(-3.5,-5.5) AJ21(-2.5,-5.5) AJ22(-1.5,-5.5) AJ23(-0.5,-5.5) AJ24(0.5,-5.5) AJ25(1.5,-5.5) AJ26(2.5,-5.5) AJ27(3.5,-5.5) AJ28(4.5,-5.5) AJ29(5.5,-5.5) AJ30(6.5,-5.5) AJ31(7.5,-5.5) AJ32(8.5,-5.5) AJ33(9.5,-5.5) AJ34(10.5,-5.5) AJ35(11.5,-5.5) AJ36(12.5,-5.5) AJ37(13.5,-5.5) AJ38(14.5,-5.5) AJ39(15.5,-5.5) AJ40(16.5,-5.5) AJ41(17.5,-5.5) AJ42(18.5,-5.5) AJ43(19.5,-5.5) AJ44(20.5,-5.5) AJ45(21.5,-5.5) AJ46(22.5,-5.5) AK1(-22.5,-6.5) AK2(-21.5,-6.5) AK3(-20.5,-6.5) AK4(-19.5,-6.5) AK5(-18.5,-6.5) AK6(-17.5,-6.5) AK7(-16.5,-6.5) AK8(-15.5,-6.5) AK9(-14.5,-6.5) AK10(-13.5,-6.5) AK11(-12.5,-6.5) AK12(-11.5,-6.5) AK13(-10.5,-6.5) AK14(-9.5,-6.5) AK15(-8.5,-6.5) AK16(-7.5,-6.5) AK17(-6.5,-6.5) AK18(-5.5,-6.5) AK19(-4.5,-6.5) AK20(-3.5,-6.5) AK21(-2.5,-6.5) AK22(-1.5,-6.5) AK23(-0.5,-6.5) AK24(0.5,-6.5) AK25(1.5,-6.5) AK26(2.5,-6.5) AK27(3.5,-6.5) AK28(4.5,-6.5) AK29(5.5,-6.5) AK30(6.5,-6.5) AK31(7.5,-6.5) AK32(8.5,-6.5) AK33(9.5,-6.5) AK34(10.5,-6.5) AK35(11.5,-6.5) AK36(12.5,-6.5) AK37(13.5,-6.5) AK38(14.5,-6.5) AK39(15.5,-6.5) AK40(16.5,-6.5) AK41(17.5,-6.5) AK42(18.5,-6.5) AK43(19.5,-6.5) AK44(20.5,-6.5) AK45(21.5,-6.5) AK46(22.5,-6.5) AL1(-22.5,-7.5) AL2(-21.5,-7.5) AL3(-20.5,-7.5) AL4(-19.5,-7.5) AL5(-18.5,-7.5) AL6(-17.5,-7.5) AL7(-16.5,-7.5) AL8(-15.5,-7.5) AL9(-14.5,-7.5) AL10(-13.5,-7.5) AL11(-12.5,-7.5) AL12(-11.5,-7.5) AL13(-10.5,-7.5) AL14(-9.5,-7.5) AL15(-8.5,-7.5) AL16(-7.5,-7.5) AL17(-6.5,-7.5) AL18(-5.5,-7.5) AL19(-4.5,-7.5) AL20(-3.5,-7.5) AL21(-2.5,-7.5) AL22(-1.5,-7.5) AL23(-0.5,-7.5) AL24(0.5,-7.5) AL25(1.5,-7.5) AL26(2.5,-7.5) AL27(3.5,-7.5) AL28(4.5,-7.5) AL29(5.5,-7.5) AL30(6.5,-7.5) AL31(7.5,-7.5) AL32(8.5,-7.5) AL33(9.5,-7.5) AL34(10.5,-7.5) AL35(11.5,-7.5) AL36(12.5,-7.5) AL37(13.5,-7.5) AL38(14.5,-7.5) AL39(15.5,-7.5) AL40(16.5,-7.5) AL41(17.5,-7.5) AL42(18.5,-7.5) AL43(19.5,-7.5) AL44(20.5,-7.5) AL45(21.5,-7.5) AL46(22.5,-7.5) AM1(-22.5,-8.5) AM2(-21.5,-8.5) AM3(-20.5,-8.5) AM4(-19.5,-8.5) AM5(-18.5,-8.5) AM6(-17.5,-8.5) AM7(-16.5,-8.5) AM8(-15.5,-8.5) AM9(-14.5,-8.5) AM10(-13.5,-8.5) AM11(-12.5,-8.5) AM12(-11.5,-8.5) AM13(-10.5,-8.5) AM14(-9.5,-8.5) AM15(-8.5,-8.5) AM16(-7.5,-8.5) AM17(-6.5,-8.5) AM18(-5.5,-8.5) AM19(-4.5,-8.5) AM20(-3.5,-8.5) AM21(-2.5,-8.5) AM22(-1.5,-8.5) AM23(-0.5,-8.5) AM24(0.5,-8.5) AM25(1.5,-8.5) AM26(2.5,-8.5) AM27(3.5,-8.5) AM28(4.5,-8.5) AM29(5.5,-8.5) AM30(6.5,-8.5) AM31(7.5,-8.5) AM32(8.5,-8.5) AM33(9.5,-8.5) AM34(10.5,-8.5) AM35(11.5,-8.5) AM36(12.5,-8.5) AM37(13.5,-8.5) AM38(14.5,-8.5) AM39(15.5,-8.5) AM40(16.5,-8.5) AM41(17.5,-8.5) AM42(18.5,-8.5) AM43(19.5,-8.5) AM44(20.5,-8.5) AM45(21.5,-8.5) AM46(22.5,-8.5) AN1(-22.5,-9.5) AN2(-21.5,-9.5) AN3(-20.5,-9.5) AN4(-19.5,-9.5) AN5(-18.5,-9.5) AN6(-17.5,-9.5) AN7(-16.5,-9.5) AN8(-15.5,-9.5) AN9(-14.5,-9.5) AN10(-13.5,-9.5) AN11(-12.5,-9.5) AN12(-11.5,-9.5) AN13(-10.5,-9.5) AN14(-9.5,-9.5) AN15(-8.5,-9.5) AN16(-7.5,-9.5) AN17(-6.5,-9.5) AN18(-5.5,-9.5) AN19(-4.5,-9.5) AN20(-3.5,-9.5) AN21(-2.5,-9.5) AN22(-1.5,-9.5) AN23(-0.5,-9.5) AN24(0.5,-9.5) AN25(1.5,-9.5) AN26(2.5,-9.5) AN27(3.5,-9.5) AN28(4.5,-9.5) AN29(5.5,-9.5) AN30(6.5,-9.5) AN31(7.5,-9.5) AN32(8.5,-9.5) AN33(9.5,-9.5) AN34(10.5,-9.5) AN35(11.5,-9.5) AN36(12.5,-9.5) AN37(13.5,-9.5) AN38(14.5,-9.5) AN39(15.5,-9.5) AN40(16.5,-9.5) AN41(17.5,-9.5) AN42(18.5,-9.5) AN43(19.5,-9.5) AN44(20.5,-9.5) AN45(21.5,-9.5) AN46(22.5,-9.5) AP1(-22.5,-10.5) AP2(-21.5,-10.5) AP3(-20.5,-10.5) AP4(-19.5,-10.5) AP5(-18.5,-10.5) AP6(-17.5,-10.5) AP7(-16.5,-10.5) AP8(-15.5,-10.5) AP9(-14.5,-10.5) AP10(-13.5,-10.5) AP11(-12.5,-10.5) AP12(-11.5,-10.5) AP13(-10.5,-10.5) AP14(-9.5,-10.5) AP15(-8.5,-10.5) AP16(-7.5,-10.5) AP17(-6.5,-10.5) AP18(-5.5,-10.5) AP19(-4.5,-10.5) AP20(-3.5,-10.5) AP21(-2.5,-10.5) AP22(-1.5,-10.5) AP23(-0.5,-10.5) AP24(0.5,-10.5) AP25(1.5,-10.5) AP26(2.5,-10.5) AP27(3.5,-10.5) AP28(4.5,-10.5) AP29(5.5,-10.5) AP30(6.5,-10.5) AP31(7.5,-10.5) AP32(8.5,-10.5) AP33(9.5,-10.5) AP34(10.5,-10.5) AP35(11.5,-10.5) AP36(12.5,-10.5) AP37(13.5,-10.5) AP38(14.5,-10.5) AP39(15.5,-10.5) AP40(16.5,-10.5) AP41(17.5,-10.5) AP42(18.5,-10.5) AP43(19.5,-10.5) AP44(20.5,-10.5) AP45(21.5,-10.5) AP46(22.5,-10.5) AR1(-22.5,-11.5) AR2(-21.5,-11.5) AR3(-20.5,-11.5) AR4(-19.5,-11.5) AR5(-18.5,-11.5) AR6(-17.5,-11.5) AR7(-16.5,-11.5) AR8(-15.5,-11.5) AR9(-14.5,-11.5) AR10(-13.5,-11.5) AR11(-12.5,-11.5) AR12(-11.5,-11.5) AR13(-10.5,-11.5) AR14(-9.5,-11.5) AR15(-8.5,-11.5) AR16(-7.5,-11.5) AR17(-6.5,-11.5) AR18(-5.5,-11.5) AR19(-4.5,-11.5) AR20(-3.5,-11.5) AR21(-2.5,-11.5) AR22(-1.5,-11.5) AR23(-0.5,-11.5) AR24(0.5,-11.5) AR25(1.5,-11.5) AR26(2.5,-11.5) AR27(3.5,-11.5) AR28(4.5,-11.5) AR29(5.5,-11.5) AR30(6.5,-11.5) AR31(7.5,-11.5) AR32(8.5,-11.5) AR33(9.5,-11.5) AR34(10.5,-11.5) AR35(11.5,-11.5) AR36(12.5,-11.5) AR37(13.5,-11.5) AR38(14.5,-11.5) AR39(15.5,-11.5) AR40(16.5,-11.5) AR41(17.5,-11.5) AR42(18.5,-11.5) AR43(19.5,-11.5) AR44(20.5,-11.5) AR45(21.5,-11.5) AR46(22.5,-11.5) AT1(-22.5,-12.5) AT2(-21.5,-12.5) AT3(-20.5,-12.5) AT4(-19.5,-12.5) AT5(-18.5,-12.5) AT6(-17.5,-12.5) AT7(-16.5,-12.5) AT8(-15.5,-12.5) AT9(-14.5,-12.5) AT10(-13.5,-12.5) AT11(-12.5,-12.5) AT12(-11.5,-12.5) AT13(-10.5,-12.5) AT14(-9.5,-12.5) AT15(-8.5,-12.5) AT16(-7.5,-12.5) AT17(-6.5,-12.5) AT18(-5.5,-12.5) AT19(-4.5,-12.5) AT20(-3.5,-12.5) AT21(-2.5,-12.5) AT22(-1.5,-12.5) AT23(-0.5,-12.5) AT24(0.5,-12.5) AT25(1.5,-12.5) AT26(2.5,-12.5) AT27(3.5,-12.5) AT28(4.5,-12.5) AT29(5.5,-12.5) AT30(6.5,-12.5) AT31(7.5,-12.5) AT32(8.5,-12.5) AT33(9.5,-12.5) AT34(10.5,-12.5) AT35(11.5,-12.5) AT36(12.5,-12.5) AT37(13.5,-12.5) AT38(14.5,-12.5) AT39(15.5,-12.5) AT40(16.5,-12.5) AT41(17.5,-12.5) AT42(18.5,-12.5) AT43(19.5,-12.5) AT44(20.5,-12.5) AT45(21.5,-12.5) AT46(22.5,-12.5) AU1(-22.5,-13.5) AU2(-21.5,-13.5) AU3(-20.5,-13.5) AU4(-19.5,-13.5) AU5(-18.5,-13.5) AU6(-17.5,-13.5) AU7(-16.5,-13.5) AU8(-15.5,-13.5) AU9(-14.5,-13.5) AU10(-13.5,-13.5) AU11(-12.5,-13.5) AU12(-11.5,-13.5) AU13(-10.5,-13.5) AU14(-9.5,-13.5) AU15(-8.5,-13.5) AU16(-7.5,-13.5) AU17(-6.5,-13.5) AU18(-5.5,-13.5) AU19(-4.5,-13.5) AU20(-3.5,-13.5) AU21(-2.5,-13.5) AU22(-1.5,-13.5) AU23(-0.5,-13.5) AU24(0.5,-13.5) AU25(1.5,-13.5) AU26(2.5,-13.5) AU27(3.5,-13.5) AU28(4.5,-13.5) AU29(5.5,-13.5) AU30(6.5,-13.5) AU31(7.5,-13.5) AU32(8.5,-13.5) AU33(9.5,-13.5) AU34(10.5,-13.5) AU35(11.5,-13.5) AU36(12.5,-13.5) AU37(13.5,-13.5) AU38(14.5,-13.5) AU39(15.5,-13.5) AU40(16.5,-13.5) AU41(17.5,-13.5) AU42(18.5,-13.5) AU43(19.5,-13.5) AU44(20.5,-13.5) AU45(21.5,-13.5) AU46(22.5,-13.5) AV1(-22.5,-14.5) AV2(-21.5,-14.5) AV3(-20.5,-14.5) AV4(-19.5,-14.5) AV5(-18.5,-14.5) AV6(-17.5,-14.5) AV7(-16.5,-14.5) AV8(-15.5,-14.5) AV9(-14.5,-14.5) AV10(-13.5,-14.5) AV11(-12.5,-14.5) AV12(-11.5,-14.5) AV13(-10.5,-14.5) AV14(-9.5,-14.5) AV15(-8.5,-14.5) AV16(-7.5,-14.5) AV17(-6.5,-14.5) AV18(-5.5,-14.5) AV19(-4.5,-14.5) AV20(-3.5,-14.5) AV21(-2.5,-14.5) AV22(-1.5,-14.5) AV23(-0.5,-14.5) AV24(0.5,-14.5) AV25(1.5,-14.5) AV26(2.5,-14.5) AV27(3.5,-14.5) AV28(4.5,-14.5) AV29(5.5,-14.5) AV30(6.5,-14.5) AV31(7.5,-14.5) AV32(8.5,-14.5) AV33(9.5,-14.5) AV34(10.5,-14.5) AV35(11.5,-14.5) AV36(12.5,-14.5) AV37(13.5,-14.5) AV38(14.5,-14.5) AV39(15.5,-14.5) AV40(16.5,-14.5) AV41(17.5,-14.5) AV42(18.5,-14.5) AV43(19.5,-14.5) AV44(20.5,-14.5) AV45(21.5,-14.5) AV46(22.5,-14.5) AW1(-22.5,-15.5) AW2(-21.5,-15.5) AW3(-20.5,-15.5) AW4(-19.5,-15.5) AW5(-18.5,-15.5) AW6(-17.5,-15.5) AW7(-16.5,-15.5) AW8(-15.5,-15.5) AW9(-14.5,-15.5) AW10(-13.5,-15.5) AW11(-12.5,-15.5) AW12(-11.5,-15.5) AW13(-10.5,-15.5) AW14(-9.5,-15.5) AW15(-8.5,-15.5) AW16(-7.5,-15.5) AW17(-6.5,-15.5) AW18(-5.5,-15.5) AW19(-4.5,-15.5) AW20(-3.5,-15.5) AW21(-2.5,-15.5) AW22(-1.5,-15.5) AW23(-0.5,-15.5) AW24(0.5,-15.5) AW25(1.5,-15.5) AW26(2.5,-15.5) AW27(3.5,-15.5) AW28(4.5,-15.5) AW29(5.5,-15.5) AW30(6.5,-15.5) AW31(7.5,-15.5) AW32(8.5,-15.5) AW33(9.5,-15.5) AW34(10.5,-15.5) AW35(11.5,-15.5) AW36(12.5,-15.5) AW37(13.5,-15.5) AW38(14.5,-15.5) AW39(15.5,-15.5) AW40(16.5,-15.5) AW41(17.5,-15.5) AW42(18.5,-15.5) AW43(19.5,-15.5) AW44(20.5,-15.5) AW45(21.5,-15.5) AW46(22.5,-15.5) AY1(-22.5,-16.5) AY2(-21.5,-16.5) AY3(-20.5,-16.5) AY4(-19.5,-16.5) AY5(-18.5,-16.5) AY6(-17.5,-16.5) AY7(-16.5,-16.5) AY8(-15.5,-16.5) AY9(-14.5,-16.5) AY10(-13.5,-16.5) AY11(-12.5,-16.5) AY12(-11.5,-16.5) AY13(-10.5,-16.5) AY14(-9.5,-16.5) AY15(-8.5,-16.5) AY16(-7.5,-16.5) AY17(-6.5,-16.5) AY18(-5.5,-16.5) AY19(-4.5,-16.5) AY20(-3.5,-16.5) AY21(-2.5,-16.5) AY22(-1.5,-16.5) AY23(-0.5,-16.5) AY24(0.5,-16.5) AY25(1.5,-16.5) AY26(2.5,-16.5) AY27(3.5,-16.5) AY28(4.5,-16.5) AY29(5.5,-16.5) AY30(6.5,-16.5) AY31(7.5,-16.5) AY32(8.5,-16.5) AY33(9.5,-16.5) AY34(10.5,-16.5) AY35(11.5,-16.5) AY36(12.5,-16.5) AY37(13.5,-16.5) AY38(14.5,-16.5) AY39(15.5,-16.5) AY40(16.5,-16.5) AY41(17.5,-16.5) AY42(18.5,-16.5) AY43(19.5,-16.5) AY44(20.5,-16.5) AY45(21.5,-16.5) AY46(22.5,-16.5) B2(-21.5,21.5) B3(-20.5,21.5) B4(-19.5,21.5) B5(-18.5,21.5) B6(-17.5,21.5) B7(-16.5,21.5) B8(-15.5,21.5) B9(-14.5,21.5) B10(-13.5,21.5) B11(-12.5,21.5) B12(-11.5,21.5) B13(-10.5,21.5) B14(-9.5,21.5) B15(-8.5,21.5) B16(-7.5,21.5) B17(-6.5,21.5) B18(-5.5,21.5) B19(-4.5,21.5) B20(-3.5,21.5) B21(-2.5,21.5) B22(-1.5,21.5) B23(-0.5,21.5) B24(0.5,21.5) B25(1.5,21.5) B26(2.5,21.5) B27(3.5,21.5) B28(4.5,21.5) B29(5.5,21.5) B30(6.5,21.5) B31(7.5,21.5) B32(8.5,21.5) B33(9.5,21.5) B34(10.5,21.5) B35(11.5,21.5) B36(12.5,21.5) B37(13.5,21.5) B38(14.5,21.5) B39(15.5,21.5) B40(16.5,21.5) B41(17.5,21.5) B42(18.5,21.5) B43(19.5,21.5) B44(20.5,21.5) B45(21.5,21.5) BA1(-22.5,-17.5) BA2(-21.5,-17.5) BA3(-20.5,-17.5) BA4(-19.5,-17.5) BA5(-18.5,-17.5) BA6(-17.5,-17.5) BA7(-16.5,-17.5) BA8(-15.5,-17.5) BA9(-14.5,-17.5) BA10(-13.5,-17.5) BA11(-12.5,-17.5) BA12(-11.5,-17.5) BA13(-10.5,-17.5) BA14(-9.5,-17.5) BA15(-8.5,-17.5) BA16(-7.5,-17.5) BA17(-6.5,-17.5) BA18(-5.5,-17.5) BA19(-4.5,-17.5) BA20(-3.5,-17.5) BA21(-2.5,-17.5) BA22(-1.5,-17.5) BA23(-0.5,-17.5) BA24(0.5,-17.5) BA25(1.5,-17.5) BA26(2.5,-17.5) BA27(3.5,-17.5) BA28(4.5,-17.5) BA29(5.5,-17.5) BA30(6.5,-17.5) BA31(7.5,-17.5) BA32(8.5,-17.5) BA33(9.5,-17.5) BA34(10.5,-17.5) BA35(11.5,-17.5) BA36(12.5,-17.5) BA37(13.5,-17.5) BA38(14.5,-17.5) BA39(15.5,-17.5) BA40(16.5,-17.5) BA41(17.5,-17.5) BA42(18.5,-17.5) BA43(19.5,-17.5) BA44(20.5,-17.5) BA45(21.5,-17.5) BA46(22.5,-17.5) BB1(-22.5,-18.5) BB2(-21.5,-18.5) BB3(-20.5,-18.5) BB4(-19.5,-18.5) BB5(-18.5,-18.5) BB6(-17.5,-18.5) BB7(-16.5,-18.5) BB8(-15.5,-18.5) BB9(-14.5,-18.5) BB10(-13.5,-18.5) BB11(-12.5,-18.5) BB12(-11.5,-18.5) BB13(-10.5,-18.5) BB14(-9.5,-18.5) BB15(-8.5,-18.5) BB16(-7.5,-18.5) BB17(-6.5,-18.5) BB18(-5.5,-18.5) BB19(-4.5,-18.5) BB20(-3.5,-18.5) BB21(-2.5,-18.5) BB22(-1.5,-18.5) BB23(-0.5,-18.5) BB24(0.5,-18.5) BB25(1.5,-18.5) BB26(2.5,-18.5) BB27(3.5,-18.5) BB28(4.5,-18.5) BB29(5.5,-18.5) BB30(6.5,-18.5) BB31(7.5,-18.5) BB32(8.5,-18.5) BB33(9.5,-18.5) BB34(10.5,-18.5) BB35(11.5,-18.5) BB36(12.5,-18.5) BB37(13.5,-18.5) BB38(14.5,-18.5) BB39(15.5,-18.5) BB40(16.5,-18.5) BB41(17.5,-18.5) BB42(18.5,-18.5) BB43(19.5,-18.5) BB44(20.5,-18.5) BB45(21.5,-18.5) BB46(22.5,-18.5) BC1(-22.5,-19.5) BC2(-21.5,-19.5) BC3(-20.5,-19.5) BC4(-19.5,-19.5) BC5(-18.5,-19.5) BC6(-17.5,-19.5) BC7(-16.5,-19.5) BC8(-15.5,-19.5) BC9(-14.5,-19.5) BC10(-13.5,-19.5) BC11(-12.5,-19.5) BC12(-11.5,-19.5) BC13(-10.5,-19.5) BC14(-9.5,-19.5) BC15(-8.5,-19.5) BC16(-7.5,-19.5) BC17(-6.5,-19.5) BC18(-5.5,-19.5) BC19(-4.5,-19.5) BC20(-3.5,-19.5) BC21(-2.5,-19.5) BC22(-1.5,-19.5) BC23(-0.5,-19.5) BC24(0.5,-19.5) BC25(1.5,-19.5) BC26(2.5,-19.5) BC27(3.5,-19.5) BC28(4.5,-19.5) BC29(5.5,-19.5) BC30(6.5,-19.5) BC31(7.5,-19.5) BC32(8.5,-19.5) BC33(9.5,-19.5) BC34(10.5,-19.5) BC35(11.5,-19.5) BC36(12.5,-19.5) BC37(13.5,-19.5) BC38(14.5,-19.5) BC39(15.5,-19.5) BC40(16.5,-19.5) BC41(17.5,-19.5) BC42(18.5,-19.5) BC43(19.5,-19.5) BC44(20.5,-19.5) BC45(21.5,-19.5) BC46(22.5,-19.5) BD1(-22.5,-20.5) BD2(-21.5,-20.5) BD3(-20.5,-20.5) BD4(-19.5,-20.5) BD5(-18.5,-20.5) BD6(-17.5,-20.5) BD7(-16.5,-20.5) BD8(-15.5,-20.5) BD9(-14.5,-20.5) BD10(-13.5,-20.5) BD11(-12.5,-20.5) BD12(-11.5,-20.5) BD13(-10.5,-20.5) BD14(-9.5,-20.5) BD15(-8.5,-20.5) BD16(-7.5,-20.5) BD17(-6.5,-20.5) BD18(-5.5,-20.5) BD19(-4.5,-20.5) BD20(-3.5,-20.5) BD21(-2.5,-20.5) BD22(-1.5,-20.5) BD23(-0.5,-20.5) BD24(0.5,-20.5) BD25(1.5,-20.5) BD26(2.5,-20.5) BD27(3.5,-20.5) BD28(4.5,-20.5) BD29(5.5,-20.5) BD30(6.5,-20.5) BD31(7.5,-20.5) BD32(8.5,-20.5) BD33(9.5,-20.5) BD34(10.5,-20.5) BD35(11.5,-20.5) BD36(12.5,-20.5) BD37(13.5,-20.5) BD38(14.5,-20.5) BD39(15.5,-20.5) BD40(16.5,-20.5) BD41(17.5,-20.5) BD42(18.5,-20.5) BD43(19.5,-20.5) BD44(20.5,-20.5) BD45(21.5,-20.5) BD46(22.5,-20.5) BE2(-21.5,-21.5) BE3(-20.5,-21.5) BE4(-19.5,-21.5) BE5(-18.5,-21.5) BE6(-17.5,-21.5) BE7(-16.5,-21.5) BE8(-15.5,-21.5) BE9(-14.5,-21.5) BE10(-13.5,-21.5) BE11(-12.5,-21.5) BE12(-11.5,-21.5) BE13(-10.5,-21.5) BE14(-9.5,-21.5) BE15(-8.5,-21.5) BE16(-7.5,-21.5) BE17(-6.5,-21.5) BE18(-5.5,-21.5) BE19(-4.5,-21.5) BE20(-3.5,-21.5) BE21(-2.5,-21.5) BE22(-1.5,-21.5) BE23(-0.5,-21.5) BE24(0.5,-21.5) BE25(1.5,-21.5) BE26(2.5,-21.5) BE27(3.5,-21.5) BE28(4.5,-21.5) BE29(5.5,-21.5) BE30(6.5,-21.5) BE31(7.5,-21.5) BE32(8.5,-21.5) BE33(9.5,-21.5) BE34(10.5,-21.5) BE35(11.5,-21.5) BE36(12.5,-21.5) BE37(13.5,-21.5) BE38(14.5,-21.5) BE39(15.5,-21.5) BE40(16.5,-21.5) BE41(17.5,-21.5) BE42(18.5,-21.5) BE43(19.5,-21.5) BE44(20.5,-21.5) BE45(21.5,-21.5) BF3(-20.5,-22.5) BF4(-19.5,-22.5) BF5(-18.5,-22.5) BF6(-17.5,-22.5) BF7(-16.5,-22.5) BF8(-15.5,-22.5) BF9(-14.5,-22.5) BF10(-13.5,-22.5) BF11(-12.5,-22.5) BF12(-11.5,-22.5) BF13(-10.5,-22.5) BF14(-9.5,-22.5) BF15(-8.5,-22.5) BF16(-7.5,-22.5) BF17(-6.5,-22.5) BF18(-5.5,-22.5) BF19(-4.5,-22.5) BF20(-3.5,-22.5) BF21(-2.5,-22.5) BF22(-1.5,-22.5) BF23(-0.5,-22.5) BF24(0.5,-22.5) BF25(1.5,-22.5) BF26(2.5,-22.5) BF27(3.5,-22.5) BF28(4.5,-22.5) BF29(5.5,-22.5) BF30(6.5,-22.5) BF31(7.5,-22.5) BF32(8.5,-22.5) BF33(9.5,-22.5) BF34(10.5,-22.5) BF35(11.5,-22.5) BF36(12.5,-22.5) BF37(13.5,-22.5) BF38(14.5,-22.5) BF39(15.5,-22.5) BF40(16.5,-22.5) BF41(17.5,-22.5) BF42(18.5,-22.5) BF43(19.5,-22.5) BF44(20.5,-22.5) C1(-22.5,20.5) C2(-21.5,20.5) C3(-20.5,20.5) C4(-19.5,20.5) C5(-18.5,20.5) C6(-17.5,20.5) C7(-16.5,20.5) C8(-15.5,20.5) C9(-14.5,20.5) C10(-13.5,20.5) C11(-12.5,20.5) C12(-11.5,20.5) C13(-10.5,20.5) C14(-9.5,20.5) C15(-8.5,20.5) C16(-7.5,20.5) C17(-6.5,20.5) C18(-5.5,20.5) C19(-4.5,20.5) C20(-3.5,20.5) C21(-2.5,20.5) C22(-1.5,20.5) C23(-0.5,20.5) C24(0.5,20.5) C25(1.5,20.5) C26(2.5,20.5) C27(3.5,20.5) C28(4.5,20.5) C29(5.5,20.5) C30(6.5,20.5) C31(7.5,20.5) C32(8.5,20.5) C33(9.5,20.5) C34(10.5,20.5) C35(11.5,20.5) C36(12.5,20.5) C37(13.5,20.5) C38(14.5,20.5) C39(15.5,20.5) C40(16.5,20.5) C41(17.5,20.5) C42(18.5,20.5) C43(19.5,20.5) C44(20.5,20.5) C45(21.5,20.5) C46(22.5,20.5) D1(-22.5,19.5) D2(-21.5,19.5) D3(-20.5,19.5) D4(-19.5,19.5) D5(-18.5,19.5) D6(-17.5,19.5) D7(-16.5,19.5) D8(-15.5,19.5) D9(-14.5,19.5) D10(-13.5,19.5) D11(-12.5,19.5) D12(-11.5,19.5) D13(-10.5,19.5) D14(-9.5,19.5) D15(-8.5,19.5) D16(-7.5,19.5) D17(-6.5,19.5) D18(-5.5,19.5) D19(-4.5,19.5) D20(-3.5,19.5) D21(-2.5,19.5) D22(-1.5,19.5) D23(-0.5,19.5) D24(0.5,19.5) D25(1.5,19.5) D26(2.5,19.5) D27(3.5,19.5) D28(4.5,19.5) D29(5.5,19.5) D30(6.5,19.5) D31(7.5,19.5) D32(8.5,19.5) D33(9.5,19.5) D34(10.5,19.5) D35(11.5,19.5) D36(12.5,19.5) D37(13.5,19.5) D38(14.5,19.5) D39(15.5,19.5) D40(16.5,19.5) D41(17.5,19.5) D42(18.5,19.5) D43(19.5,19.5) D44(20.5,19.5) D45(21.5,19.5) D46(22.5,19.5) E1(-22.5,18.5) E2(-21.5,18.5) E3(-20.5,18.5) E4(-19.5,18.5) E5(-18.5,18.5) E6(-17.5,18.5) E7(-16.5,18.5) E8(-15.5,18.5) E9(-14.5,18.5) E10(-13.5,18.5) E11(-12.5,18.5) E12(-11.5,18.5) E13(-10.5,18.5) E14(-9.5,18.5) E15(-8.5,18.5) E16(-7.5,18.5) E17(-6.5,18.5) E18(-5.5,18.5) E19(-4.5,18.5) E20(-3.5,18.5) E21(-2.5,18.5) E22(-1.5,18.5) E23(-0.5,18.5) E24(0.5,18.5) E25(1.5,18.5) E26(2.5,18.5) E27(3.5,18.5) E28(4.5,18.5) E29(5.5,18.5) E30(6.5,18.5) E31(7.5,18.5) E32(8.5,18.5) E33(9.5,18.5) E34(10.5,18.5) E35(11.5,18.5) E36(12.5,18.5) E37(13.5,18.5) E38(14.5,18.5) E39(15.5,18.5) E40(16.5,18.5) E41(17.5,18.5) E42(18.5,18.5) E43(19.5,18.5) E44(20.5,18.5) E45(21.5,18.5) E46(22.5,18.5) F1(-22.5,17.5) F2(-21.5,17.5) F3(-20.5,17.5) F4(-19.5,17.5) F5(-18.5,17.5) F6(-17.5,17.5) F7(-16.5,17.5) F8(-15.5,17.5) F9(-14.5,17.5) F10(-13.5,17.5) F11(-12.5,17.5) F12(-11.5,17.5) F13(-10.5,17.5) F14(-9.5,17.5) F15(-8.5,17.5) F16(-7.5,17.5) F17(-6.5,17.5) F18(-5.5,17.5) F19(-4.5,17.5) F20(-3.5,17.5) F21(-2.5,17.5) F22(-1.5,17.5) F23(-0.5,17.5) F24(0.5,17.5) F25(1.5,17.5) F26(2.5,17.5) F27(3.5,17.5) F28(4.5,17.5) F29(5.5,17.5) F30(6.5,17.5) F31(7.5,17.5) F32(8.5,17.5) F33(9.5,17.5) F34(10.5,17.5) F35(11.5,17.5) F36(12.5,17.5) F37(13.5,17.5) F38(14.5,17.5) F39(15.5,17.5) F40(16.5,17.5) F41(17.5,17.5) F42(18.5,17.5) F43(19.5,17.5) F44(20.5,17.5) F45(21.5,17.5) F46(22.5,17.5) G1(-22.5,16.5) G2(-21.5,16.5) G3(-20.5,16.5) G4(-19.5,16.5) G5(-18.5,16.5) G6(-17.5,16.5) G7(-16.5,16.5) G8(-15.5,16.5) G9(-14.5,16.5) G10(-13.5,16.5) G11(-12.5,16.5) G12(-11.5,16.5) G13(-10.5,16.5) G14(-9.5,16.5) G15(-8.5,16.5) G16(-7.5,16.5) G17(-6.5,16.5) G18(-5.5,16.5) G19(-4.5,16.5) G20(-3.5,16.5) G21(-2.5,16.5) G22(-1.5,16.5) G23(-0.5,16.5) G24(0.5,16.5) G25(1.5,16.5) G26(2.5,16.5) G27(3.5,16.5) G28(4.5,16.5) G29(5.5,16.5) G30(6.5,16.5) G31(7.5,16.5) G32(8.5,16.5) G33(9.5,16.5) G34(10.5,16.5) G35(11.5,16.5) G36(12.5,16.5) G37(13.5,16.5) G38(14.5,16.5) G39(15.5,16.5) G40(16.5,16.5) G41(17.5,16.5) G42(18.5,16.5) G43(19.5,16.5) G44(20.5,16.5) G45(21.5,16.5) G46(22.5,16.5) H1(-22.5,15.5) H2(-21.5,15.5) H3(-20.5,15.5) H4(-19.5,15.5) H5(-18.5,15.5) H6(-17.5,15.5) H7(-16.5,15.5) H8(-15.5,15.5) H9(-14.5,15.5) H10(-13.5,15.5) H11(-12.5,15.5) H12(-11.5,15.5) H13(-10.5,15.5) H14(-9.5,15.5) H15(-8.5,15.5) H16(-7.5,15.5) H17(-6.5,15.5) H18(-5.5,15.5) H19(-4.5,15.5) H20(-3.5,15.5) H21(-2.5,15.5) H22(-1.5,15.5) H23(-0.5,15.5) H24(0.5,15.5) H25(1.5,15.5) H26(2.5,15.5) H27(3.5,15.5) H28(4.5,15.5) H29(5.5,15.5) H30(6.5,15.5) H31(7.5,15.5) H32(8.5,15.5) H33(9.5,15.5) H34(10.5,15.5) H35(11.5,15.5) H36(12.5,15.5) H37(13.5,15.5) H38(14.5,15.5) H39(15.5,15.5) H40(16.5,15.5) H41(17.5,15.5) H42(18.5,15.5) H43(19.5,15.5) H44(20.5,15.5) H45(21.5,15.5) H46(22.5,15.5) J1(-22.5,14.5) J2(-21.5,14.5) J3(-20.5,14.5) J4(-19.5,14.5) J5(-18.5,14.5) J6(-17.5,14.5) J7(-16.5,14.5) J8(-15.5,14.5) J9(-14.5,14.5) J10(-13.5,14.5) J11(-12.5,14.5) J12(-11.5,14.5) J13(-10.5,14.5) J14(-9.5,14.5) J15(-8.5,14.5) J16(-7.5,14.5) J17(-6.5,14.5) J18(-5.5,14.5) J19(-4.5,14.5) J20(-3.5,14.5) J21(-2.5,14.5) J22(-1.5,14.5) J23(-0.5,14.5) J24(0.5,14.5) J25(1.5,14.5) J26(2.5,14.5) J27(3.5,14.5) J28(4.5,14.5) J29(5.5,14.5) J30(6.5,14.5) J31(7.5,14.5) J32(8.5,14.5) J33(9.5,14.5) J34(10.5,14.5) J35(11.5,14.5) J36(12.5,14.5) J37(13.5,14.5) J38(14.5,14.5) J39(15.5,14.5) J40(16.5,14.5) J41(17.5,14.5) J42(18.5,14.5) J43(19.5,14.5) J44(20.5,14.5) J45(21.5,14.5) J46(22.5,14.5) K1(-22.5,13.5) K2(-21.5,13.5) K3(-20.5,13.5) K4(-19.5,13.5) K5(-18.5,13.5) K6(-17.5,13.5) K7(-16.5,13.5) K8(-15.5,13.5) K9(-14.5,13.5) K10(-13.5,13.5) K11(-12.5,13.5) K12(-11.5,13.5) K13(-10.5,13.5) K14(-9.5,13.5) K15(-8.5,13.5) K16(-7.5,13.5) K17(-6.5,13.5) K18(-5.5,13.5) K19(-4.5,13.5) K20(-3.5,13.5) K21(-2.5,13.5) K22(-1.5,13.5) K23(-0.5,13.5) K24(0.5,13.5) K25(1.5,13.5) K26(2.5,13.5) K27(3.5,13.5) K28(4.5,13.5) K29(5.5,13.5) K30(6.5,13.5) K31(7.5,13.5) K32(8.5,13.5) K33(9.5,13.5) K34(10.5,13.5) K35(11.5,13.5) K36(12.5,13.5) K37(13.5,13.5) K38(14.5,13.5) K39(15.5,13.5) K40(16.5,13.5) K41(17.5,13.5) K42(18.5,13.5) K43(19.5,13.5) K44(20.5,13.5) K45(21.5,13.5) K46(22.5,13.5) L1(-22.5,12.5) L2(-21.5,12.5) L3(-20.5,12.5) L4(-19.5,12.5) L5(-18.5,12.5) L6(-17.5,12.5) L7(-16.5,12.5) L8(-15.5,12.5) L9(-14.5,12.5) L10(-13.5,12.5) L11(-12.5,12.5) L12(-11.5,12.5) L13(-10.5,12.5) L14(-9.5,12.5) L15(-8.5,12.5) L16(-7.5,12.5) L17(-6.5,12.5) L18(-5.5,12.5) L19(-4.5,12.5) L20(-3.5,12.5) L21(-2.5,12.5) L22(-1.5,12.5) L23(-0.5,12.5) L24(0.5,12.5) L25(1.5,12.5) L26(2.5,12.5) L27(3.5,12.5) L28(4.5,12.5) L29(5.5,12.5) L30(6.5,12.5) L31(7.5,12.5) L32(8.5,12.5) L33(9.5,12.5) L34(10.5,12.5) L35(11.5,12.5) L36(12.5,12.5) L37(13.5,12.5) L38(14.5,12.5) L39(15.5,12.5) L40(16.5,12.5) L41(17.5,12.5) L42(18.5,12.5) L43(19.5,12.5) L44(20.5,12.5) L45(21.5,12.5) L46(22.5,12.5) M1(-22.5,11.5) M2(-21.5,11.5) M3(-20.5,11.5) M4(-19.5,11.5) M5(-18.5,11.5) M6(-17.5,11.5) M7(-16.5,11.5) M8(-15.5,11.5) M9(-14.5,11.5) M10(-13.5,11.5) M11(-12.5,11.5) M12(-11.5,11.5) M13(-10.5,11.5) M14(-9.5,11.5) M15(-8.5,11.5) M16(-7.5,11.5) M17(-6.5,11.5) M18(-5.5,11.5) M19(-4.5,11.5) M20(-3.5,11.5) M21(-2.5,11.5) M22(-1.5,11.5) M23(-0.5,11.5) M24(0.5,11.5) M25(1.5,11.5) M26(2.5,11.5) M27(3.5,11.5) M28(4.5,11.5) M29(5.5,11.5) M30(6.5,11.5) M31(7.5,11.5) M32(8.5,11.5) M33(9.5,11.5) M34(10.5,11.5) M35(11.5,11.5) M36(12.5,11.5) M37(13.5,11.5) M38(14.5,11.5) M39(15.5,11.5) M40(16.5,11.5) M41(17.5,11.5) M42(18.5,11.5) M43(19.5,11.5) M44(20.5,11.5) M45(21.5,11.5) M46(22.5,11.5) N1(-22.5,10.5) N2(-21.5,10.5) N3(-20.5,10.5) N4(-19.5,10.5) N5(-18.5,10.5) N6(-17.5,10.5) N7(-16.5,10.5) N8(-15.5,10.5) N9(-14.5,10.5) N10(-13.5,10.5) N11(-12.5,10.5) N12(-11.5,10.5) N13(-10.5,10.5) N14(-9.5,10.5) N15(-8.5,10.5) N16(-7.5,10.5) N17(-6.5,10.5) N18(-5.5,10.5) N19(-4.5,10.5) N20(-3.5,10.5) N21(-2.5,10.5) N22(-1.5,10.5) N23(-0.5,10.5) N24(0.5,10.5) N25(1.5,10.5) N26(2.5,10.5) N27(3.5,10.5) N28(4.5,10.5) N29(5.5,10.5) N30(6.5,10.5) N31(7.5,10.5) N32(8.5,10.5) N33(9.5,10.5) N34(10.5,10.5) N35(11.5,10.5) N36(12.5,10.5) N37(13.5,10.5) N38(14.5,10.5) N39(15.5,10.5) N40(16.5,10.5) N41(17.5,10.5) N42(18.5,10.5) N43(19.5,10.5) N44(20.5,10.5) N45(21.5,10.5) N46(22.5,10.5) P1(-22.5,9.5) P2(-21.5,9.5) P3(-20.5,9.5) P4(-19.5,9.5) P5(-18.5,9.5) P6(-17.5,9.5) P7(-16.5,9.5) P8(-15.5,9.5) P9(-14.5,9.5) P10(-13.5,9.5) P11(-12.5,9.5) P12(-11.5,9.5) P13(-10.5,9.5) P14(-9.5,9.5) P15(-8.5,9.5) P16(-7.5,9.5) P17(-6.5,9.5) P18(-5.5,9.5) P19(-4.5,9.5) P20(-3.5,9.5) P21(-2.5,9.5) P22(-1.5,9.5) P23(-0.5,9.5) P24(0.5,9.5) P25(1.5,9.5) P26(2.5,9.5) P27(3.5,9.5) P28(4.5,9.5) P29(5.5,9.5) P30(6.5,9.5) P31(7.5,9.5) P32(8.5,9.5) P33(9.5,9.5) P34(10.5,9.5) P35(11.5,9.5) P36(12.5,9.5) P37(13.5,9.5) P38(14.5,9.5) P39(15.5,9.5) P40(16.5,9.5) P41(17.5,9.5) P42(18.5,9.5) P43(19.5,9.5) P44(20.5,9.5) P45(21.5,9.5) P46(22.5,9.5) R1(-22.5,8.5) R2(-21.5,8.5) R3(-20.5,8.5) R4(-19.5,8.5) R5(-18.5,8.5) R6(-17.5,8.5) R7(-16.5,8.5) R8(-15.5,8.5) R9(-14.5,8.5) R10(-13.5,8.5) R11(-12.5,8.5) R12(-11.5,8.5) R13(-10.5,8.5) R14(-9.5,8.5) R15(-8.5,8.5) R16(-7.5,8.5) R17(-6.5,8.5) R18(-5.5,8.5) R19(-4.5,8.5) R20(-3.5,8.5) R21(-2.5,8.5) R22(-1.5,8.5) R23(-0.5,8.5) R24(0.5,8.5) R25(1.5,8.5) R26(2.5,8.5) R27(3.5,8.5) R28(4.5,8.5) R29(5.5,8.5) R30(6.5,8.5) R31(7.5,8.5) R32(8.5,8.5) R33(9.5,8.5) R34(10.5,8.5) R35(11.5,8.5) R36(12.5,8.5) R37(13.5,8.5) R38(14.5,8.5) R39(15.5,8.5) R40(16.5,8.5) R41(17.5,8.5) R42(18.5,8.5) R43(19.5,8.5) R44(20.5,8.5) R45(21.5,8.5) R46(22.5,8.5) T1(-22.5,7.5) T2(-21.5,7.5) T3(-20.5,7.5) T4(-19.5,7.5) T5(-18.5,7.5) T6(-17.5,7.5) T7(-16.5,7.5) T8(-15.5,7.5) T9(-14.5,7.5) T10(-13.5,7.5) T11(-12.5,7.5) T12(-11.5,7.5) T13(-10.5,7.5) T14(-9.5,7.5) T15(-8.5,7.5) T16(-7.5,7.5) T17(-6.5,7.5) T18(-5.5,7.5) T19(-4.5,7.5) T20(-3.5,7.5) T21(-2.5,7.5) T22(-1.5,7.5) T23(-0.5,7.5) T24(0.5,7.5) T25(1.5,7.5) T26(2.5,7.5) T27(3.5,7.5) T28(4.5,7.5) T29(5.5,7.5) T30(6.5,7.5) T31(7.5,7.5) T32(8.5,7.5) T33(9.5,7.5) T34(10.5,7.5) T35(11.5,7.5) T36(12.5,7.5) T37(13.5,7.5) T38(14.5,7.5) T39(15.5,7.5) T40(16.5,7.5) T41(17.5,7.5) T42(18.5,7.5) T43(19.5,7.5) T44(20.5,7.5) T45(21.5,7.5) T46(22.5,7.5) U1(-22.5,6.5) U2(-21.5,6.5) U3(-20.5,6.5) U4(-19.5,6.5) U5(-18.5,6.5) U6(-17.5,6.5) U7(-16.5,6.5) U8(-15.5,6.5) U9(-14.5,6.5) U10(-13.5,6.5) U11(-12.5,6.5) U12(-11.5,6.5) U13(-10.5,6.5) U14(-9.5,6.5) U15(-8.5,6.5) U16(-7.5,6.5) U17(-6.5,6.5) U18(-5.5,6.5) U19(-4.5,6.5) U20(-3.5,6.5) U21(-2.5,6.5) U22(-1.5,6.5) U23(-0.5,6.5) U24(0.5,6.5) U25(1.5,6.5) U26(2.5,6.5) U27(3.5,6.5) U28(4.5,6.5) U29(5.5,6.5) U30(6.5,6.5) U31(7.5,6.5) U32(8.5,6.5) U33(9.5,6.5) U34(10.5,6.5) U35(11.5,6.5) U36(12.5,6.5) U37(13.5,6.5) U38(14.5,6.5) U39(15.5,6.5) U40(16.5,6.5) U41(17.5,6.5) U42(18.5,6.5) U43(19.5,6.5) U44(20.5,6.5) U45(21.5,6.5) U46(22.5,6.5) V1(-22.5,5.5) V2(-21.5,5.5) V3(-20.5,5.5) V4(-19.5,5.5) V5(-18.5,5.5) V6(-17.5,5.5) V7(-16.5,5.5) V8(-15.5,5.5) V9(-14.5,5.5) V10(-13.5,5.5) V11(-12.5,5.5) V12(-11.5,5.5) V13(-10.5,5.5) V14(-9.5,5.5) V15(-8.5,5.5) V16(-7.5,5.5) V17(-6.5,5.5) V18(-5.5,5.5) V19(-4.5,5.5) V20(-3.5,5.5) V21(-2.5,5.5) V22(-1.5,5.5) V23(-0.5,5.5) V24(0.5,5.5) V25(1.5,5.5) V26(2.5,5.5) V27(3.5,5.5) V28(4.5,5.5) V29(5.5,5.5) V30(6.5,5.5) V31(7.5,5.5) V32(8.5,5.5) V33(9.5,5.5) V34(10.5,5.5) V35(11.5,5.5) V36(12.5,5.5) V37(13.5,5.5) V38(14.5,5.5) V39(15.5,5.5) V40(16.5,5.5) V41(17.5,5.5) V42(18.5,5.5) V43(19.5,5.5) V44(20.5,5.5) V45(21.5,5.5) V46(22.5,5.5) W1(-22.5,4.5) W2(-21.5,4.5) W3(-20.5,4.5) W4(-19.5,4.5) W5(-18.5,4.5) W6(-17.5,4.5) W7(-16.5,4.5) W8(-15.5,4.5) W9(-14.5,4.5) W10(-13.5,4.5) W11(-12.5,4.5) W12(-11.5,4.5) W13(-10.5,4.5) W14(-9.5,4.5) W15(-8.5,4.5) W16(-7.5,4.5) W17(-6.5,4.5) W18(-5.5,4.5) W19(-4.5,4.5) W20(-3.5,4.5) W21(-2.5,4.5) W22(-1.5,4.5) W23(-0.5,4.5) W24(0.5,4.5) W25(1.5,4.5) W26(2.5,4.5) W27(3.5,4.5) W28(4.5,4.5) W29(5.5,4.5) W30(6.5,4.5) W31(7.5,4.5) W32(8.5,4.5) W33(9.5,4.5) W34(10.5,4.5) W35(11.5,4.5) W36(12.5,4.5) W37(13.5,4.5) W38(14.5,4.5) W39(15.5,4.5) W40(16.5,4.5) W41(17.5,4.5) W42(18.5,4.5) W43(19.5,4.5) W44(20.5,4.5) W45(21.5,4.5) W46(22.5,4.5) Y1(-22.5,3.5) Y2(-21.5,3.5) Y3(-20.5,3.5) Y4(-19.5,3.5) Y5(-18.5,3.5) Y6(-17.5,3.5) Y7(-16.5,3.5) Y8(-15.5,3.5) Y9(-14.5,3.5) Y10(-13.5,3.5) Y11(-12.5,3.5) Y12(-11.5,3.5) Y13(-10.5,3.5) Y14(-9.5,3.5) Y15(-8.5,3.5) Y16(-7.5,3.5) Y17(-6.5,3.5) Y18(-5.5,3.5) Y19(-4.5,3.5) Y20(-3.5,3.5) Y21(-2.5,3.5) Y22(-1.5,3.5) Y23(-0.5,3.5) Y24(0.5,3.5) Y25(1.5,3.5) Y26(2.5,3.5) Y27(3.5,3.5) Y28(4.5,3.5) Y29(5.5,3.5) Y30(6.5,3.5) Y31(7.5,3.5) Y32(8.5,3.5) Y33(9.5,3.5) Y34(10.5,3.5) Y35(11.5,3.5) Y36(12.5,3.5) Y37(13.5,3.5) Y38(14.5,3.5) Y39(15.5,3.5) Y40(16.5,3.5) Y41(17.5,3.5) Y42(18.5,3.5) Y43(19.5,3.5) Y44(20.5,3.5) Y45(21.5,3.5) Y46(22.5,3.5)
SOD_123
  rect 1.194x0.711 smd: 1(-1.85,0) 2(1.85,0)
SOIC_8
  rect 2.032x0.635 smd: 1(-2.464,1.905) 2(-2.464,0.635) 3(-2.464,-0.635) 4(-2.464,-1.905) 5(2.464,-1.905) 6(2.464,-0.635) 7(2.464,0.635) 8(2.464,1.905)
SON10_TPS51200
  rect 0.864x0.279 smd: 1(-1.475,1) 2(-1.475,0.5) 3(-1.475,0) 4(-1.475,-0.5) 5(-1.475,-1) 6(1.475,-1) 7(1.475,-0.5) 8(1.475,0) 9(1.475,0.5) 10(1.475,1)
  custom 0.41x0.41 smd: 11(0,0)
SOT23_3
  rect 1.372x0.66 smd: 1(-1.05,0.95) 2(-1.05,-0.95) 3(1.05,0)
SOT23_6
  rect 0.584x1.321 smd: 1(-0.95,-1.219) 2(0,-1.219) 3(0.95,-1.219) 4(0.95,1.219) 5(0,1.219) 6(-0.95,1.219)
SOT523
  rect 0.406x0.508 smd: 1(-0.5,-0.65) 2(0,0.65) 3(0.5,-0.65)
SOT_23
  rect 1.016x1.397 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
SOT_723
  rect 0.381x0.508 smd: 1(-0.4,-0.4) 2(0.4,-0.4)
  rect 0.483x0.508 smd: 3(0,0.4)
SW_102_1261_EV
  round 2.54 hole 1.854: 1(4.699,0) 2(0,0) 3(-4.699,0) SH1(6.604,-9.525) SH2(-6.604,-9.525)
SW_CTS_8P_SMT_HALF_PITCH
  rect 0.762x1.27 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81) 5(1.905,3.81) 6(0.635,3.81) 7(-0.635,3.81) 8(-1.905,3.81)
SW_TL3301_G_4P
  rect 2.108x1.397 smd: 1(-4.547,2.261) 2(4.547,2.261) 3(-4.547,-2.261) 4(4.547,-2.261)
TANT_D
  rect 2.946x2.464 smd: 1(-3.175,0) 2(3.175,0)
TANT_X
  rect 2.946x2.464 smd: 1(-3.574,0) 2(3.574,0)
TDFN_10_3X3_EP
  rect 0.711x0.305 smd: 1(-1.475,1) 2(-1.475,0.5) 3(-1.475,0) 4(-1.475,-0.5) 5(-1.475,-1) 6(1.475,-1) 7(1.475,-0.5) 8(1.475,0) 9(1.475,0.5) 10(1.475,1)
  rect 1.575x2.362 smd: 11(0,0)
TP_KEY_MINI
  round 1.524 hole 1.016: 1(0,0)
TQFN_16
  rect 0.94x0.356 smd: 1(-1.839,0.975) 2(-1.839,0.325) 3(-1.839,-0.325) 4(-1.839,-0.975) 9(1.839,-0.975) 10(1.839,-0.325) 11(1.839,0.325) 12(1.839,0.975)
  rect 0.356x0.94 smd: 5(-0.975,-1.844) 6(-0.325,-1.844) 7(0.325,-1.844) 8(0.975,-1.844) 13(0.975,1.844) 14(0.325,1.844) 15(-0.325,1.844) 16(-0.975,1.844)
  rect 2.235x2.235 smd: 17(0,0)
TQFN_28_EP
  rect 0.762x0.203 smd: 1(-2,1.2) 2(-2,0.8) 3(-2,0.4) 4(-2,0) 5(-2,-0.4) 6(-2,-0.8) 7(-2,-1.2) 15(2,-1.2) 16(2,-0.8) 17(2,-0.4) 18(2,0) 19(2,0.4) 20(2,0.8) 21(2,1.2)
  rect 0.203x0.762 smd: 8(-1.2,-2) 9(-0.8,-2) 10(-0.4,-2) 11(0,-2) 12(0.4,-2) 13(0.8,-2) 14(1.2,-2) 22(1.2,2) 23(0.8,2) 24(0.4,2) 25(0,2) 26(-0.4,2) 27(-0.8,2) 28(-1.2,2)
  rect 2.743x2.743 smd: 29(0,0)
TQFN_32_EP
  rect 0.813x0.305 smd: 1(-2.415,1.75) 2(-2.415,1.25) 3(-2.415,0.75) 4(-2.415,0.25) 5(-2.415,-0.25) 6(-2.415,-0.75) 7(-2.415,-1.25) 8(-2.415,-1.75) 17(2.415,-1.75) 18(2.415,-1.25) 19(2.415,-0.75) 20(2.415,-0.25) 21(2.415,0.25) 22(2.415,0.75) 23(2.415,1.25) 24(2.415,1.75)
  rect 0.305x0.813 smd: 9(-1.75,-2.415) 10(-1.25,-2.415) 11(-0.75,-2.415) 12(-0.25,-2.415) 13(0.25,-2.415) 14(0.75,-2.415) 15(1.25,-2.415) 16(1.75,-2.415) 25(1.75,2.415) 26(1.25,2.415) 27(0.75,2.415) 28(0.25,2.415) 29(-0.25,2.415) 30(-0.75,2.415) 31(-1.25,2.415) 32(-1.75,2.415)
  rect 3.15x3.15 smd: 33(0,0)
TSSOP8_65P440X300MM
  rect 1.549x0.381 smd: 1(-2.875,0.975) 2(-2.875,0.325) 3(-2.875,-0.325) 4(-2.875,-0.975) 5(2.875,-0.975) 6(2.875,-0.325) 7(2.875,0.325) 8(2.875,0.975)
TSSOP_16_EP
  rect 1.397x0.381 smd: 1(-2.85,2.276) 2(-2.85,1.626) 3(-2.85,0.975) 4(-2.85,0.325) 5(-2.85,-0.325) 6(-2.85,-0.975) 7(-2.85,-1.626) 8(-2.85,-2.276) 9(2.85,-2.276) 10(2.85,-1.626) 11(2.85,-0.975) 12(2.85,-0.325) 13(2.85,0.325) 14(2.85,0.975) 15(2.85,1.626) 16(2.85,2.276)
  rect 3.048x3.048 smd: 17(0,0)
TSSOP_20
  rect 1.524x0.406 smd: 1(-2.921,2.925) 2(-2.921,2.275) 3(-2.921,1.625) 4(-2.921,0.975) 5(-2.921,0.325) 6(-2.921,-0.325) 7(-2.921,-0.975) 8(-2.921,-1.625) 9(-2.921,-2.275) 10(-2.921,-2.925) 11(2.921,-2.925) 12(2.921,-2.275) 13(2.921,-1.625) 14(2.921,-0.975) 15(2.921,-0.325) 16(2.921,0.325) 17(2.921,0.975) 18(2.921,1.625) 19(2.921,2.275) 20(2.921,2.925)
TSSOP_24
  rect 1.524x0.406 smd: 1(-2.92,3.575) 2(-2.92,2.925) 3(-2.92,2.275) 4(-2.92,1.625) 5(-2.92,0.975) 6(-2.92,0.325) 7(-2.92,-0.325) 8(-2.92,-0.975) 9(-2.92,-1.625) 10(-2.92,-2.275) 11(-2.92,-2.925) 12(-2.92,-3.575) 13(2.92,-3.575) 14(2.92,-2.925) 15(2.92,-2.275) 16(2.92,-1.625) 17(2.92,-0.975) 18(2.92,-0.325) 19(2.92,0.325) 20(2.92,0.975) 21(2.92,1.625) 22(2.92,2.275) 23(2.92,2.925) 24(2.92,3.575)
unnamed#2
  round 1.016 smd: (0,0)
VQFN_48
  rect 0.864x0.279 smd: 1(-3.475,2.751) 2(-3.475,2.25) 3(-3.475,1.75) 4(-3.475,1.25) 5(-3.475,0.749) 6(-3.475,0.249) 7(-3.475,-0.249) 8(-3.475,-0.749) 9(-3.475,-1.25) 10(-3.475,-1.75) 11(-3.475,-2.25) 12(-3.475,-2.751) 25(3.475,-2.751) 26(3.475,-2.25) 27(3.475,-1.75) 28(3.475,-1.25) 29(3.475,-0.749) 30(3.475,-0.249) 31(3.475,0.249) 32(3.475,0.749) 33(3.475,1.25) 34(3.475,1.75) 35(3.475,2.25) 36(3.475,2.751)
  rect 0.279x0.864 smd: 13(-2.751,-3.475) 14(-2.25,-3.475) 15(-1.75,-3.475) 16(-1.25,-3.475) 17(-0.749,-3.475) 18(-0.249,-3.475) 19(0.249,-3.475) 20(0.749,-3.475) 21(1.25,-3.475) 22(1.75,-3.475) 23(2.25,-3.475) 24(2.751,-3.475) 37(2.751,3.475) 38(2.25,3.475) 39(1.75,3.475) 40(1.25,3.475) 41(0.749,3.475) 42(0.249,3.475) 43(-0.249,3.475) 44(-0.749,3.475) 45(-1.25,3.475) 46(-1.75,3.475) 47(-2.25,3.475) 48(-2.751,3.475)
  rect 4.089x4.089 smd: 49(0,0)
WLP_9
  round 0.229 smd: A1(-0.5,0.5) A2(0,0.5) A3(0.5,0.5) B1(-0.5,0) B2(0,0) B3(0.5,0) C1(-0.5,-0.5) C2(0,-0.5) C3(0.5,-0.5)
XTAL_ABM8
  rect 1.321x1.041 smd: 1(-1.156,-0.94) 2(1.156,-0.94) 3(1.156,0.94) 4(-1.156,0.94)
XTAL_CS_023_125X98
  rect 1.397x1.194 smd: 1(-1.092,-0.851) 2(1.092,-0.851) 3(1.092,0.851) 4(-1.092,0.851)
XTAL_EPSON_FA238
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)

## Nets
AGND1: C229.2(CAP1) C1683.2(CAP1) C1684.2(CAP1) C1685.2(CAP1) C1712.2(CAP1) R1201.2 R1205.2 R1206.2 R1219.2 R1238.2 R1254.2 R1265.2 U164.7(GND) U164.37(EPAD) Z119.1(NET1)
AGND2: C1408.2(CAP1) C1446.2(CAP1) C1539.2(CAP1) C1543.2(CAP1) Q48.3(EMITTER) R1125.2 R1131.2 R1132.2 R1166.2 U9.5(DGND) U9.8(CIO) U9.28(LCFFP) U9.29(LCFFN) U9.33(EPAD) Z93.1(NET1)
AGND5: C370.2(CAP1) C423.2(CAP1) C480.2(CAP1) C740.2(CAP1) Q25.3(EMITTER) R155.2 R199.2 R214.2 R515.2 U30.5(DGND) U30.8(CIO) U30.28(LCFFP) U30.29(LCFFN) U30.33(EPAD) Z15.1(NET1)
AGND6: C145.2(CAP1) C175.2(CAP1) C188.2(CAP1) C189.2(CAP1) Q20.3(EMITTER) R74.2 R136.2 R137.2 R159.2 U6.5(DGND) U6.8(CIO) U6.28(LCFFP) U6.29(LCFFN) U6.33(EPAD) Z1.1(NET1)
AGND8: C1409.2(CAP1) C1447.2(CAP1) C1540.2(CAP1) C1544.2(CAP1) Q49.3(EMITTER) R1108.2 R1126.2 R1133.2 R1167.2 U4.5(DGND) U4.8(CIO) U4.28(LCFFP) U4.29(LCFFN) U4.33(EPAD) Z94.1(NET1)
AGND9: C1717.2(CAP1) R1207.2 R1214.2 R1221.2 R1240.2 R1258.2 R1262.2 R1266.2 U166.7(GND) U166.15(PWM4) U166.16(PWM3) U166.18(PWM1) U166.37(EPAD) Z121.1(NET1)
AGND10: C1715.2(CAP1) R1213.2 R1220.2 R1229.2 R1239.2 R1256.2 R1280.2 R1281.2 U165.7(GND) U165.15(PWM4) U165.16(PWM3) U165.18(PWM1) U165.37(EPAD) Z120.1(NET1)
AGND12: C1313.2(CAP1) C1318.2(CAP1) C1330.2(CAP1) C1336.2(CAP1) Q40.3(EMITTER) R1028.2 R1077.2 R1078.2 R1174.2 U150.5(DGND) U150.8(CIO) U150.28(LCFFP) U150.29(LCFFN) U150.33(EPAD) Z88.1(NET1)
AGND13: C1411.2(CAP1) C1449.2(CAP1) C1542.2(CAP1) C1546.2(CAP1) Q51.3(EMITTER) R1109.2 R1130.2 R1169.2 R1170.2 U156.5(DGND) U156.8(CIO) U156.28(LCFFP) U156.29(LCFFN) U156.33(EPAD) Z96.1(NET1)
