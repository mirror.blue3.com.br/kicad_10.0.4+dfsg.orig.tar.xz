# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFP_SI570_CLOCK_C_P: length 30.2
  TOP w0.104: C94.1 126.78,32.81 126.78,34.3 v1(127.05,34.57) ; v2(113.24,50.84) U1.W9
  18_SIG6 w0.076: v2(113.24,50.84) 113.24,50.53 113.31,50.45 114.56,50.45 114.85,50.15 114.85,47.09 114.82,47.05 114.82,44.42 114.85,44.39 114.85,41.84 114.9,41.8 114.9,41.78
  18_SIG6 w0.089: v1(127.05,34.57) 126.79,34.83 126.79,34.96 126.16,35.59 126.16,36.23 125.87,36.53 120.97,36.53 119.04,38.46 116.91,38.46 114.9,40.47 114.9,41.78
QSFP_SI570_CLOCK_N: length 40.3
  TOP w0.104: U38.5 95.04,22.75 94.79,22.5 94.79,21.13 95.24,20.68 118.5,20.68 126.02,28.2 C95.2
QSFP_SI570_CLOCK_P: length 41.7
  TOP w0.104: C94.2 126.73,30.74 126.37,30.74 126.25,30.62 126.25,28.11 118.59,20.45 95.15,20.45 94.56,21.04 94.56,22.58 94.39,22.75 U38.4
QSPI0_CS_B: length 72.9
  TOP w0.152: U1.AJ11 v2(124.24,52.84) ; v1(148.94,18.57) 148.44,19.08 147.4,19.08 146.89,18.57 U133.7 R1015.2
  18_SIG6 w0.089: v2(124.24,52.84) 124.71,53.31 126.47,53.31 126.74,53.04 126.74,49.64 127.03,49.34 127.44,49.34 127.74,49.05 127.74,47.65 127.74,47.64 128.03,47.34 128.04,47.34 128.56,47.34 128.74,47.17 128.74,46.63 129.03,46.34 129.46,46.34 129.74,46.07 129.74,45.55 129.95,45.34 131.29,45.34 131.29,45.34 131.44,45.34 131.74,45.05 131.74,44.64 132.03,44.34 132.44,44.34 132.74,44.05 132.74,33.99 134.59,32.13 134.59,29.29 134.92,28.96 135.66,28.96 135.79,28.83 135.79,25.81 136.22,25.37 137.66,25.37 137.75,25.29 137.75,24.3 137.84,24.21 138.2,24.21 138.29,24.3 138.29,25.29 138.38,25.37 138.73,25.37 138.82,25.29 138.82,24.3 138.91,24.21 139.26,24.21 139.35,24.3 139.35,25.29 139.44,25.37 142.14,25.37 142.52,24.99 142.52,23.72 142.75,23.49 144.86,23.49 145.39,24.03 145.39,26.64 145.87,27.13 147.85,27.13 148.32,26.66 148.32,25.36 148.64,25.04 148.64,22.66 148.94,22.35 v1(148.94,18.57)
QSPI0_DQ0: length 65.1
  TOP w0.152: U1.AP11 v2(129.24,52.84) ; U133.15 v1(153.06,24.92)
  18_SIG6 w0.089: v2(129.24,52.84) 129.74,52.34 129.74,49.64 130.03,49.34 131.44,49.34 131.74,49.05 131.74,48.61 132.01,48.34 132.45,48.34 132.74,48.05 132.74,47.63 133.02,47.34 133.45,47.34 133.74,47.06 133.74,45.64 134.03,45.34 134.48,45.34 134.74,45.08 134.74,44.63 135.02,44.34 135.48,44.34 135.74,44.08 135.74,43.64 136.03,43.34 136.35,43.34 136.44,43.34 136.74,43.05 136.74,38.24 137.16,37.82 144.04,37.82 145.25,36.62 145.25,34.12 151.8,27.57 151.8,21.86 152.17,21.49 152.3,21.49 153,22.19 153.12,22.19 153.38,21.93 153.38,21.81 152.68,21.11 152.68,20.98 152.93,20.73 153.05,20.73 153.75,21.43 153.88,21.43 154.13,21.18 154.13,21.05 153.43,20.35 153.43,20.23 153.8,19.86 154.99,19.86 155.8,20.68 155.8,24.16 155.04,24.92 v1(153.06,24.92)
QSPI0_DQ1: length 65.9
  TOP w0.152: U133.8 v1(147.67,17.3) ; U1.AN11 v2(128.24,52.84)
  18_SIG6 w0.089: v2(128.24,52.84) 128.74,52.34 128.74,49.64 129.03,49.34 129.34,49.34 129.34,49.34 129.44,49.34 129.74,49.05 129.74,48.74 129.74,48.64 130.03,48.34 130.27,48.34 130.27,48.34 130.44,48.34 130.74,48.05 130.74,47.64 131.03,47.34 131.2,47.34 131.2,47.34 132.5,47.34 132.74,47.11 132.74,45.64 133.03,45.34 133.44,45.34 133.74,45.05 133.74,44.63 134.02,44.34 134.45,44.34 134.74,44.06 134.74,35.24 138.25,31.72 139.12,31.72 139.21,31.81 139.21,32.75 139.3,32.84 139.65,32.84 139.74,32.75 139.74,31.81 139.83,31.72 140.19,31.72 140.27,31.81 140.27,32.75 140.36,32.84 140.72,32.84 140.81,32.75 140.81,31.81 140.9,31.72 145.77,31.72 150.98,26.52 150.98,21.54 153.67,18.85 153.67,16.89 153.37,16.59 148.39,16.59 v1(147.67,17.3)
QSPI0_DQ2: length 68.7
  TOP w0.152: R1018.2 U133.9 v1(153.06,17.3) ; v2(127.24,52.84) U1.AM11
  18_SIG6 w0.089: v2(127.24,52.84) 127.74,52.34 127.74,49.64 128.03,49.34 128.37,49.34 128.44,49.34 128.74,49.05 128.74,48.97 128.74,47.61 129,47.34 130.44,47.34 130.74,47.05 130.74,46.83 130.74,46.64 131.03,46.34 131.22,46.34 131.44,46.34 131.74,46.05 131.74,45.74 131.74,45.64 132.03,45.34 132.13,45.34 132.44,45.34 132.74,45.05 132.74,44.74 132.74,44.64 133.03,44.34 133.13,44.34 133.13,44.34 133.45,44.34 133.74,44.06 133.74,33.88 136.5,31.11 136.5,29.65 136.59,29.57 137.02,29.57 137.11,29.48 137.11,29.12 137.02,29.03 136.59,29.03 136.5,28.94 136.5,28.59 136.59,28.5 137.02,28.5 137.11,28.41 137.11,28.05 137.02,27.97 136.59,27.97 136.5,27.88 136.5,26.54 137.06,25.98 140.89,25.98 140.97,26.07 140.97,27.98 141.06,28.07 141.42,28.07 141.51,27.98 141.51,26.07 141.6,25.98 143.84,25.98 145.59,27.74 148.36,27.74 149.66,26.44 149.66,19.76 151.54,17.88 152.48,17.88 v1(153.06,17.3)
QSPI0_DQ3: length 70
  TOP w0.152: v1(147.67,26.19) U133.1 145.66,26.21 R1016.2 ; v2(126.24,52.84) 126.24,52.84 U1.AL11
  18_SIG6 w0.089: v1(147.67,26.19) 147.67,24.23 146.33,22.89 143.74,22.89 142.44,21.59 139.53,21.59 139.44,21.68 139.44,22.64 139.35,22.73 138.99,22.73 138.9,22.64 138.9,21.68 138.81,21.59 138.46,21.59 138.37,21.68 138.37,22.64 138.28,22.73 137.93,22.73 137.84,22.64 137.84,21.68 137.75,21.59 136.02,21.59 134.01,23.6 134.01,24.32 134.1,24.41 135.04,24.41 135.13,24.5 135.13,24.85 135.04,24.94 134.1,24.94 134.01,25.03 134.01,25.39 134.1,25.47 135.04,25.47 135.13,25.56 135.13,25.92 135.04,26.01 134.1,26.01 134.01,26.1 134.01,26.45 134.1,26.54 135.04,26.54 135.13,26.63 135.13,26.99 135.04,27.07 134.1,27.07 134.01,27.16 134.01,27.52 134.1,27.61 135.04,27.61 135.13,27.7 135.13,28.05 135.04,28.14 134.1,28.14 134.01,28.23 134.01,31.34 131.74,33.62 131.74,44.05 131.44,44.34 130,44.34 129.74,44.6 129.74,45.06 129.46,45.34 127.95,45.34 127.74,45.56 127.74,47.06 127.46,47.34 126.99,47.34 126.74,47.6 126.74,49.09 126.49,49.34 125.97,49.34 125.74,49.57 125.74,52.34 v2(126.24,52.84)
QSPI1_CS_B: length 51.4
  TOP w0.152: U1.BF16 v2(141.24,57.84)
  20_SIG7 w0.089: v1(151.79,18.57) 151.79,27.99 142.19,37.59 142.19,57.33 141.67,57.84 v2(141.24,57.84)
  BOTTOM w0.152: v1(151.79,18.57) 152.25,19.02 153.42,19.02 153.87,18.57 U43.7 156.75,18.57 157.23,18.09 R1293.2
QSPI1_DQ0: length 65.8
  TOP w0.152: v2(127.24,60.84) U1.AM19
  16_SIG5 w0.089: v2(127.24,60.84) 127.69,60.39 127.69,58.6 127.43,58.34 126.97,58.34 126.75,58.12 126.75,41.07 129.84,37.97 129.84,34.92 130.52,34.25 130.65,34.25 131.01,34.6 131.13,34.6 131.38,34.35 131.38,34.23 131.03,33.87 131.03,33.74 131.28,33.49 131.4,33.49 131.76,33.85 131.89,33.85 132.14,33.6 132.14,33.47 131.78,33.11 131.78,32.99 132.03,32.74 132.16,32.74 132.52,33.09 132.64,33.09 132.89,32.84 132.89,32.72 132.54,32.36 132.54,32.23 132.79,31.98 132.91,31.98 133.27,32.34 133.4,32.34 133.65,32.09 133.65,31.96 133.29,31.61 133.29,31.48 136.68,28.09 136.68,25.04 140,21.72 142.72,21.72 143.81,22.81 144.91,22.81 145.59,22.12 148.62,22.12 149.1,22.61 v1(149.1,23.65)
  BOTTOM w0.152: U43.15 147.83,24.92 v1(149.1,23.65)
QSPI1_DQ1: length 66
  TOP w0.152: U1.AM18 126.74,60.34 v2(127.24,59.84)
  16_SIG5 w0.089: v1(147.85,19.74) 147.14,20.45 140.51,20.45 140.42,20.54 140.42,20.82 140.33,20.9 139.98,20.9 139.89,20.82 139.89,20.54 139.8,20.45 139.42,20.45 138.23,21.64 136.5,21.64 136.09,22.05 136.09,27.71 127.81,35.99 127.81,39.07 125.76,41.12 125.76,59.18 125.93,59.36 126.75,59.36 v2(127.24,59.84)
  BOTTOM w0.152: U43.8 153.82,17.3 153.29,16.76 152.02,16.76 149.05,19.74 v1(147.85,19.74)
QSPI1_DQ2: length 68
  TOP w0.152: v2(128.24,61.84) U1.AN20
  16_SIG5 w0.089: v2(128.24,61.84) 128.75,61.33 128.75,58.7 128.4,58.34 127.91,58.34 127.74,58.17 127.74,41.33 131.2,37.86 131.2,35.98 136.26,30.92 136.26,30.44 140.82,25.88 145.77,25.88 146.57,26.68 149.21,26.68 149.63,26.26 149.63,25.81 150.14,25.3 150.14,18.49 v1(148.94,17.3)
  BOTTOM w0.152: v1(148.94,17.3) 148.51,16.87 147.27,16.87 146.84,17.3 U43.9 143.93,17.3 R1019.2
QSPI1_DQ3: length 67.5
  TOP w0.152: v2(129.24,61.84) U1.AP20
  16_SIG5 w0.089: v2(129.24,61.84) 129.74,61.34 129.74,58.65 129.41,58.32 128.97,58.32 128.74,58.09 128.74,41.52 132.68,37.58 132.68,37.46 131.99,36.77 131.99,36.64 132.24,36.39 132.37,36.39 133.05,37.08 133.18,37.08 133.43,36.83 133.43,36.7 132.74,36.01 132.74,35.89 132.99,35.64 133.12,35.64 133.81,36.32 133.93,36.32 134.18,36.07 134.18,35.95 133.5,35.26 133.5,35.13 133.75,34.88 133.87,34.88 134.56,35.57 134.69,35.57 134.94,35.32 134.94,35.19 134.25,34.51 134.25,34.38 134.5,34.13 134.63,34.13 135.32,34.82 135.44,34.82 136.88,33.38 136.88,30.56 137.52,29.92 141.4,29.92 143.92,27.41 149.66,27.41 150.19,26.87 v1(150.19,26.06)
  BOTTOM w0.152: R191.2 U43.1 151.87,26.19 151.74,26.06 v1(150.19,26.06)
QSPI_CLK: length 82.5
  TOP w0.152: v2(121.24,54.84) 120.74,55.34 U1.AF13 ; v1(149.07,25.96) 149.63,25.4 150.9,25.4 151.69,26.19 U133.16
  16_SIG5 w0.089: v1(149.07,25.96) 149.07,25.12 149.71,24.49 149.71,20.62 148.31,19.23 148.31,18.14 147.98,17.81 144.22,17.81 142.67,19.35 138.18,19.35 138.09,19.44 138.09,21.04 138,21.13 137.65,21.13 137.56,21.04 137.56,19.44 137.47,19.35 137.12,19.35 137.03,19.44 137.03,21.04 136.94,21.13 136.58,21.13 136.49,21.04 136.49,19.44 136.4,19.35 135.79,19.35 135.36,19.79 135.36,25.73 128.12,32.97 126.67,32.97 124.43,35.2 124.43,39.8 122.73,41.5 122.73,54.1 122.5,54.33 121.75,54.33 v2(121.24,54.84)
  BOTTOM w0.152: U43.16 146.76,26.19 147.29,25.65 148.77,25.65 v1(149.07,25.96)
QSPI_RESET_B: length 12.1
  TOP w0.152: R1328.2 U133.3 v1(148.13,23.65)
  BOTTOM w0.152: v1(148.13,23.65) 148.69,23.09 151.31,23.09 151.87,23.65 U43.3
REG_EN: length 424.6
  TOP w0.152: v1(169.99,139.79) 169.73,139.79 169.12,139.19 U166.9 ; R499.2 220.73,152.37 220.54,152.56 v1(218.67,152.56) 218.53,152.56 218.05,153.04 218.05,154.22 217.64,154.64 210.57,154.64 210.34,154.41 203,154.41 202.24,155.17 199.85,155.17 199.31,155.7 181.73,155.7 174.43,148.4 135.93,148.4 135.36,147.83 135.36,145.03 134.7,144.37 129.35,144.37 v1(127.94,142.96) 127.55,142.96 127.32,142.72 U25.1 ; v1(180.6,42.16) 180.6,42.61 180.04,43.17 U165.9
  03_SIG1 w0.173: v1(215,60.63) 215.23,60.86 215.23,62.27 214.81,62.69 213.82,62.69 213.53,62.4 212.68,62.4 211.52,61.24 211.52,60.78 211.52,58.98 212.89,57.62 212.89,53.26 213.62,52.54 213.62,52.14 213.35,51.87 213.25,51.87 v1(213.24,51.86) 211.13,49.75 207.86,49.75 206.69,50.93 201.24,50.93 199.97,49.66 193.52,49.66 190.8,52.37 190.8,53.47 189.03,55.25 187.3,55.25 186.03,53.97 186.03,52.94 183.14,50.05 183.14,48.19 182.38,47.43 181.76,47.43 180.6,46.27 v1(180.6,42.16)
  05_SIG2 w0.173: v1(215,60.63) 214.57,60.2 212.38,60.2 211.76,60.82 211.76,63.47 212.63,64.34 213.06,64.34 217.31,68.59 217.31,76.45 218.69,77.83 218.69,79.38 218.29,79.78 218.29,86.08 220.01,87.81 220.01,89.22 221.45,90.65 221.45,92.41 222,92.96 222,97.02 225.42,100.44 226.22,100.44 228.97,103.19 228.97,106.96 234.46,112.44 v1(238.54,112.44) 238.99,112.89 238.99,119.39 235.06,123.32 217.09,123.32 211.23,129.18 211.23,132.89 210.49,133.63 210.49,135.43 211.07,136.01 211.07,142.15 212.5,143.58 212.5,151.59 213.47,152.56 v1(218.67,152.56)
  BOTTOM w0.152: v1(218.67,152.56) 219.11,152.12 U15.4 ; 237.78,112.29 237.93,112.44 v1(238.54,112.44) ; v1(215,60.63) 214.77,60.4 212.59,60.4 212.03,60.96 U6.12 ; v1(127.94,142.96) 142.23,142.96 144.58,145.31 168.78,145.31 170.97,143.13 170.97,140.78 v1(169.99,139.79) 170.71,139.06 170.71,134.4 171.27,133.85 171.27,129.79 169,127.52 164.82,127.52 163.07,129.27 152.46,129.27 151.94,128.75 151.94,127.07 152.53,126.49 152.53,123.52 152.22,123.22 152.22,121.23 152.04,121.06 151.38,121.06 150.88,120.55 150.88,115.03 152.29,113.61 154.32,113.61 154.68,113.97 154.68,114.34 155.27,114.94 U9.12 ; U4.12 216.22,51.53 215.65,52.1 213.47,52.1 v1(213.24,51.86)
  BOTTOM w0.216: 237.78,112.29 237.59,112.11 U164.9
REG_SYNC: length 365.9
  03_SIG1 w0.381: v1(175.13,134.29) 177.05,132.38 v1(177.05,115.77) 176.06,114.78 173.93,114.78 169.57,110.42 163.61,110.42 162.76,109.57 v1(162.76,108.8)
  05_SIG2 w0.381: v1(49.33,157.72) 48.62,157.02 48.62,151.28 47.89,150.55 47.89,148.74 50.83,145.8 50.83,140.77 49.68,139.62 49.68,135.38 47.7,133.4 46.05,133.4 45.44,132.79 45.44,131.39 43.54,129.49 42.32,129.49 41.84,129.01 v1(41.84,127.89) ; v1(221.2,67.95) 222.21,66.94 222.21,64.35 220.59,62.73 217.85,62.73 217.12,62 217.12,58.05 211.65,52.58 211.65,45.96 v1(210.44,44.76)
  07_SIG3 w0.381: v1(175.13,134.29) 176.07,135.22 176.07,137.65 173.2,140.51 169.8,140.51 168.58,139.29 168.58,135.24 166.74,133.4 166.11,133.4 163.97,131.26 158.31,131.26 156.54,133.03 148.93,133.03 143.27,138.68 143.27,142.09 133.26,152.1 128.29,152.1 127.32,153.07 127.32,154.23 126.24,155.32 122.1,155.32 119.47,157.95 119.47,160.08 118.47,161.08 v1(118.47,170.87)
  18_SIG6 w0.381: v1(49.33,157.72) 48.37,158.68 48.37,166.87 51.43,169.93 54.1,169.93 57.02,172.85 116.49,172.85 v1(118.47,170.87)
  20_SIG7 w0.381: v1(177.05,115.77) 179.81,113.01 190.33,113.01 201.4,101.93 201.4,84.89 211.57,74.73 218.54,74.73 220.37,72.9 220.37,68.78 v1(221.2,67.95)
  BOTTOM w0.381: R1070.1 41.96,127.77 v1(41.84,127.89) ; R1144.1 v1(210.44,44.76) ; R141.1 221,67.74 v1(221.2,67.95) ; R1143.1 162.1,109.24 162.28,109.07 162.49,109.07 v1(162.76,108.8) ; v1(175.13,134.29) 175.81,134.29 R362.1
RJ45_LGRN_PWR: length 3.4
  TOP w0.152: J10.16 43.7,151.31 R82.2
RJ45_RGRN_PWR: length 6.9
  TOP w0.152: J10.14 31.78,149.1 29.29,149.1 28.06,150.33 R81.2
RLD3_C3_72B_0_VREF: length 27
  TOP w0.152: U141.A7 v2(93.23,123.32) ; v1(99.58,107.51) 98.52,107.51 96.21,109.82 93.73,109.82 v2(93.23,110.32) U141.N7
  07_SIG3 w0.173: v2(93.23,110.32) 93.23,110.32 94.3,111.39 94.3,114.25 94.71,114.67 94.71,117.15 94.36,117.5 94.36,122.93 93.96,123.32 v2(93.23,123.32)
  BOTTOM w0.152: R988.1 93.23,123.32 v2(93.23,123.32) ; v2(93.23,110.32) 93.73,109.82 C1233.1
  BOTTOM w0.381: R989.2 v1(99.58,107.51)
RLD3_C3_72B_0_ZQ: length 10.6
  TOP w0.14: v1(86.23,121.32) 85.95,121.6 R1145.1
  TOP w0.152: U141.F7 v2(93.23,118.32)
  BOTTOM w0.152: v2(93.23,118.32) 92.72,118.83 92.72,119.53 92.43,119.82 86.99,119.82 86.23,120.58 v1(86.23,121.32)
RLD3_C3_72B_1_VREF: length 26
  TOP w0.152: U142.A7 v2(82.32,117.17) ; U142.N7 v2(69.32,117.17)
  BOTTOM w0.152: C1236.1 82.67,115.65 82.82,115.5 82.82,114.85 82.63,114.66 82.09,114.66 81.85,114.42 81.85,113.9 81.63,113.67 79.08,113.67 78.82,113.93 78.82,115.83 78.47,116.18 77.14,116.18 76.65,116.67 70.05,116.67 69.55,117.17 v2(69.32,117.17) 69.32,117.17 69.32,116.23 67.71,114.62 R1142.2 ; C1236.1 83.18,116.13 83.31,116.26 R1141.1 ; C1236.1 82.67,116.82 v2(82.32,117.17)
RLD3_C3_72B_1_ZQ: length 11
  TOP w0.152: v2(80.01,125.26) 79.74,125.26 R1007.1 ; U142.F7 v2(77.32,117.17)
  BOTTOM w0.152: v2(77.32,117.17) 77.82,117.67 77.82,121.34 77.82,121.34 77.82,122.41 78.08,122.67 78.53,122.67 78.82,122.96 78.82,123.59 79.31,124.07 79.31,124.53 80.04,125.26 v2(80.01,125.26)
RLD3_C3_72B_A0: length 154.9
  TOP w0.152: U142.E2 v2(78.32,122.17) ; U1.A29 95.74,71.34 v2(95.24,71.84) ; U141.E2 v2(88.23,119.32)
  TOP w0.241: v1(85.23,119.3) 85.2,119.3 85.07,119.17 R964.2
  03_SIG1 w0.173: v2(78.32,122.17) 77.82,122.67 75.41,122.67 75.21,122.47 75.21,122.23 75.3,122.14 75.62,122.14 75.71,122.05 75.71,121.82 75.62,121.73 75.3,121.73 75.21,121.64 75.21,121.46 75.3,121.37 75.62,121.37 75.71,121.29 75.71,121.11 75.62,121.02 75.3,121.02 75.21,120.93 75.21,120.8 75.34,120.66 76.52,120.66 76.82,120.96 76.82,121.4 77.09,121.67 78.71,121.67 78.82,121.55 78.82,117.88 79.02,117.68 79.52,117.68 79.83,117.99 79.83,122.27 79.83,122.27 79.83,122.53 79.97,122.67 80.67,122.67 80.82,122.51 80.82,117.84 80.99,117.67 82.61,117.67 82.82,117.88 82.82,120.36 82.81,120.37 82.81,121.01 82.9,121.09 83.06,121.09 83.17,121.2 83.17,121.53 83.07,121.63 82.98,121.63 82.84,121.77 82.84,122.15 82.83,122.15 82.83,122.43 82.96,122.55 83.11,122.55 83.36,122.3 86.08,122.3 86.56,121.82 87.45,121.82 87.73,121.54 87.73,119.82 v2(88.23,119.32)
  05_SIG2 w0.173: 94.39,71.96 94.5,71.84 v2(95.24,71.84) ; 73.81,124.82 73.84,124.78 73.84,124.53 73.72,124.4 73.35,124.4 73.26,124.31 73.26,124.11 73.35,124.02 73.72,124.02 73.82,123.92 73.82,119.92 74.07,119.67 74.53,119.67 74.82,119.96 74.82,120.41 76.07,121.67 76.53,121.67 76.82,121.96 76.82,122.42 77.07,122.67 77.82,122.67 v2(78.32,122.17)
  05_SIG2 w0.262: v1(85.23,119.3) 86.27,119.3 86.74,118.82 87.73,118.82 v2(88.23,119.32)
  05_SIG2 w0.292: 73.81,124.82 73.81,125.54 73.7,125.65 72.75,125.65 72.59,125.5 72.59,124.49 72.44,124.33 72.12,124.33 71.96,124.49 71.96,125.5 71.81,125.65 71.49,125.65 71.33,125.5 71.33,124.49 71.18,124.33 70.86,124.33 70.7,124.49 70.7,125.5 70.55,125.65 70.23,125.65 70.07,125.5 70.07,124.49 69.92,124.33 69.6,124.33 69.44,124.49 69.44,125.5 69.29,125.65 68.89,125.65 68.7,125.46 68.7,123.39 67.13,121.83 64.9,121.83 64.39,121.32 64.39,114.75 64.91,114.23 64.91,113.51 64.39,113 64.39,108.12 66.55,105.97 69.04,105.97 69.88,106.81 72.26,106.81 73.95,105.12 74.71,105.12 75.17,104.66 78.5,104.66 78.64,104.52 82.02,104.52 82.5,104.04 82.5,102.83 82.89,102.44 83.6,102.44 85.34,100.69 85.34,100.15 85.7,99.8 87.55,99.8 87.6,99.85 89.41,99.85 89.81,99.44 89.81,98.68 91.63,96.86 91.63,93.31 91.2,92.87 91.2,75.15 94.39,71.96
RLD3_C3_72B_A1: length 165.9
  TOP w0.152: U141.F5 v2(91.23,118.32) ; U1.C29 97.74,71.34 v2(97.24,71.84) ; U142.F5 v2(77.32,119.17)
  TOP w0.241: R965.2 89.23,108.66 v2(89.23,109.32)
  03_SIG1 w0.173: v2(91.23,118.32) 90.73,118.82 90.73,120.55 90.46,120.82 88.99,120.82 88.73,121.09 88.73,121.56 88.47,121.82 87.96,121.82 87.74,122.04 87.74,122.55 87.33,122.96 85.12,122.96 84.94,123.14 84.69,123.14 84.52,122.97 84.52,122.82 84.43,122.73 84.25,122.73 84.16,122.82 84.16,123.45 83.93,123.68 75.05,123.68 74.86,123.48 74.86,119.89 74.63,119.67 74.06,119.67 73.82,119.42 73.82,117.9 74.05,117.67 74.73,117.67 74.84,117.77 74.84,119.3 74.92,119.38 75.15,119.38 75.24,119.29 75.24,119.2 75.33,119.11 75.73,119.11 75.82,119.02 75.82,118.84 75.73,118.76 75.33,118.76 75.24,118.67 75.24,118.49 75.33,118.4 75.73,118.4 75.82,118.31 75.82,118.13 75.73,118.04 75.33,118.04 75.24,117.95 75.24,117.77 75.34,117.67 77.66,117.67 77.82,117.83 77.82,119.95 77.82,120.51 77.66,120.67 77.05,120.67 76.82,120.44 76.82,118.82 76.95,118.69 77.23,118.69 77.32,118.79 v2(77.32,119.17)
  05_SIG2 w0.173: 97.73,109.73 97.73,110.69 97.59,110.82 96.9,110.82 96.73,110.99 96.73,111.67 96.88,111.82 97.52,111.82 97.73,112.03 97.73,112.69 97.59,112.82 95.96,112.82 95.73,112.59 95.73,108.99 95.43,108.69 94.59,108.69 94.23,109.04 94.23,115.95 93.62,116.56 93.21,116.56 92.73,117.04 92.73,120.53 92.44,120.82 92.02,120.82 91.73,120.53 91.73,120.02 91.53,119.82 90.92,119.82 90.73,120.02 90.73,120.57 90.48,120.82 90,120.82 89.73,120.55 89.73,119.98 89.57,119.82 88.91,119.82 88.73,120.01 88.73,120.57 88.47,120.82 88.01,120.82 87.73,120.54 87.73,119.99 87.55,119.82 85.54,119.82 85.47,119.89 85.01,119.89 84.4,119.28 84.15,119.28 83.54,118.67 77.49,118.67 77.32,118.84 v2(77.32,119.17) ; v2(97.24,71.84) 97.74,72.34 98.44,72.34 98.74,72.64 98.74,74.1 98.98,74.34 99.58,74.34 99.74,74.5 99.74,75.19 99.89,75.34 105.46,75.34 105.73,75.07 105.73,74.52 105.9,74.35 109.45,74.35 109.73,74.63 109.73,79.07 109.47,79.32 108.97,79.32 108.74,79.55 108.74,82.07 108.46,82.34 99.95,82.34 99.74,82.56 99.74,83.08 99.48,83.34 98.98,83.34 98.74,83.58 98.74,84.17 98.56,84.34 97.95,84.34 97.74,84.56 97.74,89.31
  05_SIG2 w0.262: v2(91.23,118.32) 90.73,117.82 90.73,111.12 90.43,110.82 90.02,110.82 89.73,110.53 89.73,109.82 v2(89.23,109.32)
  05_SIG2 w0.292: 97.73,109.73 97.74,109.72 97.74,107.57 100.36,104.95 100.36,103.43 98.92,101.99 98.92,98.54 100.33,97.13 100.33,92.73 97.74,90.13 97.74,89.31
RLD3_C3_72B_A2: length 160.6
  TOP w0.152: v2(98.24,71.84) 98.74,71.34 U1.D29 ; U142.F4 v2(77.32,120.17) ; U141.F4 v2(90.23,118.32)
  TOP w0.241: R966.2 86.07,117.17 v1(86.23,117.32)
  05_SIG2 w0.173: v2(77.32,120.17) 77.82,119.67 79.54,119.67 79.82,119.95 79.82,120.38 80.11,120.67 80.59,120.67 80.82,120.44 80.82,119.91 81.07,119.67 81.57,119.67 81.82,119.92 81.82,121.51 81.98,121.67 82.69,121.67 82.82,121.53 82.82,119.92 83.06,119.68 84.12,119.68 84.61,120.17 84.61,120.36 84.51,120.46 83.81,120.46 83.69,120.58 83.69,120.77 84.13,121.21 84.25,121.21 84.56,120.89 84.7,120.89 84.85,121.05 84.85,121.18 84.51,121.53 84.51,121.64 84.69,121.82 84.9,121.82 84.96,121.89 84.96,122.09 85.05,122.17 85.32,122.17 85.37,122.13 85.37,121.56 85.43,121.49 85.59,121.49 85.67,121.41 85.67,120.75 85.83,120.59 85.83,120.33 85.92,120.24 86.27,120.24 86.4,120.37 86.4,120.68 86.54,120.82 87.5,120.82 87.73,121.05 87.73,121.69 87.86,121.82 88.59,121.82 88.73,121.69 88.73,121.1 89.01,120.82 89.48,120.82 89.73,121.07 89.73,121.61 89.94,121.82 90.5,121.82 90.73,121.59 90.73,121.08 90.99,120.82 91.51,120.82 91.73,121.04 91.73,121.67 91.88,121.82 92.6,121.82 92.73,121.7 92.73,121.11 93.02,120.82 93.63,120.82 93.82,120.63 93.82,117.48 95.73,115.58 95.73,114.1 96.01,113.82 98.5,113.82 98.73,113.59 98.73,109.64 ; 98.74,89.41 98.74,84.57 98.97,84.34 99.45,84.34 99.72,84.07 99.72,83.72 100.1,83.34 108.48,83.34 108.74,83.08 108.74,82.53 108.92,82.34 109.46,82.34 109.74,82.06 109.74,79.57 109.98,79.32 110.49,79.32 110.72,79.1 110.72,73.58 110.48,73.34 105.89,73.34 105.72,73.52 105.72,74.06 105.44,74.34 100.06,74.34 99.74,74.02 99.74,72.66 99.42,72.34 99.03,72.34 98.53,71.84 v2(98.24,71.84)
  05_SIG2 w0.262: v1(86.23,117.32) 86.47,117.32 86.97,117.82 89.73,117.82 v2(90.23,118.32)
  05_SIG2 w0.292: 98.74,89.41 98.74,90.12 101.14,92.53 101.14,97.51 100.33,98.32 100.33,102.06 101.09,102.82 101.09,105.18 98.73,107.54 98.73,109.64
  07_SIG3 w0.173: v2(77.32,120.17) 76.82,120.67 76.82,121.38 77.11,121.67 79.6,121.67 79.81,121.87 79.81,122.35 80.13,122.67 80.55,122.67 80.82,122.94 80.82,123.61 80.71,123.72 80.47,123.72 80.34,123.85 80.34,124.29 80.47,124.41 80.71,124.41 80.82,124.52 80.82,124.82 ; v2(90.23,118.32) 90.73,118.82 90.73,121.51 90.38,121.87 89.9,121.87 89.73,121.69 89.73,117.98 89.94,117.76 90.52,117.76 90.67,117.61 90.67,117.08 90.41,116.81 87.03,116.81 86.74,117.11 86.74,117.53 85.88,118.39 85.88,118.84 85.97,118.93 86.19,118.93 86.28,119.03 86.28,119.27 86.22,119.33 85.98,119.33 85.91,119.41 85.91,119.72 86,119.81 86.22,119.81 86.31,119.9 86.31,120.15 86.2,120.26 85.96,120.26 85.88,120.35 85.88,120.77 85.64,121.01 84.8,121.01 84.72,121.09 84.72,121.57 84.85,121.7 84.97,121.7 85.18,121.49 85.39,121.49 85.58,121.68 85.58,121.81 85.38,122.01 85.38,122.23 85.63,122.48 85.63,122.6 85.5,122.73 85.32,122.73 84.78,122.19 84.63,122.19 84.51,122.31 84.51,124.47 84.45,124.53 84.45,124.6
  07_SIG3 w0.292: 84.45,124.6 84.45,124.94 84,125.39 81.05,125.39 80.82,125.17 80.82,124.82
RLD3_C3_72B_A3: length 164.2
  TOP w0.152: U1.B30 v2(96.24,72.84) ; U141.F9 v2(96.23,118.32) ; U142.F9 v2(77.32,114.17)
  TOP w0.279: R967.2 94.49,125.27 v1(94.74,125.02)
  03_SIG1 w0.173: v2(96.23,118.32) 96.23,118.63 95.73,119.13 95.73,119.55 95.99,119.82 96.43,119.82 96.73,120.12 96.73,124.18 96.47,124.43 95.91,124.43 95.82,124.35 95.82,124.09 95.74,124 95.56,124 95.38,124.18 94.97,124.18 94.72,123.93 94.72,123.04 94.94,122.82 95.62,122.82 95.73,122.71 95.73,121.97 95.58,121.82 94.95,121.82 94.59,121.46 94.59,119.23 95,118.82 95.48,118.82 95.73,118.58 95.73,118.08 95.46,117.81 94.77,117.81 94.48,117.52 94.48,117.1 94.05,116.67 94.05,114.12 93.76,113.82 89.98,113.82 89.73,113.57 89.73,113.06 89.49,112.82 88.04,112.82 87.73,113.13 87.73,113.53 87.44,113.82 86.91,113.82 86.54,114.19 86.05,114.19 85.43,114.82 84.87,114.82 84.66,114.6 84.66,114.35 84.53,114.22 84.23,114.22 84.07,114.38 84.07,114.68 83.94,114.82 83.73,114.82 83.58,114.67 77.82,114.67 v2(77.32,114.17)
  05_SIG2 w0.173: 95.3,88.65 94.74,88.08 94.74,84.46 94.85,84.34 95.49,84.34 95.74,84.1 95.74,83.69 96.08,83.34 96.54,83.34 96.74,83.15 96.74,82.63 96.97,82.4 97.49,82.4 97.74,82.15 97.74,81.57 97.96,81.34 98.6,81.34 98.74,81.21 98.74,80.54 98.93,80.34 99.42,80.34 99.72,80.04 99.72,79.5 99.87,79.34 106.41,79.34 106.73,79.02 106.73,77.5 106.55,77.32 106.02,77.32 105.77,77.57 105.77,78.14 105.57,78.34 99.98,78.34 99.75,78.1 99.75,77.7 99.42,77.37 99.03,77.37 98.76,77.09 98.76,76.68 98.45,76.38 98.04,76.38 97.76,76.1 97.76,75.67 97.46,75.36 96.91,75.36 96.74,75.18 96.74,74.68 96.4,74.34 95.98,74.34 95.74,74.1 95.74,73.55 96.24,73.05 v2(96.24,72.84) ; 77.82,108.81 77.82,111.43 78.06,111.67 78.57,111.67 78.82,111.92 78.82,112.37 79.11,112.67 81.72,112.67 81.82,112.77 81.82,116.55 81.74,116.64 81.53,116.64 81.44,116.55 81.44,115.81 81.35,115.71 81.15,115.71 81.06,115.8 81.06,116.55 80.97,116.64 80.77,116.64 80.68,116.55 80.68,115.81 80.59,115.71 80.39,115.71 80.3,115.8 80.3,116.55 80.21,116.64 80.01,116.64 79.92,116.55 79.92,115.81 79.82,115.71 79.63,115.71 79.54,115.8 79.54,116.55 79.45,116.64 78.99,116.64 78.82,116.46 78.82,112.91 78.58,112.67 77.97,112.67 77.82,112.52 77.82,111.96 77.53,111.67 77.05,111.67 76.82,111.9 76.82,113.67 v2(77.32,114.17)
  05_SIG2 w0.292: 77.82,108.81 77.82,108.8 78.08,108.55 85.77,108.55 85.99,108.33 85.99,108.1 85.77,107.88 85.77,107.66 86,107.44 86.22,107.44 86.44,107.66 86.66,107.66 86.88,107.43 86.88,107.21 86.68,107 86.68,106.78 87.22,106.24 87.44,106.24 87.65,106.45 87.87,106.45 88.45,105.87 89.05,105.87 89.21,105.71 89.21,104.93 89.36,104.77 89.68,104.77 89.84,104.93 89.84,105.71 89.99,105.87 96.53,105.87 97.31,105.09 97.31,103.96 95.68,102.34 95.2,102.34 95.02,102.16 95.02,100.82 95.9,99.95 95.9,98.03 96.46,97.48 96.46,92.13 95.43,91.1 95.43,88.77 95.3,88.65
  07_SIG3 w0.262: v1(94.74,125.02) 94.74,125.39 95.03,125.68 96.01,125.68 96.72,124.97 96.72,118.82 v2(96.23,118.32)
RLD3_C3_72B_A4: length 161.1
  TOP w0.152: U141.F10 v2(97.23,118.32) ; U142.F10 v2(77.32,113.17) ; U1.C30 v2(97.24,72.84)
  TOP w0.241: v2(101.23,115.32) 101.46,115.55 R968.2
  03_SIG1 w0.173: v2(77.32,113.17) 77.32,113.49 77.49,113.67 83.59,113.67 83.87,113.39 84.04,113.39 84.16,113.51 84.16,113.61 84.31,113.77 84.56,113.77 84.68,113.64 84.68,113.39 84.3,113 84.3,112.76 84.48,112.58 84.72,112.58 84.96,112.82 85.68,112.82 85.83,112.67 85.83,111.96 85.96,111.83 86.2,111.83 86.29,111.92 86.29,113.11 86.16,113.23 85.88,113.23 85.77,113.34 85.77,113.53 85.89,113.65 86.58,113.65 86.67,113.56 86.67,111.95 86.79,111.82 89.58,111.82 89.73,111.97 89.73,112.52 90.02,112.82 90.5,112.82 90.73,112.6 90.73,112.04 90.94,111.83 91.59,111.83 91.73,111.97 91.73,112.63 91.92,112.82 92.54,112.82 92.73,112.63 92.73,111.99 92.89,111.82 94.5,111.82 94.6,111.92 94.6,112.19 94.49,112.3 93.82,112.3 93.72,112.4 93.72,112.66 93.81,112.75 94.69,112.75 94.78,112.84 94.78,113.09 94.69,113.18 94.29,113.18 94.16,113.31 94.16,113.57 94.4,113.82 94.4,116.35 94.79,116.74 95.34,116.74 95.73,117.13 95.73,117.57 95.98,117.82 96.61,117.82 96.73,117.94 96.73,119.57 96.98,119.82 97.45,119.82 97.73,119.54 97.73,119.09 97.23,118.59 v2(97.23,118.32)
  05_SIG2 w0.173: 87.68,108.46 87.05,109.09 84.94,109.09 84.37,109.67 78.99,109.67 78.82,109.83 78.82,111.43 79.06,111.67 82.55,111.67 82.82,111.94 82.82,115.95 82.92,116.05 83.39,116.05 83.48,116.14 83.48,116.37 83.39,116.45 82.92,116.45 82.82,116.56 82.82,117.51 82.66,117.67 77.99,117.67 77.82,117.5 77.82,116.68 77.9,116.6 78.36,116.6 78.45,116.51 78.45,116.23 78.36,116.15 77.9,116.15 77.82,116.07 77.82,113.67 v2(77.32,113.17) ; 96.14,88.87 96.14,88.47 95.74,88.07 95.74,84.6 95.99,84.34 96.61,84.34 96.74,84.22 96.74,83.69 97.09,83.34 97.59,83.34 97.74,83.2 97.74,82.58 97.98,82.34 98.61,82.34 98.74,82.21 98.74,81.7 99.09,81.34 99.53,81.34 99.74,81.14 99.74,80.54 99.93,80.34 106.53,80.34 106.74,80.13 106.74,79.52 106.91,79.35 107.37,79.35 107.75,78.97 107.75,76.58 107.52,76.35 105.87,76.35 105.71,76.5 105.71,77.17 105.54,77.34 99.97,77.34 99.72,77.09 99.72,76.71 99.42,76.4 99.06,76.4 98.76,76.1 98.76,75.69 98.42,75.36 97.99,75.36 97.74,75.11 97.74,74.65 97.43,74.34 97.03,74.34 96.74,74.05 96.74,73.65 97.24,73.15 v2(97.24,72.84)
  05_SIG2 w0.292: 87.68,108.46 88.24,107.9 88.24,107.15 88.82,106.56 96.82,106.56 98.35,105.03 98.35,103.96 96.25,101.87 96.25,101.11 96.57,100.79 96.57,98.63 98.91,96.29 98.91,95.69 98.75,95.53 98.07,95.53 97.94,95.67 97.94,95.96 97.78,96.11 97.42,96.11 97.13,95.82 97.13,93.22 97.28,93.07 97.64,93.07 97.87,93.29 97.87,94.76 98.01,94.9 98.75,94.9 98.91,94.75 98.91,93.32 96.14,90.56 96.14,88.87
  BOTTOM w0.241: v2(101.23,115.32) 100.93,115.32 100.35,115.9 98.66,115.9 97.73,116.83 97.73,117.56 97.23,118.06 v2(97.23,118.32)
RLD3_C3_72B_A5: length 158.7
  TOP w0.152: U141.F12 v2(99.23,118.32) ; U142.F12 v2(77.32,111.17) ; U1.A31 v2(95.24,73.84)
  05_SIG2 w0.173: v2(95.24,73.84) 94.83,74.25 94.83,74.37 94.39,74.81 ; 73.23,108.81 73.06,108.98 72.35,108.98 72.23,109.11 72.23,109.56 72.33,109.67 74.59,109.67 75.01,110.08 75.01,110.28 74.92,110.37 74.84,110.37 74.75,110.46 74.75,110.64 74.84,110.73 74.99,110.73 75.08,110.81 75.08,111.45 74.86,111.67 72.51,111.67 72.05,111.67 71.82,111.9 71.82,112.41 72.07,112.67 72.55,112.67 72.82,112.94 72.82,113.43 73.06,113.67 73.56,113.67 73.82,113.93 73.82,114.41 73.57,114.67 72.08,114.67 71.82,114.41 71.82,113.89 71.6,113.66 71.11,113.66 70.82,113.38 70.82,109.86 70.56,109.6 70.07,109.6 69.82,109.84 69.82,114.42 70.06,114.67 70.57,114.67 70.82,114.92 70.82,115.8 71.01,115.98 71.87,115.98 72.27,116.38 72.47,116.38 72.82,116.74 72.82,117.5 72.99,117.67 74.61,117.67 74.88,117.94 75.23,117.94 75.4,117.76 75.4,116.99 75.31,116.91 74.82,116.91 74.73,116.82 74.73,116.59 74.82,116.5 75.58,116.5 75.67,116.41 75.67,116.18 75.55,116.07 73.92,116.07 73.84,116.16 73.84,116.59 73.74,116.69 73.48,116.69 73.4,116.61 73.4,116.16 73.32,116.07 72.7,116.07 72.59,115.96 72.59,115.78 72.69,115.69 75.22,115.69 75.29,115.62 75.29,115.45 75.2,115.36 74.92,115.36 74.83,115.27 74.83,115.09 74.92,115 75.21,115 75.3,114.91 75.3,114.77 75.18,114.65 74.92,114.65 74.83,114.56 74.83,114.38 74.92,114.29 75.18,114.29 75.29,114.18 75.29,114.01 75.23,113.95 74.93,113.95 74.83,113.85 74.83,113.67 74.92,113.58 75.33,113.58 75.42,113.49 75.42,113.29 75.33,113.2 75.03,113.2 74.95,113.12 74.95,112.24 75.67,111.53 75.67,110.92 75.92,110.67 76.82,110.67 v2(77.32,111.17) 77.05,111.17 76.55,111.67 76.09,111.67 75.81,111.94 75.81,115.46 76.3,115.95 76.3,116.45 75.79,116.96 75.79,120.37 76.09,120.67 76.53,120.67 76.82,120.96 76.82,121.4 77.09,121.67 78.54,121.67 78.82,121.95 78.82,122.41 79.08,122.67 79.54,122.67 79.82,122.95 79.82,123.4 80.78,124.35 81.17,124.35 81.31,124.21 81.31,124 81.4,123.91 81.63,123.91 81.75,124.03 81.75,124.29 81.83,124.38 84.89,124.38 85.02,124.51 85.9,124.51 86.54,123.88 88.57,123.88 88.65,123.96 88.65,124.47 88.74,124.56 89,124.56 89.09,124.47 89.09,123.96 89.18,123.88 89.45,123.88 89.54,123.96 89.54,124.4 89.63,124.48 89.84,124.48 89.92,124.4 89.92,123.96 90.01,123.88 93.88,123.88 94.93,122.82 95.45,122.82 95.73,122.54 95.73,121.96 95.87,121.82 96.47,121.82 96.73,121.56 96.73,120.9 96.81,120.82 97.46,120.82 97.73,120.56 97.73,119.9 97.81,119.82 98.44,119.82 98.73,119.53 98.73,118.82 v2(99.23,118.32)
  05_SIG2 w0.292: 73.23,108.81 74.3,107.75 75.34,107.75 75.74,107.35 75.74,107 76.06,106.68 78.6,106.68 79.13,107.21 83.31,107.21 87.9,102.62 89.28,102.62 89.46,102.44 91.85,102.44 92.35,101.93 92.35,101.22 93.71,99.87 93.71,98.11 95.11,96.71 95.11,93.23 93.22,91.34 93.22,75.99 94.39,74.81
  BOTTOM w0.241: R969.2 101.49,120.76 101.43,120.82 99.87,120.82 99.73,120.68 99.73,119.11 99.23,118.61 v2(99.23,118.32)
RLD3_C3_72B_A6: length 158.8
  TOP w0.152: U142.G3 v2(76.32,121.17) ; U1.A30 v2(95.24,72.84) ; U141.G3 v2(89.23,117.32)
  TOP w0.241: v2(85.23,112.32) 84.55,113 R970.2
  05_SIG2 w0.173: v2(95.24,72.84) 94.45,72.84 94.39,72.91 ; v2(76.32,121.17) 76.08,121.17 75.21,120.29 75.21,119.18 74.7,118.67 74.04,118.67 73.82,118.88 73.82,119.42 73.58,119.67 73.04,119.67 72.82,119.89 72.82,123.62 72.54,123.9 71.1,123.9 70.82,123.62 70.82,122.87 70.62,122.67 69,122.67 68.91,122.58
  05_SIG2 w0.262: v2(85.23,112.32) 86.73,113.82 87.43,113.82 87.73,114.12 87.73,114.53 88.02,114.82 88.43,114.82 88.73,115.12 88.73,116.82 v2(89.23,117.32)
  05_SIG2 w0.292: 94.39,72.91 91.87,75.43 91.87,92.35 92.3,92.79 92.3,97.59 91.03,98.86 91.03,99.57 90.08,100.52 88.09,100.52 87.45,101.17 86.03,101.17 85.68,101.52 85.68,102.02 84.76,102.94 84.25,102.94 83.85,103.35 83.85,104.27 82.92,105.19 78.92,105.19 78.78,105.33 75.45,105.33 74.99,105.79 74.27,105.79 72.53,107.53 69.56,107.53 68.67,106.64 66.83,106.64 65.13,108.34 65.13,111.96 66.51,113.35 66.51,114.71 66.24,114.98 65.23,114.98 65.07,115.13 65.07,115.45 65.23,115.61 66.59,115.61 66.75,115.76 66.75,116.08 66.59,116.24 65.23,116.24 65.07,116.39 65.07,116.71 65.23,116.87 66.62,116.87 66.77,117.02 66.77,117.34 66.62,117.5 65.23,117.5 65.07,117.65 65.07,117.97 65.23,118.13 67.56,118.13 67.69,118.25 67.69,118.6 67.53,118.76 65.23,118.76 65.07,118.91 65.07,119.3 65.23,119.46 67.51,119.46 67.67,119.62 67.67,119.93 67.51,120.09 65.23,120.09 65.07,120.25 65.07,120.65 65.33,120.9 67.23,120.9 68.91,122.58
  14_SIG4 w0.089: v2(89.23,117.32) 89.23,117.64 89.05,117.82 88.03,117.82 87.73,118.12 87.73,118.53 87.43,118.83 86.96,118.83 86.56,118.43 86.43,118.43 86.18,118.68 86.18,119.08 86.29,119.19 86.63,119.19 86.74,119.3 86.74,119.46 86.63,119.57 86.29,119.57 86.18,119.68 86.18,120.18 85.29,121.07 83.54,121.07 82.95,121.67 79.96,121.67 79.82,121.53 79.82,120.77 79.71,120.67 78.94,120.67 78.81,120.8 78.81,121.52 78.68,121.65 78.03,121.65 77.83,121.45 77.83,119.97 77.53,119.67 77.12,119.67 76.82,119.97 76.82,121.52 76.68,121.67 75.53,121.67 75.09,121.23 75.09,121.11 75.18,121.02 75.56,121.02 75.65,120.93 75.65,120.75 75.56,120.66 75.18,120.66 75.09,120.57 75.09,119.94 74.82,119.67 74.09,119.67 73.82,119.4 73.82,116.31 73.94,116.19 74.11,116.19 74.2,116.27 74.2,116.57 74.29,116.66 74.46,116.66 74.55,116.57 74.55,116.27 74.64,116.19 74.91,116.19 75.42,116.7 75.42,116.85 75.33,116.93 74.92,116.93 74.83,117.02 74.83,118.81 75.35,119.33 75.35,119.72 75.7,120.07 75.7,120.29 76.32,120.91 v2(76.32,121.17)
RLD3_C3_72B_A7: length 153.1
  TOP w0.152: U141.F1 v2(87.23,118.32) ; 95.74,75.34 v2(95.24,75.84) ; U142.F1 v2(77.32,123.17)
  TOP w0.241: R971.2 84.93,117.78 85.45,117.78 85.99,118.32 v2(87.23,118.32)
  07_SIG3 w0.173: v2(95.24,75.84) 95.05,75.84 95.05,75.84 94.39,76.5 ; 68.91,123.7 72.7,123.7 72.82,123.57 72.82,122.95 73.1,122.67 73.61,122.67 73.82,122.45 73.82,119.93 74.09,119.67 74.58,119.67 75.82,120.91 75.82,121.37 76.12,121.67 76.53,121.67 76.82,121.96 76.82,122.37 77.32,122.87 v2(77.32,123.17) 77.59,123.17 78.1,122.67 79.61,122.67 79.82,122.88 79.82,124.59 79.6,124.82 ; v2(87.23,118.32) 86.96,118.06 86.74,118.06 86.46,118.34 86.46,118.62 86.72,118.87 87.6,118.87 87.75,119.02 87.75,119.64 87.63,119.76 86.92,119.76 86.73,119.95 86.73,121.85 86.58,122 86.19,122 86.04,122.15 86.04,122.37 86.19,122.52 86.37,122.52 86.53,122.67 86.53,124.42 86.39,124.56 86.11,124.56 85.98,124.43 85.98,123.29 85.83,123.14 85.09,123.14 84.89,123.34 84.89,124.17 85.15,124.44 85.15,124.6
  07_SIG3 w0.292: 94.39,76.5 89.46,81.43 89.46,84.79 86.15,88.09 82.52,88.09 81.96,87.53 74.88,87.53 73.74,88.67 73.74,95.12 74.19,95.58 81.22,95.58 81.71,96.08 81.71,98.78 81.29,99.21 78.25,99.21 77.63,99.83 77.63,100.23 76.11,101.75 76.11,104.32 75.85,104.57 72.32,104.57 72.16,104.42 67.44,104.42 66.99,104.86 64.99,104.86 62.93,106.92 62.93,109.97 62.43,110.46 62.43,112.55 63.08,113.2 63.08,115.46 63.38,115.75 63.38,116.93 63.82,117.37 63.82,121.41 66.11,123.7 68.91,123.7 ; 79.6,124.82 79.13,125.28 77.56,125.28 77.32,125.53 77.32,127.05 77.57,127.3 77.89,127.3 78.05,127.15 78.05,126.24 78.21,126.09 78.52,126.09 78.68,126.24 78.68,127.15 78.84,127.3 79.15,127.3 79.31,127.15 79.31,126.24 79.47,126.09 79.78,126.09 79.94,126.24 79.94,127.15 80.1,127.3 80.41,127.3 80.57,127.15 80.57,126.24 80.72,126.09 81.05,126.09 81.2,126.24 81.2,127.06 81.35,127.21 81.67,127.21 81.83,127.05 81.83,126.24 81.98,126.09 82.31,126.09 82.49,126.27 82.49,127.03 82.65,127.19 82.89,127.19 83.06,127.02 83.06,126.43 83.29,126.21 83.44,126.21 84.03,126.8 84.37,126.8 84.6,126.57 84.6,125.81 85.15,125.25 85.15,124.6
RLD3_C3_72B_A8: length 154.4
  TOP w0.152: U141.G11 v2(98.23,117.32) ; U142.G11 v2(76.32,112.17) ; 96.74,75.34 v2(96.24,75.84)
  TOP w0.241: v2(101.23,117.32) 101.24,117.33 R972.2
  03_SIG1 w0.173: v2(98.23,117.32) 98.23,116.85 97.71,116.33 97.16,116.33 96.73,115.91 96.73,114.04 96.95,113.82 97.45,113.82 97.73,113.55 97.73,111.09 97.46,110.82 97.01,110.82 96.73,110.54 96.73,109.9 96.83,109.8 97.32,109.8 97.41,109.72 97.41,109.49 97.32,109.4 96.83,109.4 96.74,109.31 96.74,108.91 96.67,108.83 96.38,108.83 96.29,108.92 96.29,109.72 96.2,109.8 95.95,109.8 95.86,109.72 95.86,108.92 95.75,108.81 94.81,108.81 94.7,108.92 94.7,109.84 94.63,109.91 94.43,109.91 94.32,109.81 94.32,108.92 94.23,108.83 94.01,108.83 93.92,108.92 93.92,109.45 93.83,109.53 93.65,109.53 93.54,109.42 93.54,108.9 93.15,108.51 88.52,108.51 88.35,108.68 88.35,109.31 88.26,109.4 87.68,109.4 87.59,109.31 87.59,108.92 87.48,108.81 85.69,108.81 85.5,109.01 85.5,109.48 85.33,109.65 85.08,109.65 84.91,109.48 84.91,109.03 84.74,108.85 84.49,108.85 84.22,109.13 84.22,110.58 84.13,110.67 78.12,110.67 77.82,110.96 77.82,111.37 77.53,111.67 77.12,111.67 76.62,112.17 v2(76.32,112.17)
  05_SIG2 w0.262: v2(98.23,117.32) 98.74,116.81 100.72,116.81 v2(101.23,117.32)
  07_SIG3 w0.173: v2(96.24,75.84) 96.24,76.08 95.74,76.58 95.74,77.03 95.41,77.36 95.03,77.36 94.76,77.63 94.76,78.06 94.39,78.44 ; 68.91,110.63 68.94,110.67 74.63,110.67 75.03,111.07 75.03,111.23 75.48,111.68 75.83,111.68 v2(76.32,112.17)
  07_SIG3 w0.292: 68.91,110.63 68.67,110.4 66.08,110.4 65.76,110.72 65.76,111.58 65.56,111.78 64,111.78 63.79,111.57 63.79,111.12 64.5,110.41 64.5,110.05 64.8,109.75 65.86,109.75 66.01,109.59 66.01,109.28 65.86,109.12 64.47,109.12 64.31,108.96 64.31,108.65 64.47,108.49 65.86,108.49 66.01,108.33 66.01,108.02 65.86,107.86 65.12,107.86 64.83,107.57 64.83,107.16 65.38,106.6 67.77,106.6 68.48,105.89 69.75,105.89 70.66,106.81 71.75,106.81 72.62,105.94 76.5,105.94 77.01,105.44 78.13,105.44 78.99,104.57 78.99,104.55 79.04,104.5 79.04,103.1 78.74,102.79 77.93,102.79 77.72,102.59 77.72,102.11 78.81,101.02 81.38,101.02 83.11,99.29 83.11,95.55 81.71,94.16 81.71,91.16 81.41,90.86 74.98,90.86 74.78,90.65 74.78,89.59 74.98,89.39 75.55,89.39 75.71,89.55 75.71,90.14 75.87,90.3 76.18,90.3 76.34,90.14 76.34,89.47 76.5,89.31 76.81,89.31 76.97,89.47 76.97,90.14 77.13,90.3 77.44,90.3 77.6,90.14 77.6,89.47 77.76,89.31 78.07,89.31 78.23,89.47 78.23,90.14 78.39,90.3 78.7,90.3 78.86,90.14 78.86,89.47 79.02,89.31 79.33,89.31 79.49,89.47 79.49,90.14 79.65,90.3 79.96,90.3 80.12,90.14 80.12,89.55 80.28,89.39 80.59,89.39 80.75,89.55 80.75,90.14 80.91,90.3 81.22,90.3 81.38,90.14 81.38,89.55 81.54,89.39 81.69,89.39 82.73,90.42 86.06,90.42 90.96,85.52 90.96,81.86 94.39,78.44
RLD3_C3_72B_A9: length 155.3
  TOP w0.152: U1.B32 v2(96.24,74.84) ; U142.F13 v2(77.32,110.17) ; U141.F13 v2(100.23,118.32)
  03_SIG1 w0.173: 75.83,108.81 75.82,108.82 75.82,111.43 76.06,111.67 76.6,111.67 76.82,111.44 76.82,110.96 77.32,110.46 v2(77.32,110.17) ; 99.31,108.46 99.73,108.87 99.73,110.55 100,110.82 100.46,110.82 100.73,111.09 100.73,113.55 100.45,113.82 100.02,113.82 99.73,114.11 U141.F13 v2(100.23,118.32)
  03_SIG1 w0.292: 75.83,108.81 76.04,108.6 78.7,108.6 79.47,107.84 82.66,107.84 85.42,105.08 95.94,105.08 99.31,108.46
  05_SIG2 w0.173: 94.39,78.36 98.4,78.36 98.7,78.66 98.7,79.1 98.48,79.32 95.99,79.32 95.76,79.55 95.76,80.16 95.99,80.39 96.58,80.39 96.75,80.56 96.75,81.03 96.39,81.38 95.91,81.38 95.76,81.53 95.76,82.17 95.94,82.35 96.49,82.35 96.7,82.14 96.7,81.69 97.05,81.33 97.43,81.33 97.71,81.05 97.71,80.57 97.89,80.39 98.35,80.39 98.77,79.97 98.77,79.55 98.97,79.35 99.44,79.35 99.72,79.07 99.72,78.64 99.42,78.33 98.98,78.33 98.77,78.12 98.77,77.69 98.45,77.37 94.54,77.37 94.39,77.22 94.39,76.5 94.54,76.35 96.6,76.35 96.77,76.17 96.77,75.69 96.24,75.15 v2(96.24,74.84) ; v2(77.32,110.17) 77.46,110.03 77.46,109.8 77.33,109.67 75.9,109.67 75.82,109.75 75.82,110.16 75.69,110.29 75.5,110.29 75.36,110.16 75.36,109.77 75.28,109.68 75.11,109.68 74.83,109.4 74.83,108.94 74.96,108.81
  05_SIG2 w0.292: 94.39,78.36 94.11,78.36 93.89,78.58 93.89,78.96 94.15,79.21 94.46,79.21 94.72,79.47 94.72,79.83 94.46,80.09 94.15,80.09 93.89,80.35 93.89,80.71 94.15,80.97 94.46,80.97 94.72,81.22 94.72,81.59 94.46,81.84 94.15,81.84 93.89,82.1 93.89,82.46 94.15,82.72 94.46,82.72 94.72,82.98 94.72,83.34 94.46,83.6 94.15,83.6 93.89,83.85 93.89,89.01 94.15,89.26 94.51,89.26 94.77,89.52 94.77,89.88 94.51,90.14 94.15,90.14 93.89,90.4 93.89,90.87 95.78,92.76 95.78,97.16 95.04,97.9 95.04,99.8 93.68,101.16 93.68,102.26 93.5,102.44 92.84,102.44 92.66,102.62 92.66,103.17 92.78,103.3 93.65,103.3 93.78,103.17 95.45,103.17 96.57,104.29 96.57,104.83 96.29,105.11 95.96,105.11 95.66,104.8 95.66,104.32 95.43,104.09 95.1,104.09 94.87,104.32 94.87,104.9 94.67,105.11 94.27,105.11 94.07,104.91 94.07,104.35 93.87,104.14 93.45,104.14 93.17,104.42 93.17,104.9 92.97,105.11 92.58,105.11 92.28,104.8 92.28,103.71 91.99,103.41 91.74,103.41 91.49,103.66 91.49,104.88 91.26,105.11 90.83,105.11 90.54,104.81 90.54,103.33 90.35,103.15 89.96,103.15 89.81,103.31 89.81,103.91 89.65,104.06 89.21,104.06 89.05,103.91 89.05,103.47 88.88,103.31 88.59,103.31 88.42,103.47 88.42,104.7 88.16,104.95 87.88,104.95 87.68,104.75 87.68,104.62 87.5,104.44 87.03,104.44 86.59,104.88 86.59,105.24 86.72,105.37 86.72,105.73 86.47,105.99 86.11,105.99 85.98,105.86 85.61,105.86 85.36,106.11 85.36,106.48 85.49,106.61 85.49,106.97 85.23,107.23 84.87,107.23 84.74,107.1 84.37,107.1 83.59,107.88 77.66,107.88 77.14,107.36 76.65,107.36 76.38,107.63 76.38,108.38 76.23,108.53 75.23,108.53 74.96,108.81
  BOTTOM w0.241: v2(100.23,118.32) 100.74,117.81 101.43,117.81 101.91,117.33 R973.2
RLD3_C3_72B_A10: length 155.2
  TOP w0.152: U142.H13 v2(74.32,110.17) ; U1.B31 v2(96.24,73.84)
  TOP w0.241: v2(100.23,115.32) 100.69,114.86 101.47,114.86 101.67,114.66 R974.2
  TOP w0.279: U141.H13 v2(100.23,115.32)
  03_SIG1 w0.173: 100.73,108.46 100.73,110.57 100.98,110.82 101.46,110.82 101.77,111.14 101.77,114.51 101.45,114.82 100.98,114.82 100.48,115.32 v2(100.23,115.32) ; 73.24,108.81 73.24,109.08 v2(74.32,110.17)
  03_SIG1 w0.292: 100.73,108.46 100.73,107.41 97.64,104.32 85.23,104.32 82.39,107.16 79.19,107.16 78.42,107.93 73.67,107.93 73.24,108.35 73.24,108.81
  05_SIG2 w0.173: 68.91,108.84 68.93,108.83 71.52,108.83 71.82,109.14 71.82,110.46 72.03,110.67 74.23,110.67 74.32,110.57 v2(74.32,110.17) ; v2(96.24,73.84) 96.24,73.64 96.74,73.14 96.74,72.53 96.55,72.34 95.88,72.34 95.74,72.49 95.74,73.07 95.47,73.34 94.91,73.34 94.39,73.86 ; 68.91,114.67 69.53,114.67 69.82,114.96 69.82,115.67 70.8,116.65 71.52,116.65 71.82,116.96 71.82,117.45 71.6,117.67 71,117.67 70.82,117.85 70.82,118.51 70.98,118.67 71.55,118.67 71.82,118.94 71.82,119.41 71.82,121.47 71.63,121.67 70.08,121.67 69.82,121.41 69.82,116.66 68.91,115.75
  05_SIG2 w0.292: 94.39,73.86 92.54,75.71 92.54,91.76 94.44,93.65 94.44,96.43 92.32,98.54 92.32,99.6 90.73,101.19 88.37,101.19 83.7,105.87 79.2,105.87 79.06,106 75.73,106 75.27,106.46 74.59,106.46 72.85,108.21 69.2,108.21 68.31,107.31 67.1,107.31 66.08,108.34 66.08,111.77 67.21,112.9 67.21,114.05 68.91,115.75 ; 68.91,114.67 68.43,114.18 68.43,112.73 68.12,112.42 67.89,112.42 66.8,111.33 66.8,108.81 67.01,108.6 67.24,108.6 67.49,108.86 67.49,109.47 67.77,109.75 68.41,109.75 68.69,109.47 68.69,109.06 68.91,108.84
RLD3_C3_72B_A11: length 152.1
  TOP w0.152: 97.74,75.34 v2(97.24,75.84) ; U142.D1 v2(79.32,123.17) ; U141.D1 v2(87.23,120.32)
  TOP w0.241: R955.2 84.8,119.91 86.82,119.91 v2(87.23,120.32)
  07_SIG3 w0.173: 87.66,124.6 87.66,124.43 87.86,124.23 88.19,124.23 88.32,124.1 88.32,123.86 88.23,123.77 87.53,123.77 87.26,124.05 87.06,124.05 86.94,123.92 86.94,123.27 87.14,123.06 87.66,123.06 87.73,122.99 87.73,120.41 87.65,120.32 v2(87.23,120.32) ; 76,124.82 76.09,124.73 78.09,124.73 78.23,124.59 78.23,123.8 78.38,123.66 78.62,123.66 78.69,123.72 78.69,124.46 78.77,124.54 79.1,124.54 79.32,124.31 v2(79.32,123.17)
  07_SIG3 w0.292: 76,124.82 75.95,124.87 75.95,125.35 76.1,125.5 76.54,125.5 76.64,125.59 76.64,126.16 76.43,126.36 76.15,126.36 75.95,126.57 75.95,126.87 77.11,128.04 78.69,128.04 78.93,128.29 78.93,129.02 79.12,129.21 79.53,129.21 79.78,128.96 79.78,128.4 80.14,128.04 82.37,128.04 82.72,128.38 82.72,129.12 82.98,129.39 83.3,129.39 83.62,129.07 83.62,128.02 83.85,127.79 84.68,127.79 85.19,127.28 88.21,127.28 88.42,127.08 88.42,125.81 88.21,125.6 87.93,125.6 87.54,126 87.54,126.23 87.22,126.54 85.67,126.54 85.52,126.39 85.52,125.88 85.81,125.59 86.98,125.59 87.66,124.92 87.66,124.6
  18_SIG6 w0.089: 93.65,108.46 93.55,108.55 93.55,109.66 93.76,109.87 93.76,112.77 93.99,113 93.99,113.5 94.67,114.17 94.67,120 93.85,120.82 93.02,120.82 92.73,121.11 92.73,121.55 92.46,121.82 90.94,121.82 90.71,122.05 90.71,122.55 90.46,122.8 90.02,122.8 89.72,123.1 89.72,123.55 89.44,123.84 87.23,123.84 86.46,124.6 ; v2(97.24,75.84) 97.24,76.14 97.74,76.64 97.74,77.05 97.44,77.34 97.03,77.34 96.74,77.64 96.74,78.05 96.44,78.34 96.03,78.34 95.74,78.64 95.74,80.05 96.03,80.34 96.44,80.34 96.74,80.64 96.74,81.05 97.03,81.34 97.44,81.34 97.74,81.64 97.74,82.05 98.03,82.34 98.44,82.34 98.74,82.64 98.74,83.05 99.03,83.34 99.44,83.34 99.74,83.64 99.74,84.05 100.03,84.34 100.44,84.34 100.74,84.64 100.74,89.13 99.1,90.76 99.1,90.96 ; 71.5,124.82 72.52,123.79 74.68,123.79 75.8,122.67 U142.D1 v2(79.32,123.17)
  18_SIG6 w0.157: 99.1,90.96 99.1,91.12 100.33,92.36 100.33,93.42 98.88,94.87 98.88,99.72 98.62,99.97 98.52,99.97 98.27,100.22 98.27,100.57 98.55,100.85 98.62,100.85 98.88,101.11 98.88,102.7 99.11,102.94 99.11,104.44 97.84,105.71 96.23,105.71 95.35,106.59 95.35,107.34 94.9,107.79 94.31,107.79 93.65,108.46 ; 86.46,124.6 84.59,126.48 82.34,126.48 80.89,127.93 80.21,127.93 79.65,128.48 79.65,130.15 79.94,130.43 79.94,131.03 79,131.96 72.75,131.96 71.04,130.25 71.04,128.14 70.89,127.98 70.46,127.98 70.3,127.82 70.3,127.35 70.46,127.19 71.09,127.19 71.24,127.03 71.24,126.56 71.09,126.4 70.46,126.4 70.3,126.25 70.3,125.77 70.46,125.62 71.09,125.62 71.24,125.46 71.24,125.07 71.5,124.82
RLD3_C3_72B_A12: length 154.9
  TOP w0.152: U141.H11 v2(98.23,115.32) ; U1.C32 v2(97.24,74.84) ; U142.H11 v2(74.32,112.17)
  TOP w0.241: U141.H11 98.24,116.33 100.2,116.33 100.68,116.81 101.7,116.81 R956.2
  07_SIG3 w0.173: v2(97.24,74.84) 96.94,74.84 96.44,75.34 96.03,75.34 95.74,75.64 95.74,75.99 95.38,76.34 95.02,76.34 94.72,76.65 94.72,77.14 94.39,77.47 ; 67.8,112.36 68.52,112.36 68.8,112.09 68.8,111.93 69.07,111.66 73.82,111.66 v2(74.32,112.17)
  07_SIG3 w0.292: 94.39,77.47 90.14,81.71 90.14,85.06 90.13,85.08 90.13,85.36 86.23,89.26 84.11,89.26 84.01,89.36 82.71,89.36 81.5,88.15 79.1,88.15 78.83,88.42 78.48,88.42 78.24,88.18 77.81,88.18 77.54,88.45 77.25,88.45 76.98,88.18 76.55,88.18 76.32,88.41 75.95,88.41 75.72,88.18 75.23,88.18 74.22,89.2 74.22,94.69 74.47,94.95 81.53,94.95 82.42,95.83 82.42,99.02 81.69,99.76 78.86,99.76 78.41,100.2 78.41,100.4 76.83,101.98 76.83,103.1 77.22,103.48 78.1,103.48 78.33,103.71 78.33,104.27 77.85,104.75 76.68,104.75 76.17,105.26 72.31,105.26 71.45,106.12 70.94,106.12 70.02,105.2 67.72,105.2 67.01,105.92 65.1,105.92 64.14,106.88 64.14,106.91 63.6,107.44 63.6,110.34 63.12,110.82 63.12,112.09 63.86,112.83 63.86,113.94 64.67,114.76 64.67,115.44 64.44,115.67 64.44,116.73 64.65,116.93 65.5,116.93 65.71,116.73 65.71,114.68 64.8,113.77 64.8,112.6 64.92,112.47 65.71,112.47 65.73,112.49 66.36,112.49 66.66,112.2 66.66,111.29 66.81,111.13 67.12,111.13 67.29,111.29 67.29,112.14 67.5,112.36 67.8,112.36
  14_SIG4 w0.089: v2(98.23,115.32) 98.23,115.56 96.75,117.04 96.75,117.48 96.41,117.82 96.05,117.82 95.73,118.15 95.73,118.5 95.41,118.82 94.92,118.82 93.93,119.82 93.05,119.82 92.73,120.14 92.73,120.5 92.4,120.83 89.01,120.83 88.71,121.13 88.71,121.55 88.41,121.85 87.04,121.85 85.52,123.36 85.26,123.36 84.97,123.65 77.09,123.65 76.81,123.37 76.81,122.97 76.51,122.68 76.16,122.68 74.81,121.34 74.81,120.98 74.5,120.66 74.15,120.66 73.82,120.33 73.82,120 73.49,119.67 73.15,119.67 72.82,119.34 72.82,117.98 72.53,117.68 72.13,117.68 71.82,117.38 71.82,113.95 72.11,113.67 72.54,113.67 72.82,113.38 72.82,112.91 73.08,112.65 73.84,112.65 v2(74.32,112.17)
RLD3_C3_72B_A13: length 157.4
  TOP w0.152: U1.D30 v2(98.24,72.84) ; U141.D13 v2(100.23,120.32) ; U142.D13 v2(79.32,110.17)
  TOP w0.241: R957.2 101.66,120.76 v2(101.23,120.32)
  03_SIG1 w0.173: v2(100.23,120.32) 99.9,120.32 99.74,120.16 99.74,118.98 99.58,118.82 98.98,118.82 98.73,118.57 98.73,116.68 97.73,115.68 97.73,114.11 98.01,113.82 98.48,113.82 98.73,113.57 98.73,111.12 98.43,110.82 97.97,110.82 97.73,110.58 97.73,110.09 97.87,109.96 97.87,109.69 97.96,109.6 98.28,109.6 98.37,109.51 98.37,109.26 98.28,109.17 97.96,109.17 97.87,109.08 97.87,108.94 97.38,108.46 ; v2(79.32,110.17) 79.61,110.17 80.11,109.67 81.65,109.67 81.82,109.49 81.82,109.23 82.04,109.02 82.73,109.02 82.84,109.12 82.84,109.54 82.92,109.63 83.68,109.63 83.81,109.49 83.81,108.81
  03_SIG1 w0.292: 97.38,108.46 96.98,108.05 95.92,108.05 95.55,107.69 95.55,106.86 95.17,106.48 94.27,106.48 93.93,106.82 93.93,107.33 94.4,107.8 94.4,108.03 94.15,108.28 93.86,108.28 93.63,108.05 87.96,108.05 87.75,108.26 86.41,108.26 86.2,108.05 86.2,107.87 86.41,107.67 86.41,107.4 85.92,106.91 85.51,106.91 85.36,107.06 85.36,107.47 85.45,107.56 85.45,107.97 85.04,108.39 84.62,108.39 84.53,108.3 84.12,108.3 83.81,108.6 83.81,108.81
  05_SIG2 w0.173: 89.1,108.46 87.81,109.75 85,109.75 84.71,110.04 84.71,114.66 84.86,114.81 85.8,114.81 86.79,115.8 87.17,115.8 87.38,116.01 87.38,116.45 87.08,116.74 85.85,116.74 85.72,116.87 85.72,117.91 85.81,118 86.47,118 86.56,118.09 86.56,118.29 86.47,118.38 85.86,118.38 85.79,118.45 85.79,118.66 85.65,118.8 84.18,118.8 83.87,118.49 83.87,118.27 83.99,118.16 84.67,118.16 84.76,118.07 84.76,117.86 84.67,117.78 83.93,117.78 83.85,117.69 83.85,117.47 83.93,117.38 85.23,117.38 85.32,117.29 85.32,117.01 85.2,116.89 83.93,116.89 83.85,116.81 83.85,116.53 83.96,116.41 85.41,116.41 85.5,116.32 85.5,115.97 85.38,115.85 83.93,115.85 83.85,115.76 83.85,113.3 83.93,113.21 84.2,113.21 84.29,113.12 84.29,112.77 84.2,112.68 83.93,112.68 83.85,112.59 83.85,112.18 83.93,112.09 84.2,112.09 84.29,112 84.29,111.83 84.2,111.74 83.93,111.74 83.85,111.65 83.85,110.9 83.61,110.66 79.47,110.66 79.32,110.52 v2(79.32,110.17) ; v2(98.24,72.84) 97.74,73.34 97.74,74.11 97.97,74.34 98.47,74.34 98.74,74.61 98.74,75.21 98.91,75.39 99.42,75.39 99.75,75.72 99.75,76.17 99.91,76.34 105.43,76.34 105.73,76.04 105.73,75.56 105.91,75.39 108.53,75.39 108.71,75.56 108.71,79.04 108.46,79.3 107.91,79.3 107.74,79.47 107.74,81.21 107.6,81.34 99.97,81.34 99.74,81.57 99.74,82.12 99.51,82.34 98.99,82.34 98.74,82.59 98.74,83.12 98.51,83.34 98.03,83.34 97.74,83.63 97.74,84.12 97.51,84.34 97.02,84.34 96.74,84.62 96.74,89.2
  05_SIG2 w0.292: 96.74,89.2 96.74,90.16 99.64,93.06 99.64,96.67 97.41,98.91 97.41,100.63 97.62,100.84 97.62,101.59 97.59,101.63 97.59,102.08 99.09,103.58 99.09,105.26 97.05,107.29 97.05,107.34 96.27,108.13 89.43,108.13 89.1,108.46
  BOTTOM w0.241: v2(101.23,120.32) v2(100.23,120.32)
