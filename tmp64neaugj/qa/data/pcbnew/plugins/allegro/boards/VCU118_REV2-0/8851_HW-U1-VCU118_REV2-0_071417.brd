# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RLD3_C3_72B_DQ18: length 141.7
  TOP w0.152: v2(99.24,79.84) U1.E37 ; U141.D3 v2(89.23,120.32)
  16_SIG5 w0.089: 97.74,90.96 97.74,90.88 97.49,90.63 97.49,90.42 97.99,89.91 97.99,89.7 97.84,89.55 97.63,89.55 97.12,90.05 96.91,90.05 96.67,89.81 96.67,89.48 96.51,89.32 96.17,89.32 96.02,89.17 96.02,88.96 96.17,88.81 96.51,88.81 96.74,88.58 96.74,83.64 97.03,83.34 97.22,83.34 97.22,83.34 97.44,83.34 97.74,83.05 97.74,81.64 98.03,81.34 98.44,81.34 98.74,81.05 98.74,79.51 98.57,79.34 97.03,79.34 96.74,79.05 96.74,78.47 96.86,78.34 98.56,78.34 98.74,78.17 98.74,77.55 98.53,77.34 98.03,77.34 97.74,77.05 97.74,76.64 98.03,76.34 98.5,76.34 98.74,76.11 98.74,75.87 98.74,75.64 99.03,75.34 99.44,75.34 99.74,75.64 99.74,78.88 99.74,79.05 100.03,79.34 100.44,79.34 100.74,79.05 100.74,76.69 100.74,76.64 101.03,76.34 101.08,76.34 101.08,76.34 101.25,76.34 101.26,76.34 101.44,76.34 101.74,76.64 101.74,79.13 101.94,79.33 102.02,79.33 102.03,79.34 103.29,79.34 103.29,79.34 103.44,79.34 103.74,79.64 103.74,80.05 103.44,80.34 102.09,80.34 102.09,80.34 102.03,80.34 101.74,80.64 101.74,80.69 101.74,81.05 102.03,81.34 103.26,81.34 103.26,81.34 103.44,81.34 103.74,81.64 103.74,83.05 103.44,83.34 103.03,83.34 102.74,83.64 102.74,84.05 103.03,84.34 103.44,84.34 103.45,84.34 103.74,84.63 103.74,85.05 103.44,85.34 103.03,85.34 102.74,85.64 102.74,86.05 103.03,86.34 103.32,86.34 103.32,86.34 103.44,86.34 103.74,86.64 103.74,87.05 103.44,87.34 103.27,87.34 103.27,87.34 103.03,87.34 102.74,87.64 102.74,88.05 103.03,88.34 103.59,88.34 103.74,88.49 103.74,89.15 103.38,89.5 102.8,89.5 102.61,89.69 102.61,90.28 102.35,90.53 102.04,90.53 101.74,90.23 101.74,82.76 101.74,82.64 101.44,82.34 101.32,82.34 101.32,82.34 101.03,82.34 100.74,82.05 100.74,80.74 100.74,80.64 100.44,80.34 99.78,80.34 99.76,80.37 v2(99.24,79.84) ; 86.82,118.6 87.06,118.84 88.46,118.84 88.73,119.11 88.73,119.53 89.23,120.03 v2(89.23,120.32) ; 93.99,108.46 93.71,108.74 92.11,108.74 91.73,109.12 91.73,109.53 91.43,109.82 90.92,109.82 90.71,110.03 90.71,110.52 90.43,110.81 90.04,110.81 89.71,110.48 89.71,109.96 89.59,109.84 88.03,109.84 87.74,110.12 87.74,110.62 87.96,110.84 89.43,110.84 89.71,111.12 89.71,111.52 89.43,111.81 86.99,111.81 86.82,111.99 ; 86.82,118.05 87.02,117.84 87.39,117.84 87.71,117.52 87.71,116.93 87.92,116.73 88.61,116.73 88.74,116.86 88.74,117.65 88.93,117.83 89.41,117.83 89.71,117.52 89.71,117.12 89.71,116.88 89.87,116.73 90.63,116.73 90.78,116.58 90.78,116.36 90.63,116.21 90.15,116.21 89.99,116.06 89.99,115.79 89.84,115.64 89.63,115.64 89.48,115.79 89.48,116.06 89.32,116.21 88.88,116.21 88.73,116.06 88.73,115.14 89.03,114.84 89.4,114.84 89.71,114.52 89.71,114.52 89.73,114.5 89.73,114.12 89.43,113.82 89.03,113.82 88.73,113.52 88.73,113.11 88.46,112.84 87.01,112.84 86.82,113.03
  16_SIG5 w0.14: 86.82,118.6 86.73,118.51 86.73,118.14 86.82,118.05 ; 93.99,108.46 94.29,108.15 94.81,108.15 95.04,107.92 95.04,107.68 95.27,107.45 95.6,107.45 95.83,107.68 95.83,107.92 96.06,108.15 96.5,108.15 96.85,107.8 96.85,106.81 98.89,104.76 98.89,104.44 98.6,104.14 98.44,104.14 98.21,103.91 98.21,103.59 98.44,103.36 98.6,103.36 98.83,103.13 98.83,101.27 99.06,101.04 99.35,101.04 99.58,100.81 99.58,100.49 99.35,100.26 99.06,100.26 98.83,100.03 98.83,97.96 99.09,97.7 99.09,97.42 99.32,97.19 99.36,97.19 99.59,96.96 99.59,96.64 99.36,96.41 99.32,96.41 99.09,96.18 99.09,95.85 99.32,95.62 99.36,95.62 99.59,95.39 99.59,95.07 99.36,94.84 99.32,94.84 99.09,94.61 99.09,94.28 99.32,94.05 99.36,94.05 99.59,93.82 99.59,93.5 99.36,93.27 99.32,93.27 99.09,93.04 99.09,92.89 97.74,91.54 97.74,90.96 ; 86.82,113.03 86.74,113.1 86.74,113.4 85.71,114.43 85.71,115.53 85.44,115.81 85,115.81 84.74,115.55 84.74,114.12 85.03,113.83 85.4,113.83 85.71,113.52 85.71,113.37 86.67,112.42 86.67,112.13 86.82,111.99
RLD3_C3_72B_DQ19: length 142.4
  TOP w0.152: U141.E4 v2(90.23,119.32) ; U1.E38 v2(99.24,80.84)
  16_SIG5 w0.089: v2(90.23,119.32) 90.73,119.82 90.73,120.53 91.02,120.82 93.43,120.82 93.78,120.48 93.78,114.16 93.43,113.82 93.02,113.82 92.73,113.53 92.73,112.12 93.02,111.82 95.45,111.82 95.73,112.1 95.73,122.51 96.06,122.84 96.57,122.84 96.72,122.68 96.72,112.14 97.05,111.81 97.51,111.81 97.74,112.04 97.74,114.12 97.74,118.64 97.92,118.82 98.45,118.82 98.73,118.54 98.73,111.94 98.86,111.81 99.43,111.81 99.74,112.13 99.74,124.41 99.55,124.6 ; v2(99.24,80.84) 99.74,81.34 99.74,82.21 99.87,82.34 100.44,82.34 100.74,82.64 100.74,89.2 101.1,89.56 101.1,90.36 101.7,90.96
  16_SIG5 w0.14: 99.55,124.6 98.97,125.18 98.97,125.75 99.4,126.17 99.4,126.47 99.26,126.61 97.54,126.61 97.4,126.75 97.4,127.03 97.54,127.17 99.26,127.17 99.4,127.31 99.4,129.9 99.83,130.33 106.24,130.33 109.55,127.03 109.55,111.61 108.99,111.05 107.94,111.05 107.45,110.56 107.45,106.86 103.28,102.68 103.28,98.83 102.95,98.5 102.95,92.94 101.7,91.69 101.7,90.96
RLD3_C3_72B_DQ20: length 139.5
  TOP w0.152: v2(97.24,81.84) 97.74,81.34 U1.C39 ; U141.C6 v2(92.23,121.32)
  16_SIG5 w0.089: 93.38,124.6 93.38,124.22 93.72,123.88 93.72,121.97 93.57,121.82 93.07,121.82 92.57,121.32 v2(92.23,121.32) ; 106.74,90.96 106.74,79.52 106.56,79.34 105.92,79.34 105.74,79.16 105.74,78.64 105.44,78.34 105.34,78.34 105.34,78.34 105.03,78.34 104.74,78.05 104.74,77.64 105.03,77.34 105.15,77.34 105.15,77.34 106.44,77.34 106.74,77.05 106.74,76.64 106.44,76.34 105.21,76.34 105.21,76.34 105.03,76.34 104.74,76.05 104.74,75.87 104.74,75.59 104.99,75.34 105.2,75.34 105.2,75.34 105.55,75.34 105.74,75.16 105.74,74.51 105.57,74.34 105.29,74.34 105.29,74.34 102.94,74.34 102.74,74.54 102.74,75.05 102.44,75.34 100.03,75.34 99.74,75.05 99.74,74.64 100.03,74.34 100.22,74.34 100.22,74.34 100.58,74.34 100.74,74.19 100.74,73.47 100.61,73.34 100.03,73.34 99.74,73.64 99.74,74.05 99.44,74.34 99.27,74.34 99.27,74.34 99.03,74.34 98.74,74.64 98.74,74.88 98.74,75.05 98.44,75.34 98.12,75.34 98.12,75.34 98.03,75.34 97.74,75.64 97.74,75.72 97.74,76.05 97.44,76.34 97.12,76.34 97.12,76.34 97.03,76.34 96.74,76.64 96.74,76.72 96.74,77.05 96.44,77.34 96.03,77.34 95.74,77.64 95.74,79.05 96.03,79.34 96.45,79.34 96.74,79.63 96.74,79.64 96.74,80.05 97.03,80.34 97.44,80.34 97.74,80.63 97.74,81.05 97.24,81.55 v2(97.24,81.84)
  16_SIG5 w0.14: 106.74,90.96 106.74,91.7 107.11,92.08 107.11,92.45 106.97,92.59 106.78,92.59 106.64,92.73 106.64,93.15 106.78,93.29 106.97,93.29 107.11,93.43 107.11,97.21 106.38,97.94 106.38,99.68 106.11,99.95 105.68,99.95 105.49,100.14 105.49,100.7 105.73,100.95 107.57,100.95 108.03,101.41 108.03,102.25 107.77,102.52 107.22,102.52 107.07,102.67 107.07,102.98 107.28,103.2 107.68,103.2 108.03,103.56 108.03,104.99 109.25,106.2 109.57,106.2 110.41,105.35 110.74,105.35 110.97,105.58 110.97,105.91 110.29,106.59 110.29,107.67 112.05,109.43 112.05,123 111.28,123.78 111.28,127.76 106.86,132.18 105.02,132.18 103.17,134.04 102.94,134.04 102.71,133.81 102.71,133.35 102.48,133.12 102.15,133.12 101.92,133.35 101.92,133.81 101.7,134.04 101.09,134.04 100.3,134.82 96.92,134.82 96.69,135.05 96.69,135.69 96.45,135.93 96.13,135.93 95.9,135.71 95.9,135.05 95.67,134.82 95.35,134.82 95.12,135.05 95.12,135.46 94.89,135.69 94.56,135.69 94.33,135.46 94.33,135.05 94.04,134.76 91.9,134.76 91.69,134.97 91.69,136.48 91.44,136.73 91.05,136.73 90.87,136.55 90.87,132.45 91.34,131.98 91.34,129.95 91.75,129.54 91.75,127.18 93.38,125.54 93.38,124.6
RLD3_C3_72B_DQ21: length 137.2
  TOP w0.152: U1.B40 96.74,82.34 v2(96.24,82.84) ; U141.C4 v2(90.23,121.32)
  16_SIG5 w0.089: 79.84,123.65 79.84,121.97 80.12,121.68 80.49,121.68 80.81,121.37 80.81,121 81.12,120.68 81.49,120.68 81.81,120.37 81.81,120 82.12,119.68 82.49,119.68 82.81,119.37 82.81,119 83.12,118.68 83.56,118.68 83.59,118.65 ; 86.82,119.82 88.43,119.82 88.73,120.11 88.73,120.53 89.02,120.82 89.46,120.82 89.96,121.32 v2(90.23,121.32) ; 86.82,113.96 86.95,113.82 88.54,113.82 88.73,114.01 88.73,114.58 88.47,114.83 87.96,114.83 87.73,115.07 87.73,116.18 87.47,116.43 87.09,116.43 86.82,116.71 ; v2(96.24,82.84) 96.24,83.14 95.74,83.64 95.74,83.74 95.74,89.58 96.74,90.58 96.74,90.96
  16_SIG5 w0.14: 79.84,123.65 79.84,123.94 79.48,124.3 79.48,129.91 79.93,130.36 79.93,131.12 78.94,132.11 73.96,132.11 72.49,133.57 72.49,136.07 72.68,136.27 72.89,136.27 73.02,136.13 73.02,134.01 74.14,132.9 76.09,132.9 76.23,133.04 76.23,135.76 76.45,135.98 76.79,135.98 76.93,135.84 76.93,133.04 77.07,132.9 77.49,132.9 77.63,133.04 77.63,134.45 77.77,134.59 78.19,134.59 78.33,134.46 78.33,133.04 78.47,132.9 79.59,132.9 80.79,131.7 82.55,131.7 82.73,131.52 82.73,127.93 82.59,127.79 80.91,127.79 80.77,127.65 80.77,126.49 81,126.26 82.27,126.26 82.45,126.08 82.45,125.76 82.17,125.48 81,125.48 80.77,125.25 80.77,124.54 81.85,123.46 82.64,123.46 83.03,123.07 83.03,121.31 83.34,121.01 83.66,121.01 84.07,120.59 84.07,119.71 84.68,119.1 84.68,117.26 86.11,115.84 86.11,115.04 86.28,114.86 86.28,114.49 86.82,113.96 ; 83.59,118.65 83.87,118.37 83.87,116.76 84.37,116.27 84.37,115.94 84.17,115.75 84.1,115.75 83.87,115.52 83.87,114.43 84.53,113.77 84.53,113.18 84.89,112.83 85.65,112.83 86.2,112.28 86.2,111.92 86.7,111.42 86.7,110.1 87.39,109.41 88.49,109.41 88.99,108.91 90.92,108.91 91.72,108.1 93.1,108.1 93.55,107.65 93.55,107.24 94.36,106.43 96.27,106.43 97.55,105.14 97.55,100.44 97.33,100.22 97.33,98.37 98.27,97.43 98.27,93.27 96.74,91.73 96.74,90.96 ; 86.82,119.82 86.66,119.82 86.28,119.44 86.28,117.97 86.73,117.53 86.73,116.79 86.82,116.71
RLD3_C3_72B_DQ22: length 139.4
  TOP w0.152: U141.C2 v2(88.23,121.32) ; v2(95.24,81.84) 95.74,81.34 U1.A39
  16_SIG5 w0.089: 89.03,124.6 88.64,124.21 87.5,124.21 87.1,123.8 87.1,122.89 86.82,122.61 ; v2(88.23,121.32) 88.23,121.65 88.09,121.79 86.9,121.79 86.82,121.87 ; 83.59,111.58 83.5,111.68 83.12,111.68 82.81,112 82.81,112.37 82.49,112.68 82.12,112.68 81.81,113 81.81,113.37 81.49,113.68 81.12,113.68 80.81,114 80.81,115.94 80.96,116.09 81.31,116.09 81.46,116.24 81.46,116.46 81.31,116.61 80.96,116.61 80.81,116.76 80.81,118.45 80.58,118.68 80.12,118.68 79.81,118.99 79.81,119.43 79.56,119.68 79.12,119.68 78.81,120 78.81,120.37 78.49,120.68 78.12,120.68 77.81,121 77.81,121.37 77.49,121.68 77.12,121.68 76.84,121.97 76.84,124.15 76.17,124.82
  16_SIG5 w0.14: 83.59,111.58 84.63,110.54 84.63,110.21 86.77,108.08 87.73,108.08 88.08,107.72 88.08,107.46 93.68,101.87 93.68,101.23 93.91,101 94.08,101 94.31,100.77 94.31,100.44 94.08,100.21 93.91,100.21 93.68,99.98 93.68,98.76 95.86,96.57 95.86,94.47 94.04,92.65 94.04,83.04 v2(95.24,81.84) ; 89.03,124.6 89.03,126.3 87.83,127.5 87.83,135.66 87.29,136.21 85.08,136.21 83.04,138.24 80.17,138.24 79.85,138.56 79.85,139.54 79.62,139.77 79.29,139.77 79.06,139.53 79.06,138.56 78.83,138.33 78.51,138.33 78.28,138.56 78.28,140.25 78.02,140.5 77.7,140.5 77.49,140.3 77.49,138.56 77.26,138.33 76.94,138.33 76.71,138.56 76.71,140.25 76.45,140.5 76.13,140.5 75.92,140.3 75.92,138.56 75.59,138.22 71.66,138.22 71.32,138.56 71.32,138.94 71.09,139.17 70.77,139.17 70.63,139.03 70.63,138.65 70.25,138.27 68.77,138.27 67.61,139.42 67.61,140.72 66.75,141.58 66.09,141.58 65.79,141.28 65.79,139.85 66.14,139.5 66.14,138.36 65.41,137.63 64.05,137.63 62.93,136.51 62.93,134.75 64.01,133.68 66.09,133.68 68.33,131.44 71.65,131.44 72.47,130.63 72.47,128.52 76.17,124.82 ; 86.82,122.61 86.74,122.54 86.74,121.94 86.82,121.87
RLD3_C3_72B_DQ23: length 138.9
  TOP w0.152: U1.A40 95.74,82.34 v2(95.24,82.84) ; U141.B5 v2(91.23,122.32)
  16_SIG5 w0.089: v2(91.23,122.32) 90.91,122.32 90.41,121.82 88.93,121.82 88.73,121.62 88.73,121.11 88.43,120.82 86.82,120.82 ; v2(95.24,82.84) 95.09,82.84 94.43,83.51 94.43,89.8 94.72,90.09 94.72,90.96 ; 77.84,123.6 77.84,121.97 78.12,121.68 78.49,121.68 78.84,121.34 78.84,120.97 79.12,120.68 79.49,120.68 79.81,120.37 79.81,120 80.12,119.68 80.49,119.68 80.81,119.37 80.81,118.98 81.1,118.68 81.49,118.68 81.84,118.34 81.84,113.97 82.12,113.68 82.49,113.68 82.81,113.37 82.81,113 83.12,112.68 83.51,112.68 83.59,112.59
  16_SIG5 w0.14: 77.84,123.6 77.84,124.06 78.08,124.31 78.08,125.6 77.87,125.81 76.99,125.81 76.84,125.96 76.84,126.21 78.12,127.5 78.12,127.82 77.89,128.05 77.57,128.05 76.26,126.74 75.89,126.74 75.66,126.97 75.66,127.25 77.15,128.74 77.15,128.98 76.92,129.21 76.72,129.21 75.51,127.99 73.96,127.99 73,128.96 73,131.26 71.62,132.64 68.2,132.64 66.47,134.37 64.24,134.37 63.58,135.03 63.58,136.25 64.3,136.97 64.95,136.97 65.08,136.83 65.08,136.29 65.32,136.05 65.84,136.05 66.13,136.34 66.13,137.25 66.37,137.49 67.79,137.49 68.07,137.21 68.07,136.17 68.22,136.02 68.8,136.02 68.99,136.21 68.99,137.44 69.13,137.58 82.61,137.58 84.56,135.64 84.56,129.15 85.97,127.74 86.84,127.74 87.07,127.51 87.07,127.19 86.84,126.96 86.59,126.96 86.36,126.73 86.36,126.4 86.59,126.17 88.09,126.17 88.34,125.92 88.34,125.59 88.14,125.39 86.59,125.39 86.36,125.16 86.36,123.9 86.59,123.67 86.59,123.32 85.69,122.41 85.69,121.1 86,120.78 86.77,120.78 86.82,120.82 ; 83.59,112.59 83.81,112.38 83.81,112.01 84.99,110.82 85.43,110.82 85.79,110.45 85.79,109.86 87.17,108.49 88.07,108.49 88.6,107.96 89.32,107.96 89.59,107.7 89.59,107.2 94.07,102.72 94.41,102.72 95,102.13 95,99.87 95.32,99.54 95.32,98.2 96.63,96.89 96.63,93.99 94.72,92.08 94.72,90.96
RLD3_C3_72B_DQ24: length 139.9
  TOP w0.152: U1.D40 98.74,82.34 v2(98.24,82.84) ; U141.B3 v2(89.23,122.32)
  16_SIG5 w0.089: 98.45,90.96 98.42,90.92 98.42,89.73 97.74,89.05 97.74,88.95 97.74,83.64 98.24,83.14 v2(98.24,82.84) ; v2(89.23,122.32) 88.74,122.81 87.71,122.81 87.55,122.96 87.55,123.39 87.97,123.81 89.43,123.81 89.71,123.52 89.71,122.99 89.86,122.84 90.43,122.84 90.71,123.12 90.71,123.49 91.03,123.81 91.43,123.81 91.71,123.52 91.71,122.85 91.72,122.84 92.58,122.84 92.74,122.67 92.74,122.1 92.44,121.81 91.01,121.81 90.73,121.53 90.73,121.12 90.43,120.82 90.02,120.82 89.73,120.53 89.73,119 89.91,118.82 90.41,118.82 90.71,118.52 90.71,117.15 91.21,116.66 91.22,116.66 91.39,116.49 91.39,116.14 91.22,115.97 91.08,115.97 90.73,115.61 90.73,114.12 90.43,113.82 90.02,113.82 89.73,113.53 89.73,112.12 90.02,111.82 90.43,111.82 90.73,111.53 90.73,111.12 91.02,110.82 91.36,110.82 91.73,110.45 91.73,110.12 92.02,109.82 92.49,109.82 92.91,109.4 94.16,109.4 94.82,108.74 97,108.74 97.28,108.46
  16_SIG5 w0.14: 97.28,108.46 97.66,108.08 97.66,106.91 98.65,105.92 101.86,105.92 103.31,107.37 103.31,111.8 104.6,113.09 104.6,113.64 104.01,114.23 104.01,116.78 103.28,117.52 103.28,119.05 104.14,119.92 104.14,123.05 105.08,123.99 105.08,125.8 105.21,125.94 106.19,125.94 106.33,126.08 106.33,126.36 106.19,126.5 105.21,126.5 105.08,126.64 105.08,127.06 105.33,127.32 107.15,127.32 107.62,126.85 107.62,126.3 107.43,126.11 107,126.11 106.81,125.91 106.81,125.54 106.67,125.4 105.88,125.4 105.74,125.26 105.74,124.98 105.88,124.84 106.88,124.84 107.02,124.7 107.02,124.41 106.88,124.28 105.83,124.28 105.69,124.14 105.69,123.86 105.83,123.72 106.67,123.72 106.81,123.58 106.81,123.26 106.67,123.12 104.99,123.12 104.85,122.98 104.85,122.7 104.99,122.56 107.21,122.56 107.35,122.42 107.35,122.14 107.21,122 104.99,122 104.85,121.86 104.85,121.58 104.99,121.44 106.67,121.44 106.81,121.3 106.81,121.02 106.67,120.88 104.99,120.88 104.85,120.74 104.85,120.46 104.99,120.32 106.67,120.32 106.81,120.18 106.81,119.61 106.52,119.33 105.18,119.33 104.66,118.81 104.66,118.49 104.9,118.25 104.9,114.74 105.61,114.03 105.61,113.06 104.18,111.63 104.18,109.14 105.17,108.15 105.17,107.03 102.98,104.84 100.07,104.84 99.54,104.32 99.54,102.72 100.25,102.01 100.25,92.76 98.45,90.96
RLD3_C3_72B_DQ25: length 139.1
  TOP w0.152: U141.A6 v2(92.23,123.32) ; v2(97.24,82.84) 97.74,82.34 U1.C40
  16_SIG5 w0.089: 83.59,109.45 83.35,109.45 82.81,109.99 82.81,110.37 82.5,110.68 82.12,110.68 81.81,110.99 81.81,111.37 81.49,111.68 80.02,111.68 79.81,111.89 79.81,112.37 79.52,112.65 79.05,112.65 78.84,112.86 78.84,118.37 78.52,118.68 78.12,118.68 77.84,118.97 77.84,119.37 77.52,119.68 77.12,119.68 76.81,120 76.81,120.37 76.49,120.68 76.12,120.68 75.23,121.56 75.23,124.23 74.65,124.82 ; 94.39,79.34 95.49,79.34 95.74,79.59 95.74,80.05 96.03,80.34 96.49,80.34 96.74,80.59 96.74,82.34 v2(97.24,82.84)
  16_SIG5 w0.14: 83.59,109.45 83.64,109.45 87.99,105.1 88.46,105.1 91.04,102.53 91.04,98.83 92.92,96.95 93.31,96.95 94.32,95.94 94.32,94.86 92.07,92.62 92.07,81.37 94.11,79.34 94.39,79.34 ; v2(92.23,123.32) 92.74,123.83 92.74,125.24 92.4,125.58 91.53,125.58 89.18,127.93 89.18,138.99 86.06,142.11 68.7,142.11 67.32,143.49 63.1,143.49 61.77,142.16 61.77,137.17 60.88,136.28 60.88,134.99 64.17,131.71 65.9,131.71 67.84,129.77 67.84,128.96 69.27,127.53 71.94,127.53 74.65,124.82
RLD3_C3_72B_DQ26: length 141.5
  TOP w0.152: U1.B38 96.74,80.34 v2(96.24,80.84) ; U141.A4 v2(90.23,123.32)
  16_SIG5 w0.089: 75.39,124.82 75.84,124.37 75.84,121.97 76.12,121.68 76.49,121.68 76.81,121.37 76.81,121 77.12,120.68 77.49,120.68 77.81,120.37 77.81,120 78.12,119.68 78.49,119.68 78.81,119.37 78.81,118.99 79.1,118.69 79.48,118.69 79.81,118.37 79.81,116.7 79.66,116.55 79.35,116.55 79.2,116.4 79.2,116.18 79.35,116.03 79.66,116.03 79.81,115.88 79.81,112.86 80.02,112.65 81.52,112.65 81.81,112.37 81.81,112 82.12,111.68 82.49,111.68 82.81,111.37 82.81,110.99 83.12,110.68 83.56,110.68 83.59,110.65 ; 94.39,80.34 95.66,80.34 95.92,80.6 96,80.6 v2(96.24,80.84)
  16_SIG5 w0.14: 83.59,110.65 83.85,110.38 83.85,110.1 88.08,105.87 88.78,105.87 92.38,102.27 92.38,101.32 92.61,101.09 92.76,101.09 92.99,100.86 92.99,100.53 92.76,100.3 92.61,100.3 92.38,100.07 92.38,98.58 93.24,97.72 93.63,97.72 95.09,96.25 95.09,94.62 92.85,92.38 92.85,89.97 93.35,89.48 93.35,88.93 92.85,88.44 92.85,87.88 93.35,87.39 93.35,86.84 92.85,86.34 92.85,85.62 93.08,85.39 93.17,85.39 93.4,85.16 93.4,84.84 93.17,84.61 93.08,84.61 92.85,84.38 92.85,84.05 93.08,83.82 93.17,83.82 93.4,83.59 93.4,83.27 93.17,83.04 93.08,83.04 92.85,82.81 92.85,81.64 93.11,81.39 93.44,81.39 94.04,81.99 94.36,81.99 94.59,81.76 94.59,81.43 93.99,80.83 93.99,80.51 94.16,80.34 94.39,80.34 ; v2(90.23,123.32) 90.23,123.76 89.86,124.12 89.86,124.9 90.23,125.27 90.23,125.97 88.42,127.78 88.42,136.78 87.81,137.39 87.81,139.4 87.52,139.69 87.06,139.69 86.84,139.47 86.84,137.26 86.51,136.93 85.77,136.93 85.37,137.33 85.37,137.53 85.51,137.67 85.67,137.67 85.89,137.88 85.89,138.19 85.66,138.42 85.16,138.42 84.91,138.68 84.91,141.04 84.36,141.59 68.42,141.59 67.26,142.75 64.92,142.75 64.48,142.3 64.48,140.22 62.59,138.33 62.59,137.07 62.29,136.78 62.29,134.49 63.94,132.84 65.94,132.84 67.87,130.91 70.83,130.91 70.97,130.77 70.97,129.24 75.39,124.82
RLD3_C3_72B_DQ27: length 145.7
  TOP w0.152: U141.J4 v2(90.23,114.32) ; U1.D35 v2(98.24,77.84)
  14_SIG4 w0.089: 89.89,124.6 89.89,124.08 90.13,123.84 92.43,123.84 92.73,123.54 92.73,123.05 92.96,122.82 94.4,122.82 94.61,122.61 94.61,122.16 94.94,121.83 99.46,121.83 99.73,121.55 99.73,116.89 100.73,115.89 100.73,113.07 100.49,112.82 95.02,112.82 94.72,113.13 94.72,113.66 93.56,114.82 92,114.82 91.73,114.55 91.73,114.11 91.44,113.82 91.02,113.82 90.52,114.32 v2(90.23,114.32) ; 105.74,89.36 105.74,86.64 105.44,86.34 105.03,86.34 104.74,86.05 104.74,85.64 104.44,85.34 104.03,85.34 103.74,85.05 103.74,84.64 103.44,84.34 103.03,84.34 102.74,84.05 102.74,83.64 102.44,83.34 102.03,83.34 101.74,83.05 101.74,82.64 101.44,82.34 101.03,82.34 100.74,82.05 100.74,79.63 100.44,79.34 100.01,79.34 99.72,79.05 99.72,78.7 99.72,78.7 99.72,78.64 99.42,78.35 97.96,78.35 97.89,78.28 97.89,77.92 97.96,77.84 v2(98.24,77.84)
  14_SIG4 w0.14: 89.89,124.6 89.89,124.77 89.74,124.91 88.88,124.91 88.61,125.18 88.61,125.68 88.42,125.87 88.01,125.87 87.87,125.72 87.87,125.39 87.73,125.26 86.96,125.26 86.79,125.43 86.79,125.77 86.67,125.88 83.18,125.88 82.42,126.64 82.42,127.25 84.66,129.49 84.66,130.66 83.79,131.52 83.16,131.52 83.06,131.62 83.06,131.94 83.2,132.08 84.61,132.08 85.43,131.26 88.21,131.26 90.14,133.19 103.69,133.19 103.81,133.07 103.81,132.87 103.42,132.48 103.42,132.28 103.62,132.08 103.81,132.08 104.2,132.47 104.4,132.47 113.41,123.47 113.41,113.08 112.58,112.25 112.58,109.61 111.58,108.61 111.58,105.49 108.1,102.01 108.1,101.5 107.91,101.31 107.91,101.07 108.21,100.78 108.21,100.54 108.04,100.37 107.81,100.37 107.51,100.67 107.27,100.67 106.38,99.77 106.38,97.41 107.82,95.96 107.82,94.1 106.34,92.62 106.34,89.97 105.74,89.36
RLD3_C3_72B_DQ28: length 145
  TOP w0.152: U141.K3 v2(89.23,113.32) ; U1.C35 v2(97.24,77.84)
  14_SIG4 w0.089: v2(89.23,113.32) 89.23,113.61 89.71,114.1 89.71,114.63 89.91,114.82 91.43,114.82 91.73,115.12 91.73,115.52 92.03,115.82 93.42,115.82 94.73,114.51 94.73,114.12 95.02,113.82 99.55,113.82 99.72,114 99.72,116.11 98.73,117.1 98.73,120.52 98.42,120.83 94.74,120.83 93.74,121.82 92.96,121.82 92.73,122.05 92.73,122.52 92.43,122.82 89.96,122.82 89.73,123.05 89.73,123.58 89.15,124.16 86.93,124.16 86.82,124.27 ; v2(97.24,77.84) 97.47,77.84 97.97,77.34 99.41,77.34 99.72,77.64 99.72,78.07 100,78.35 100.48,78.35 100.74,78.61 100.74,79.06 101.05,79.36 101.44,79.36 101.74,79.67 101.74,82.05 102.03,82.34 102.44,82.34 102.74,82.64 102.74,83.05 103.03,83.34 103.44,83.34 103.74,83.64 103.74,84.05 104.03,84.34 104.44,84.34 104.74,84.64 104.74,85.05 105.03,85.34 105.44,85.34 105.74,85.64 105.74,86.05 106.03,86.34 106.44,86.34 106.74,86.64 106.74,89.23
  14_SIG4 w0.14: 106.74,89.23 107.04,89.53 107.04,92.51 108.48,93.95 108.48,96.22 107.77,96.93 107.77,99.1 108.71,100.04 108.71,100.36 109.75,101.4 109.75,102.7 112.16,105.1 112.16,108.16 113.33,109.34 113.33,112.22 113.82,112.7 114.2,112.7 114.43,112.93 114.43,113.23 113.98,113.68 113.98,123.71 103.94,133.76 89.85,133.76 88.75,132.66 82.14,132.66 81.48,132 81.48,131.11 81.64,130.96 82.7,130.96 82.88,130.78 82.88,129.03 81.36,127.51 81.36,125.81 81.93,125.24 85.86,125.24 86.62,124.47 86.62,124.47 86.82,124.27
RLD3_C3_72B_DQ29: length 147.3
  TOP w0.152: U141.K1 v2(87.23,113.32) ; U1.D34 v2(98.24,76.84)
  14_SIG4 w0.089: v2(87.23,113.32) 86.73,113.82 86.73,115.53 87.03,115.83 91.44,115.83 91.75,116.14 93.9,116.14 94.73,115.31 94.73,115.12 95.02,114.82 98.45,114.82 98.73,115.1 98.73,116.11 97.72,117.11 97.72,117.52 97.43,117.81 97.03,117.81 96.73,118.11 96.73,118.52 96.43,118.82 96.03,118.82 95.73,119.12 95.73,119.6 95.49,119.84 94.83,119.84 93.84,120.82 93.02,120.82 92.73,121.11 92.73,121.56 92.46,121.83 89.01,121.83 88.72,122.11 88.72,123.49 88.4,123.81 86.82,123.81 ; v2(98.24,76.84) 98.74,76.34 99.42,76.34 99.75,76.68 99.75,77.04 100.08,77.36 100.44,77.36 100.72,77.64 100.72,78.01 101.02,78.32 101.03,78.32 101.04,78.32 101.42,78.32 101.75,78.65 101.75,79.05 102.01,79.31 102.03,79.31 102.04,79.32 102.49,79.32 102.74,79.57 102.74,82.05 103.03,82.34 103.43,82.34 103.74,82.65 103.74,83.06 104.01,83.34 104.43,83.34 104.74,83.65 104.74,84.06 105.02,84.34 105.35,84.34 105.74,84.73 105.74,85.04 106.04,85.34 106.44,85.34 106.74,85.64 106.74,86.01 107.07,86.34 107.36,86.34 107.74,86.72 107.74,89.35
  14_SIG4 w0.14: 107.74,89.35 107.74,92.4 109.24,93.91 109.24,100.16 110.26,101.18 110.45,101.18 111.25,101.98 111.25,103.39 113.52,105.66 113.52,108.53 115.14,110.15 115.14,111.94 115.73,112.53 115.73,122.79 107.01,131.51 107.01,132.64 105.99,133.65 104.87,133.65 104.19,134.33 89.54,134.33 88.41,133.2 81.84,133.2 80.09,131.44 80.09,130.56 79.32,129.79 79.32,126.66 81.33,124.64 85.52,124.64 86.34,123.81 86.82,123.81
RLD3_C3_72B_DQ30: length 145.4
  TOP w0.152: U1.C34 v2(97.24,76.84) ; U141.L6 v2(92.23,112.32)
  14_SIG4 w0.089: v2(92.23,112.32) 92.12,112.32 92.02,112.42 92.02,112.68 92.18,112.84 92.44,112.84 92.66,113.05 92.84,113.05 92.99,112.91 92.99,112.69 92.72,112.43 92.72,111.97 92.88,111.82 93.76,111.82 94.31,111.27 94.31,110.79 94.46,110.64 94.59,110.64 94.68,110.55 94.68,110.4 94.56,110.29 94.44,110.29 94.31,110.16 94.31,109.96 94.45,109.82 101.43,109.82 101.75,110.15 101.75,110.62 102.11,110.97 ; 102.74,89.4 102.74,86.64 102.44,86.34 102.03,86.34 101.74,86.05 101.74,85.64 101.44,85.34 101.03,85.34 100.74,85.05 100.74,84.64 100.44,84.34 100.03,84.34 99.74,84.05 99.74,83.64 99.44,83.34 99.03,83.34 98.74,83.05 98.74,82.64 98.44,82.34 98.03,82.34 97.74,82.05 97.74,81.64 97.44,81.34 97.03,81.34 96.74,81.05 96.74,79.64 97.03,79.34 97.44,79.34 97.74,79.05 97.74,78.64 97.44,78.34 97.03,78.34 96.74,78.05 96.74,77.59 97.24,77.09 v2(97.24,76.84)
  14_SIG4 w0.14: 102.74,89.4 104.64,91.3 104.64,92.9 106.19,94.45 106.19,95.6 104.73,97.06 104.73,97.9 103.47,99.17 103.47,99.43 105.11,101.06 105.11,101.62 104.68,102.05 104.68,102.27 104.98,102.57 105.11,102.57 105.37,102.31 105.78,102.31 106.52,103.05 106.52,104.14 108.67,106.3 108.67,108.12 111.07,110.51 111.07,112.84 111.94,113.71 111.94,122.91 104.33,130.51 102.43,130.51 101.98,130.06 101.34,130.06 100.89,130.51 99.99,130.51 99.59,130.11 99.17,130.11 98.4,130.88 98.12,130.88 97.98,130.74 97.98,130.64 97.84,130.5 97.57,130.5 97.43,130.64 97.43,130.74 97.29,130.88 97.01,130.88 96.87,130.74 96.87,130.21 96.73,130.07 96.45,130.07 96.31,130.21 96.31,130.74 96.17,130.88 95.89,130.88 95.75,130.74 95.75,130.38 95.62,130.25 95.33,130.25 95.19,130.39 95.19,130.74 95.05,130.88 94.77,130.88 94.63,130.74 94.63,130.19 94.49,130.05 94.21,130.05 94.07,130.18 94.07,130.74 93.93,130.88 93.65,130.88 93.51,130.74 93.51,130.42 93.37,130.28 93.09,130.28 92.96,130.41 92.96,131.45 92.82,131.59 92.27,131.59 91.69,131.01 91.69,127.9 91.55,127.76 91.16,127.76 91.02,127.62 91.02,127.06 90.88,126.92 90.6,126.92 90.46,127.06 90.46,127.62 90.32,127.76 89.88,127.76 89.62,127.5 89.62,126.94 90.13,126.43 92.16,126.43 92.29,126.56 92.29,127.58 92.47,127.76 92.93,127.76 93.15,127.54 93.15,127.21 92.86,126.92 92.86,126.62 93.02,126.46 93.29,126.46 93.6,126.77 93.77,126.77 93.98,126.56 93.98,126.33 93.61,125.96 93.61,125.78 93.78,125.61 95.64,125.61 96.59,124.65 96.91,124.65 97.17,124.91 97.47,124.91 97.73,124.65 98.03,124.65 98.29,124.91 98.59,124.91 98.85,124.65 99.15,124.65 99.41,124.91 99.71,124.91 99.97,124.65 100.48,124.65 100.86,125.03 101.96,125.03 102.18,124.81 102.18,123.77 102.41,123.55 102.41,120.99 102.48,120.91 102.48,116.53 102.85,116.16 102.85,115.77 102.48,115.4 102.48,115.06 102.75,114.8 102.75,114.3 102.48,114.04 102.48,111.35 102.11,110.97
RLD3_C3_72B_DQ31: length 143.2
  TOP w0.152: U141.L4 v2(90.23,112.32) ; U1.B36 v2(96.24,78.84)
  14_SIG4 w0.089: v2(96.24,78.84) 95.94,78.84 95.44,79.34 95.03,79.34 94.49,79.88 94.49,81.8 95.03,82.34 95.44,82.34 95.74,82.64 95.74,83.05 96.03,83.34 96.44,83.34 96.74,83.64 96.74,84.05 97.03,84.34 97.44,84.34 97.74,84.64 97.74,85.05 98.03,85.34 98.44,85.34 98.74,85.64 98.74,86.15 98.91,86.33 99.49,86.33 99.76,86.6 99.76,88.18 99.57,88.37 98.91,88.37 98.74,88.54 98.74,89.01 99.04,89.32 99.66,89.32 ; v2(90.23,112.32) 90.23,112.67 90.13,112.78 89.89,112.78 89.73,112.62 89.73,112.1 90.01,111.82 91.43,111.82 91.73,111.53 91.73,110.11 92.01,109.82 92.54,109.82 93.9,108.46
  14_SIG4 w0.14: 93.9,108.46 94.61,107.75 96.5,107.75 97.03,107.22 97.65,107.22 98.05,107.62 98.76,107.62 99.01,107.37 99.01,106.84 99.32,106.53 102.02,106.53 105.94,110.45 105.94,117.41 105.99,117.46 105.99,121.6 104.81,122.77 104.81,123.96 104.53,124.24 104.53,124.79 103.58,125.74 103.58,125.95 104.01,126.38 104.01,126.8 104.57,127.36 105.16,127.36 105.24,127.27 105.24,127.06 105.05,126.87 105.05,126.62 105.22,126.45 105.5,126.45 105.68,126.63 105.88,126.63 106.09,126.42 106.09,126.22 105.92,126.05 105.92,125.85 106.12,125.66 106.32,125.66 106.49,125.83 106.68,125.83 106.88,125.63 106.88,124.64 107.25,124.27 107.45,124.27 107.74,124.56 107.94,124.56 108.13,124.36 108.13,124.16 107.85,123.87 107.85,123.68 108.04,123.48 108.24,123.48 108.53,123.77 108.73,123.77 108.92,123.57 108.92,123.37 108.64,123.08 108.64,122.89 108.85,122.67 108.85,121.94 109.02,121.76 109.29,121.76 109.74,122.21 109.94,122.21 110.21,121.94 110.21,121.32 110.02,121.13 109.02,121.13 108.83,120.94 108.83,120.56 109.02,120.37 110.02,120.37 110.21,120.18 110.21,119.8 110.02,119.61 108.87,119.61 108.68,119.42 108.68,119.04 108.87,118.85 110.02,118.85 110.21,118.66 110.21,118.28 110.02,118.09 108.83,118.09 108.68,117.94 108.68,117.56 108.91,117.33 110.02,117.33 110.21,117.14 110.21,116.75 110.02,116.56 108.83,116.56 108.65,116.39 108.65,116.01 108.86,115.8 110.02,115.8 110.21,115.61 110.21,115.23 110.02,115.04 108.87,115.04 108.68,114.84 108.68,114.46 108.86,114.28 109.19,114.28 109.38,114.08 109.38,113.7 109.2,113.52 107.85,113.52 107.63,113.3 107.63,112.99 107.78,112.84 108.73,112.84 108.87,112.71 108.87,112.4 108.73,112.26 108.4,112.26 108.26,112.13 108.26,111.32 108.39,111.18 108.68,111.18 108.78,111.07 108.78,110.69 106.28,108.19 106.28,107.74 106.69,107.33 106.69,106.79 102.8,102.89 102,102.89 101.66,102.56 101.44,102.34 100.64,102.34 100.35,102.05 100.35,101.52 99.94,101.11 99.48,101.11 99.29,100.92 99.29,100.57 99.1,100.38 98.72,100.38 98.53,100.57 98.53,101.12 98.4,101.24 97.18,101.24 96.79,100.85 96.79,100.68 97.08,100.39 98.04,100.39 98.25,100.17 98.25,99.94 98.07,99.75 96.83,99.75 96.68,99.91 96.28,99.91 96.14,99.77 96.14,99.2 96.44,98.89 97.23,98.89 97.38,98.75 97.38,98.52 97.21,98.34 97.21,98.12 97.43,97.9 97.7,97.9 97.97,98.16 98.2,98.16 98.37,98 98.37,97.76 98.21,97.6 98.21,97.37 98.39,97.19 98.66,97.19 99.58,98.1 100.9,98.1 101.41,97.59 102.57,97.59 103.02,97.14 103.02,96.35 103.93,95.44 103.93,94.78 102.74,93.59 102.74,91.97 102.47,91.71 102.04,91.71 99.66,89.32
RLD3_C3_72B_DQ32: length 143.3
  TOP w0.152: U141.L2 v2(88.23,112.32) ; U1.B37 v2(96.24,79.84)
  14_SIG4 w0.089: 101.74,89.16 101.74,86.64 101.44,86.34 101.03,86.34 100.74,86.05 100.74,85.64 100.44,85.34 100.03,85.34 99.74,85.05 99.74,84.64 99.44,84.34 99.03,84.34 98.74,84.05 98.74,83.64 98.44,83.34 98.03,83.34 97.74,83.05 97.74,82.64 97.44,82.34 97.03,82.34 96.74,82.05 96.74,81.64 96.44,81.34 96.03,81.34 95.74,81.05 95.74,80.64 96.24,80.14 v2(96.24,79.84) ; v2(88.23,112.32) 88.23,112.6 87.73,113.09 87.73,114.63 87.93,114.83 88.58,114.83 88.72,114.68 88.72,112.93 88.83,112.82 89.43,112.82 89.73,113.11 89.73,113.55 90,113.83 90.44,113.83 90.73,113.54 90.73,112.91 90.82,112.82 91.44,112.82 91.72,112.54 91.72,112.06 91.96,111.82 92.43,111.82 92.73,111.53 92.73,111.12 93.02,110.82 93.49,110.82 93.95,110.36 93.95,109.89 95.04,108.8
  14_SIG4 w0.14: 95.04,108.8 95.45,108.8 95.75,109.1 95.75,109.35 95.85,109.45 96.36,109.45 96.48,109.32 96.48,108.84 96.61,108.71 96.86,108.71 96.99,108.84 96.99,109.32 97.11,109.45 97.37,109.45 97.49,109.32 97.49,108.84 97.62,108.71 97.88,108.71 98,108.84 98,109.32 98.12,109.45 98.38,109.45 98.51,109.32 98.51,108.84 98.63,108.71 98.89,108.71 99.01,108.84 99.01,109.32 99.14,109.45 99.37,109.45 99.52,109.3 99.52,108.94 99.65,108.8 100.53,108.8 101.16,108.18 101.91,108.18 102.28,108.55 102.28,108.79 101.76,109.32 101.76,109.56 101.92,109.72 102.16,109.72 102.69,109.2 102.92,109.2 103.05,109.33 103.05,109.47 103.22,109.63 103.41,109.63 103.58,109.8 103.58,110.04 103.41,110.21 102.74,110.21 102.57,110.37 102.57,110.61 102.74,110.78 103.85,110.78 104.01,110.94 104.01,111.18 103.85,111.35 103.22,111.35 103.05,111.52 103.05,113.2 103.9,114.05 103.9,116.93 103.68,117.14 103.23,117.14 103.07,117.3 103.07,118.13 103.25,118.31 103.25,119.07 103.07,119.25 103.07,119.68 103.25,119.86 104.48,119.86 104.84,120.23 104.84,120.68 104.57,120.95 104.56,120.95 104.54,120.97 103.35,120.97 102.98,121.35 102.98,123.63 103.33,123.98 103.33,124.44 102.14,125.62 100.27,125.62 99.89,126 99.28,126 98.81,125.53 96.49,125.53 95.81,126.21 95.1,126.21 94.91,126.4 94.91,126.6 95.2,126.89 95.2,127.1 94.91,127.4 94.72,127.4 94.42,127.09 94.22,127.09 93.73,127.58 93.73,127.9 93.87,128.04 94.81,128.04 95.09,127.76 95.86,127.76 96.14,128.04 98.63,128.04 99.01,128.42 99.34,128.42 99.72,128.04 101.24,128.04 101.63,128.42 102.01,128.42 102.39,128.04 103.58,128.04 104.55,129.01 105.02,129.01 111.36,122.67 111.36,113.98 110.42,113.03 110.42,110.69 108.09,108.36 108.09,106.57 103.49,101.97 103.49,100.52 102.81,99.84 102.29,99.84 102,99.54 102,99.03 102.27,98.76 103.07,98.76 104.16,97.67 104.16,96.82 105.34,95.64 105.34,94.54 104,93.21 104,91.43 101.74,89.16
RLD3_C3_72B_DQ33: length 142.4
  TOP w0.152: U141.M5 v2(91.23,111.32) ; U1.B35 v2(96.24,77.84)
  14_SIG4 w0.089: 94.62,83.97 95.01,84.36 95.48,84.36 95.75,84.63 95.75,85.07 96.01,85.34 96.45,85.34 96.73,85.62 96.75,85.62 96.75,87.23 96.9,87.38 97.35,87.38 97.64,87.68 97.64,88.01 97.37,88.28 96.32,88.28 ; v2(91.23,111.32) 91.23,110.89 91.15,110.81 90.84,110.81 90.73,110.69 90.73,110.11 90.44,109.82 90.02,109.82 89.74,110.11 89.74,111.66 89.58,111.82 88.02,111.82 87.74,112.11 87.74,112.62 87.54,112.82 86.92,112.82 86.73,112.63 86.73,112 86.91,111.82 87.47,111.82 87.73,111.56 87.73,111.02 87.54,110.83 86.89,110.83 86.74,110.68 86.74,109.48 87.08,109.14 87.23,109.14 87.42,109.33 87.42,109.6 87.52,109.69 87.71,109.69 87.83,109.57 87.83,109.34 88.03,109.14 88.68,109.14 89.36,108.46 89.96,108.46 ; 94.72,76.34 96.5,76.34 96.73,76.57 96.73,77.03 96.44,77.32 95.8,77.32 95.74,77.39 95.74,77.7 95.88,77.84 v2(96.24,77.84)
  14_SIG4 w0.14: 96.32,88.28 96.05,88.56 96.05,89.2 96.16,89.31 96.34,89.31 96.45,89.21 96.45,89.06 96.56,88.95 96.72,88.95 96.82,89.06 96.82,89.21 96.93,89.31 97.65,89.31 97.75,89.41 97.75,89.79 97.62,89.91 96.31,89.91 96.22,90.01 96.22,90.26 96.37,90.41 96.74,90.41 96.95,90.63 96.95,92.73 97.12,92.9 97.61,92.9 97.71,92.81 97.71,90.68 97.88,90.52 98.11,90.52 98.35,90.76 98.35,92.73 98.52,92.9 98.76,92.9 98.92,92.73 98.92,91.69 99.06,91.55 99.3,91.55 99.5,91.75 99.5,92.73 99.66,92.9 99.9,92.9 100.07,92.73 100.07,91.96 100.24,91.79 100.47,91.79 100.64,91.96 100.64,92.73 100.81,92.9 101.34,92.9 101.51,93.07 101.51,93.3 101.34,93.47 97.12,93.47 96.95,93.64 96.95,93.87 97.12,94.04 101.34,94.04 101.51,94.21 101.51,94.45 101.34,94.61 97.12,94.61 96.95,94.78 96.95,95.02 97.12,95.19 101.34,95.19 101.51,95.35 101.51,95.59 101.34,95.76 97.12,95.76 96.95,95.92 96.95,96.57 94.97,98.55 94.97,100.28 94.78,100.47 94.46,100.47 94.25,100.68 94.25,101.06 94.43,101.24 94.96,101.24 95.1,101.38 95.1,102.2 94.88,102.42 94.06,102.42 93.92,102.56 93.92,103.1 94.01,103.2 94.7,103.2 94.91,103.4 94.91,103.79 94.77,103.93 93.81,103.93 93.63,104.1 93.63,104.51 93.79,104.67 95.28,104.67 95.42,104.53 95.42,103.91 95.62,103.71 96,103.71 96.18,103.88 96.18,104.56 96.38,104.76 96.76,104.76 96.94,104.58 96.94,103.42 97.17,103.19 97.55,103.19 97.7,103.34 97.7,104.54 97.89,104.73 98.27,104.73 98.46,104.54 98.46,103.14 98.66,102.95 99.04,102.95 99.23,103.13 99.23,104.53 99.42,104.73 99.8,104.73 99.99,104.54 99.99,103.72 100.19,103.52 100.57,103.52 100.75,103.69 100.75,104.52 100.96,104.73 101.34,104.73 101.51,104.56 101.51,104.25 101.7,104.05 102.08,104.05 102.27,104.25 102.27,104.38 102.46,104.57 102.86,104.57 104.46,106.17 104.46,106.46 104.15,106.76 103.87,106.76 102.49,105.38 94.93,105.38 94.47,105.85 94.25,105.85 94,105.61 93.81,105.61 93.43,105.98 93.43,106.16 93.58,106.31 93.58,106.59 93.31,106.87 92.44,106.87 92.27,106.7 92.27,106.61 92.1,106.44 91.87,106.44 91.7,106.61 91.7,106.7 91.53,106.87 91.16,106.87 90.83,107.2 90.83,107.59 89.96,108.46 ; 94.62,83.97 94.62,83.79 94.7,83.71 94.7,83.54 94.52,83.36 94.34,83.36 94.27,83.44 94.09,83.44 93.61,82.96 93.61,78.96 93.78,78.8 94.12,78.8 94.27,78.65 94.27,78.36 94.15,78.23 93.78,78.23 93.65,78.1 93.65,77.85 93.78,77.73 94.15,77.73 94.27,77.61 94.27,77.36 94.14,77.23 93.78,77.23 93.67,77.12 93.67,76.5 93.83,76.34 94.04,76.34 94.14,76.24 94.14,76.05 94.28,75.92 94.53,75.92 94.62,76 94.62,76.24 94.72,76.34
RLD3_C3_72B_DQ34: length 142.4
  TOP w0.152: U141.M3 v2(89.23,111.32) ; U1.A36 v2(95.24,78.84)
  14_SIG4 w0.089: 94.67,83.07 94.91,83.31 95.51,83.31 95.76,83.56 95.76,84.2 95.92,84.35 96.44,84.35 96.74,84.66 96.74,85.14 96.96,85.35 97.56,85.35 97.73,85.52 97.73,86.18 97.89,86.34 98.48,86.34 98.75,86.62 98.75,88.08 98.5,88.33 97.9,88.33 97.73,88.49 97.73,89 98.12,89.38 98.3,89.38 ; 91.03,108.46 91.03,108.66 91.16,108.79 91.64,108.79 91.73,108.88 91.73,109.53 91.44,109.82 90.86,109.82 90.73,109.69 90.73,108.94 90.58,108.79 90.02,108.79 89.73,109.07 89.73,109.7 89.61,109.82 88.01,109.82 87.73,110.1 87.73,110.55 88.02,110.84 88.99,110.84 89.23,111.07 v2(89.23,111.32)
  14_SIG4 w0.14: v2(95.24,78.84) 94.79,78.84 94.14,79.5 94.14,82.54 94.25,82.65 94.41,82.65 94.56,82.51 94.71,82.51 94.82,82.61 94.82,82.77 94.67,82.92 94.67,83.07 ; 91.03,108.46 91.03,108.23 91.29,107.98 92.12,107.98 92.31,108.17 92.31,108.72 92.43,108.84 92.91,108.84 93.07,108.67 93.07,108.17 93.26,107.98 93.57,107.98 93.88,107.66 93.88,107.16 94.5,106.55 94.93,106.55 95.01,106.46 95.01,106.14 95.18,105.97 95.42,105.97 95.58,106.14 95.58,106.46 95.75,106.63 95.99,106.63 96.16,106.46 96.16,106.14 96.32,105.97 96.56,105.97 96.73,106.14 96.73,106.46 96.89,106.63 97.13,106.63 97.3,106.46 97.3,106.14 97.47,105.97 97.7,105.97 97.87,106.14 97.87,106.46 98.04,106.63 98.4,106.63 98.61,106.42 98.61,106.09 98.75,105.96 102.26,105.96 106.52,110.22 106.52,117.18 106.86,117.52 107.23,117.52 107.42,117.71 107.42,118.1 107.23,118.29 106.86,118.29 106.67,118.48 106.67,119.02 106.88,119.23 107.23,119.23 107.42,119.42 107.42,119.62 107.23,119.81 106.86,119.81 106.67,120 106.67,121.72 105.39,123.01 105.39,124.24 105.11,124.52 105.11,125.02 104.58,125.55 104.58,125.75 104.73,125.89 105.09,125.89 105.93,125.05 105.93,124.85 106.15,124.64 106.15,123.32 106.78,122.68 108.03,122.68 108.23,122.48 108.23,122.1 108.14,122.01 107.51,122.01 107.37,121.87 107.37,121.59 107.51,121.45 107.94,121.45 108.08,121.31 108.08,121.03 107.94,120.89 107.51,120.89 107.37,120.75 107.37,120.47 107.51,120.33 107.94,120.33 108.08,120.19 108.08,115.66 107.79,115.37 107.27,115.37 107.11,115.2 107.11,114.97 107.27,114.8 107.92,114.8 108.08,114.64 108.08,114.42 107.84,114.18 107.34,114.18 107.11,113.95 107.11,112.46 107.66,111.9 107.66,110.41 105.36,108.11 105.36,107.75 105.99,107.12 105.99,106.9 105.83,106.74 105.64,106.74 105.45,106.93 105.21,106.93 105.04,106.76 105.04,106.52 105.23,106.33 105.23,106.14 102.56,103.47 101.76,103.47 101.21,102.91 100.38,102.91 99.84,102.37 97.18,102.37 96.43,103.13 95.9,103.13 95.77,102.99 95.77,102.69 96.24,102.21 96.24,101.03 96.08,100.86 95.77,100.86 95.55,100.64 95.55,98.95 97.89,96.61 98.9,96.61 99.3,97.02 99.46,97.02 99.62,96.85 99.62,96.54 99.79,96.37 100.03,96.37 100.2,96.54 100.2,97.32 100.38,97.51 100.62,97.51 100.77,97.36 100.77,96.54 100.93,96.37 101.17,96.37 101.34,96.54 101.34,96.85 101.51,97.02 102.33,97.02 102.45,96.91 102.45,96.11 103.36,95.2 103.36,95.02 103.02,94.68 102.78,94.68 102.4,95.06 102.24,95.06 102.07,94.89 102.07,94.58 102.37,94.27 102.37,94.04 102.16,93.82 102.16,92.63 101.94,92.41 101.64,92.41 101.38,92.15 101.38,91.85 100.72,91.19 100.72,90.95 100.6,90.83 100.44,90.83 99.97,91.3 99.82,91.3 99.71,91.19 99.71,91.03 100.18,90.56 100.18,90.41 100.06,90.29 99.89,90.29 99.19,90.99 99.02,90.99 98.84,90.81 98.84,90.64 99.54,89.94 99.54,89.76 99.36,89.59 99.18,89.59 98.53,90.24 98.35,90.24 98.17,90.07 98.17,89.89 98.4,89.67 98.4,89.49 98.3,89.38
RLD3_C3_72B_DQ35: length 144
  TOP w0.152: U1.A34 v2(95.24,76.84) ; U141.N6 v2(92.23,110.32)
  14_SIG4 w0.089: v2(95.24,76.84) 95.06,76.67 94.7,76.67 94.61,76.76 94.61,78.24 94.71,78.34 96.64,78.34 96.74,78.44 96.74,79.25 96.65,79.34 95.87,79.34 95.74,79.47 95.74,80.22 95.61,80.34 95.03,80.34 94.74,80.64 94.74,81.05 95.03,81.34 95.44,81.34 95.74,81.64 95.74,82.05 96.03,82.34 96.44,82.34 96.74,82.64 96.74,83.07 97.01,83.34 97.44,83.34 97.74,83.64 97.74,84.05 98.03,84.34 98.44,84.34 98.74,84.64 98.74,85.05 99.03,85.34 99.44,85.34 99.74,85.64 99.74,86.05 100.03,86.34 100.44,86.34 100.74,86.64 100.74,89.06 ; v2(92.23,110.32) 92.5,110.32 93.04,109.77 93.58,109.77 95.02,108.33 96.9,108.33
  14_SIG4 w0.14: 96.9,108.33 97.03,108.21 99.95,108.21 101.05,107.1 101.78,107.1 104.62,109.94 104.62,111.23 104.79,111.4 105.19,111.4 105.36,111.57 105.36,111.81 105.19,111.97 103.8,111.97 103.66,112.12 103.66,112.35 103.85,112.55 105.19,112.55 105.36,112.71 105.36,112.95 105.19,113.12 104.79,113.12 104.62,113.28 104.62,113.52 104.79,113.69 105.19,113.69 105.36,113.86 105.36,114.09 105.19,114.26 104.79,114.26 104.62,114.43 104.62,114.66 104.79,114.83 105.19,114.83 105.36,115 105.36,115.24 105.19,115.4 104.79,115.4 104.62,115.57 104.62,115.81 104.79,115.97 105.19,115.97 105.36,116.14 105.36,116.38 105.19,116.55 104.79,116.55 104.62,116.71 104.62,116.95 104.79,117.12 105.19,117.12 105.36,117.28 105.36,117.52 105.19,117.69 104.79,117.69 104.62,117.86 104.62,118.09 104.79,118.26 105.19,118.26 105.36,118.43 105.36,118.66 105.19,118.83 104.79,118.83 104.62,119 104.62,119.15 104.93,119.46 105.22,119.46 105.42,119.65 105.42,121.28 105.1,121.59 104.41,121.59 104.19,121.81 104.19,123.34 103.96,123.57 103.96,124.55 103.42,125.1 103.42,125.1 102.32,126.2 100.49,126.2 100.16,126.53 99.07,126.53 98.59,126.05 97.86,126.05 96.9,127 96.9,127.36 97.01,127.46 97.78,127.46 97.95,127.3 97.95,126.88 98.11,126.72 98.38,126.72 98.51,126.85 98.51,127.35 98.64,127.49 99.39,127.49 99.53,127.35 99.53,127.17 99.67,127.03 99.95,127.03 100.09,127.17 100.09,127.35 100.23,127.49 100.51,127.49 100.65,127.35 100.65,126.89 100.79,126.75 101.04,126.75 101.21,126.91 101.21,127.35 101.35,127.49 101.63,127.49 101.77,127.35 101.77,126.89 101.91,126.75 102.16,126.75 102.33,126.91 102.33,127.35 102.47,127.49 102.74,127.49 102.88,127.35 102.88,126.63 103.02,126.49 103.23,126.49 103.44,126.71 103.44,126.96 104.52,128.04 105.21,128.04 110.79,122.46 110.79,114.27 109.4,112.88 109.4,110.49 107.08,108.18 107.08,107.81 107.5,107.39 107.5,106.78 103.03,102.32 102.23,102.32 101.99,102.08 101.99,101.43 102.24,101.19 102.59,101.19 102.78,101 102.78,100.62 102.59,100.43 101.84,100.43 101.21,99.8 100.9,99.8 100.73,99.96 100.73,100.47 100.56,100.64 100.32,100.64 100.16,100.47 100.16,99.96 99.99,99.8 99.17,99.8 98.98,99.61 98.98,99.29 98.6,98.9 98.6,98.7 98.89,98.41 99.03,98.41 99.3,98.68 101.22,98.68 101.74,98.16 102.81,98.16 103.59,97.38 103.59,96.58 104.5,95.67 104.5,94.54 103.31,93.35 103.31,91.74 101.81,90.24 101.81,89.73 101.53,89.45 101.35,89.45 100.91,89.89 100.73,89.89 100.47,89.63 100.47,89.33 100.74,89.06
RLD3_C3_72B_DQ36: length 124
  TOP w0.152: U1.T24 v2(110.24,66.84) ; U142.D11 v2(79.32,112.17)
  14_SIG4 w0.089: 94.39,64.68 95.11,65.41 100.53,65.41 100.74,65.2 100.74,64.64 101.04,64.34 107.44,64.34 107.74,64.64 107.74,65.45 108.74,66.45 108.74,67.05 109.03,67.34 109.74,67.34 v2(110.24,66.84) ; 77.8,108.81 77.82,108.84 77.82,110.37 78.12,110.66 78.53,110.66 78.82,110.96 78.82,112.03 78.96,112.17 v2(79.32,112.17)
  14_SIG4 w0.14: 77.8,108.81 77.8,108.81 76.34,107.35 75.34,107.35 75.17,107.19 75.17,104.89 75.46,104.6 75.98,104.6 76.16,104.42 76.16,103.49 75.92,103.25 75.54,103.25 75.31,103.02 75.31,102.44 75.86,101.89 76.23,101.89 76.23,101.89 77.1,101.89 77.77,101.21 77.77,100.05 78.1,99.72 81.47,99.72 82.17,99.02 82.17,95.66 81.64,95.12 78.68,95.12 78.49,94.93 78.49,94.68 78.3,94.49 77.92,94.49 77.73,94.68 77.73,94.93 77.54,95.12 77.16,95.12 76.97,94.93 76.97,94.68 76.78,94.49 76.4,94.49 76.21,94.68 76.21,94.93 76.02,95.12 75.11,95.12 74.3,94.31 74.3,91.01 72.75,89.46 69.49,89.46 69.11,89.08 69.11,88.3 69.3,88.11 69.92,88.11 70.11,87.91 70.11,87.53 69.92,87.34 69.3,87.34 69.11,87.15 69.11,85.88 69.37,85.62 71.5,85.62 71.93,85.2 71.93,81.16 72.21,80.87 73.58,80.87 74.33,80.13 74.33,76.99 73.3,75.97 69.52,75.97 69.27,75.72 69.27,73.38 69.56,73.09 71.31,73.09 72.9,71.5 81.76,71.5 82.24,71.03 82.24,67.96 82.56,67.63 83.26,67.63 84.25,66.65 84.25,65.67 84.76,65.15 85.69,65.15 87.41,63.43 89.79,63.43 90.97,64.62 94.33,64.62 94.39,64.68
RLD3_C3_72B_DQ37: length 123.5
  TOP w0.152: U142.E10 v2(78.32,113.17) ; U1.R24 v2(109.24,66.84)
  14_SIG4 w0.089: v2(78.32,113.17) 78.32,112.87 77.82,112.37 77.82,111.37 77.82,111.37 77.82,110.96 77.53,110.67 77.12,110.67 76.82,110.37 76.82,109.96 76.82,108.82 76.82,108.81 ; v2(109.24,66.84) 109.24,65.88 108.74,65.38 108.74,64.64 108.44,64.34 108.01,64.34 107.72,64.06 107.74,64.05 107.74,63.64 107.44,63.34 101,63.34 100.74,63.6 100.74,64.06 100.46,64.34 94.82,64.34 94.39,63.91
  14_SIG4 w0.14: 76.82,108.81 75.92,107.92 75.1,107.92 74.6,107.42 74.6,107.4 74.59,107.39 74.59,101.84 75.35,101.08 76.59,101.08 77.06,100.61 77.06,99.54 77.5,99.11 81.28,99.11 81.59,98.81 81.59,96.05 81.32,95.78 74.85,95.78 73.74,94.67 73.74,91.34 72.47,90.07 68.86,90.07 68.45,89.66 68.45,85.6 68.96,85.09 70.99,85.09 71.3,84.79 71.3,81.79 71.11,81.6 70.67,81.6 70.48,81.41 70.48,81.03 70.67,80.84 71.11,80.84 71.3,80.65 71.3,80.45 71.46,80.29 73.41,80.29 73.61,80.09 73.61,77.17 73.13,76.68 68.78,76.68 68.45,76.35 68.45,72.34 68.91,71.88 71.48,71.88 72.49,70.87 81.34,70.87 81.59,70.61 81.59,67.51 82.63,66.47 83.18,66.47 83.54,66.12 83.54,64.64 84.26,63.92 85.93,63.92 87.12,62.73 90.24,62.73 91.41,63.91 94.39,63.91
RLD3_C3_72B_DQ38: length 120.2
  TOP w0.152: U1.R27 109.74,69.34 v2(109.24,69.84) ; U142.C8 v2(80.32,115.17)
  14_SIG4 w0.089: 83.59,115.66 80.81,115.66 v2(80.32,115.17) ; 94.39,71.28 94.44,71.34 101.49,71.34 101.74,71.09 101.74,70.64 102.03,70.34 102.51,70.34 102.73,70.12 102.73,69.58 102.97,69.34 104.41,69.34 104.74,69.67 104.74,70.02 105.08,70.36 105.44,70.36 105.44,70.37 105.47,70.37 105.73,70.62 105.73,71.04 106.05,71.36 108.56,71.36 108.72,71.52 108.72,72.04 109.02,72.35 112.42,72.35 112.71,72.05 112.71,72.04 112.72,72.04 112.72,71.65 113.04,71.33 115.51,71.33 115.72,71.12 115.72,70.48 115.57,70.33 114.86,70.33 114.75,70.21 114.75,69.51 114.91,69.35 115.57,69.35 115.72,69.2 115.72,68.47 115.59,68.34 114.98,68.34 114.75,68.1 114.75,67.5 114.92,67.33 115.53,67.33 115.72,67.15 115.72,66.54 115.54,66.36 114.27,66.36 114.16,66.25 114.16,65.42 114.26,65.32 114.72,65.32 114.85,65.44 114.85,65.83 114.96,65.94 115.11,65.94 115.22,65.83 115.22,65.54 115.34,65.42 115.55,65.42 115.72,65.25 115.72,61.55 115.52,61.35 113.89,61.35 113.72,61.52 113.72,65.67 113.59,65.8 113.11,65.8 113.01,65.9 113.01,66.15 113.15,66.29 113.59,66.29 113.74,66.45 113.74,70.18 113.6,70.33 112.91,70.33 112.76,70.48 112.76,71.02 112.45,71.33 109.99,71.33 109.73,71.07 109.73,70.63 109.24,70.14 v2(109.24,69.84)
  14_SIG4 w0.14: 83.59,115.66 83.99,115.66 84.35,115.29 84.35,109.12 84.63,108.84 84.63,108.31 89.84,103.1 89.84,101.47 90.66,100.66 90.66,100.34 89.89,99.57 89.89,98.81 92.33,96.37 92.33,93.63 89.69,90.99 89.69,71.86 90.06,71.49 90.37,71.49 91.51,70.34 93.44,70.34 94.39,71.28
RLD3_C3_72B_DQ39: length 120.1
  TOP w0.152: v2(108.24,69.84) 108.74,69.34 U1.P27 ; U142.C10 v2(80.32,113.17)
  14_SIG4 w0.089: v2(80.32,113.17) 80.73,113.17 80.84,113.28 80.84,113.49 81.02,113.67 81.66,113.67 81.81,113.52 81.81,112.79 81.94,112.67 82.7,112.67 82.82,112.54 82.82,108.81 ; v2(108.24,69.84) 107.78,69.84 107.71,69.91 107.71,70.28 107.8,70.36 108.65,70.36 108.76,70.25 108.76,69.5 108.6,69.34 105.86,69.34 105.74,69.22 105.74,68.57 105.51,68.34 104.97,68.34 104.74,68.11 104.74,67.55 104.53,67.34 102.97,67.34 102.72,67.6 102.72,68.1 102.46,68.35 101.96,68.35 101.73,68.58 101.73,69.09 101.47,69.34 94.39,69.34
  14_SIG4 w0.14: 82.82,108.81 82.82,108.4 82.63,108.21 82.54,108.21 82.35,108.02 82.35,107.67 82.57,107.45 82.57,107.45 82.63,107.45 82.82,107.26 82.82,106.54 82.96,106.41 83.14,106.41 83.5,106.77 83.77,106.77 84.04,106.5 84.04,106.23 83.54,105.72 83.54,105.45 83.79,105.2 84.09,105.2 84.58,105.69 84.85,105.69 85.12,105.42 85.12,105.15 84.94,104.97 84.94,104.7 85.21,104.43 85.48,104.43 85.66,104.61 85.93,104.61 86.16,104.37 86.16,103.96 86.35,103.77 86.51,103.77 86.7,103.58 86.7,103.2 86.51,103.01 86.35,103.01 86.16,102.82 86.16,102.25 86.29,102.12 87.21,102.12 87.41,101.93 87.41,101.56 87.21,101.36 86.25,101.36 86.16,101.27 86.16,101.06 86.79,100.43 86.79,99.89 86.61,99.71 86.02,99.71 85.86,99.55 85.86,99.1 86.16,98.81 86.55,98.81 87.55,97.82 87.55,97.45 87.36,97.26 87.11,97.26 86.32,98.05 85.97,98.05 85.87,97.95 85.87,97.34 86.01,97.19 86.36,97.19 86.55,97 86.55,96.63 86.35,96.43 86.03,96.43 85.86,96.27 85.86,95.59 86.2,95.26 86.2,94.82 85.86,94.49 85.86,94.11 86.08,93.89 86.76,93.89 87.49,93.16 87.49,91.87 87.65,91.7 88,91.7 88.16,91.53 88.16,91.3 88,91.13 87.65,91.13 87.49,90.96 87.49,86.44 87.25,86.21 86.11,86.21 85.9,86 85.9,85.47 86.07,85.31 87.53,85.31 87.71,85.12 87.71,84.89 87.56,84.73 86.07,84.73 85.9,84.57 85.9,84.33 86.07,84.16 87.53,84.16 87.72,83.96 87.72,83.73 87.59,83.59 86.07,83.59 85.9,83.42 85.9,83.19 86.07,83.02 87.52,83.02 87.68,82.85 87.68,82.62 87.52,82.45 86.07,82.45 85.9,82.28 85.9,82.04 86.07,81.88 87.41,81.88 87.59,81.7 87.59,81.46 87.43,81.31 86.07,81.31 85.9,81.14 85.9,80.9 86.07,80.73 87.42,80.73 87.58,80.57 87.58,80.34 87.41,80.16 86.07,80.16 85.9,79.99 85.9,79.71 86.07,79.54 87.03,79.54 87.21,79.37 87.21,79.13 87.05,78.97 85.92,78.97 85.76,78.8 85.76,78.57 85.92,78.4 87.05,78.4 87.21,78.23 87.21,78 87.05,77.83 86.07,77.83 85.9,77.66 85.9,77.43 86.07,77.26 87.04,77.26 87.2,77.1 87.2,76.08 87.06,75.93 86.66,75.93 86.57,76.02 86.57,76.54 86.43,76.69 86.07,76.69 85.9,76.52 85.9,75.84 86.46,75.29 86.46,74.14 86.94,73.66 87.84,73.66 88.04,73.46 88.04,72.7 87.85,72.51 87.6,72.51 87.41,72.32 87.41,71.91 87.59,71.72 88.01,71.72 88.2,71.53 88.2,71.15 88.01,70.96 87.5,70.96 87.32,70.77 87.32,70.48 87.51,70.28 89.87,70.28 91.81,68.35 93.31,68.35 94.31,69.34 94.39,69.34
RLD3_C3_72B_DQ40: length 121.5
  TOP w0.152: U1.P25 108.74,67.34 v2(108.24,67.84) ; U142.C12 v2(80.32,111.17)
  14_SIG4 w0.089: 94.39,66.34 101.27,66.34 101.88,65.74 105.84,65.74 106.74,66.64 106.74,67.06 107.02,67.34 107.45,67.34 107.95,67.84 v2(108.24,67.84) ; 78.94,108.81 78.8,108.95 78.8,109.36 79.11,109.67 79.54,109.67 79.82,109.95 79.82,110.37 80.32,110.87 v2(80.32,111.17)
  14_SIG4 w0.14: 94.39,66.34 94.27,66.34 94.03,66.1 91.42,66.1 89.34,68.19 86.88,68.19 86.3,67.61 85.11,67.61 84.28,68.44 84.28,73.02 82.64,74.66 82.03,74.66 80.22,72.85 79.23,72.85 79.04,73.04 79.04,74.46 78.85,74.65 78.47,74.65 78.28,74.46 78.28,73.04 78.09,72.85 77.71,72.85 77.52,73.04 77.52,74.46 77.33,74.65 76.95,74.65 76.76,74.46 76.76,73.04 76.56,72.85 76.14,72.85 75.93,73.06 75.93,74.95 77.05,76.07 79.77,76.07 79.96,75.88 79.96,74.67 80.15,74.48 80.53,74.48 80.72,74.67 80.72,75.88 80.91,76.07 81.97,76.07 82.35,76.45 82.35,84.99 81.66,85.67 74.29,85.67 73.74,86.22 73.74,88.83 74.9,89.99 81.41,89.99 82.14,90.73 82.14,93.32 82.22,93.39 82.22,93.79 83.69,95.27 83.69,99.47 82.9,100.26 82.9,101.11 82.14,101.88 81.4,101.88 81.21,102.07 81.21,103.17 80.99,103.39 80.64,103.39 80.45,103.2 80.45,102.07 80.26,101.88 79.32,101.88 79.06,102.13 79.06,104.24 79.28,104.45 80.03,104.45 80.27,104.69 80.27,104.94 80.07,105.14 79.11,105.14 78.89,105.36 78.89,105.6 78.7,105.79 78.39,105.79 78.2,105.98 78.2,106.36 78.39,106.55 78.7,106.55 78.89,106.74 78.89,107.88 79.08,108.07 79.08,108.68 78.94,108.81
