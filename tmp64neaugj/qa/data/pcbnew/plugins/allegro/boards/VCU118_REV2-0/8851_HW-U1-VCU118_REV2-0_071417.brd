# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_C2_DQS2_T: length 46.3
  TOP w0.145: U1.AU29 131.74,71.34 v2(132.24,71.84) ; U136.G3 v4(159.56,61.66)
  05_SIG2 w0.107: 142.64,64.1 142.63,64.1
  05_SIG2 w0.127: v2(132.24,71.84) 132.74,72.35 132.84,72.45 133.49,72.45 133.84,72.09 133.84,71.68 134.08,71.45 134.49,71.45 134.84,71.09 134.84,70.68 135.08,70.45 135.49,70.45 135.84,70.09 135.84,69.68 136.07,69.45 136.48,69.45 136.84,69.09 136.84,68.68 137.08,68.45 137.49,68.45 137.84,68.09 137.84,67.68 138.07,67.45 138.48,67.45 138.84,67.09 138.84,66.48 139.7,65.62 140.39,65.62 140.84,65.17 140.84,64.68 141.07,64.45 142.24,64.45 142.59,64.1 142.63,64.1
  05_SIG2 w0.178: 153.75,60 153.99,60.24 153.99,61.94 154.45,62.4 159.05,62.4 159.31,62.14 159.31,61.9 v4(159.56,61.66) ; 142.84,63.89 142.64,64.1
  05_SIG2 w0.208: 153.75,60 153.73,59.98 152.48,59.98 152.12,59.62 152.12,57.52 151.97,57.36 151.71,57.36 151.5,57.57 151.5,59.68 151.19,59.98 149.95,59.98 149.64,59.68 149.64,58.27 149.51,58.13 149.02,58.13 148.77,58.38 148.77,60.08 148.48,60.37 146.37,60.37 142.84,63.89
DDR4_C2_DQS3_C: length 61.3
  TOP w0.145: U136.A7 v4(154.76,64.06) ; v2(129.24,74.84) U1.AP32
  03_SIG1 w0.127: 142.63,76.5 142.58,76.45 132.99,76.45 132.63,76.09 132.63,75.68 132.4,75.45 130.98,75.45 130.63,75.1 130.63,74.65 130.43,74.45 129.36,74.45 129.24,74.58 v2(129.24,74.84)
  03_SIG1 w0.178: v4(154.76,64.06) 154.84,64.14 155.04,64.14 155.13,64.05 155.13,63.83 154.89,63.59 154.54,63.59 154.35,63.78 154.35,64.5 153.97,64.88
  03_SIG1 w0.208: 142.63,76.5 143.26,76.5 143.44,76.68 143.44,76.87 143.28,77.03 142.97,77.03 142.65,77.35 142.65,78.19 142.92,78.46 144.25,78.46 144.63,78.08 144.63,75.64 144.77,75.49 145.07,75.49 145.21,75.63 145.21,78 145.49,78.28 146.05,78.28 146.41,77.93 146.41,75.54 146.51,75.44 146.98,75.44 147.42,75.87 147.42,77.95 147.74,78.27 148.42,78.27 148.77,77.93 148.77,75.4 147.23,73.86 145.06,73.86 144.86,73.66 144.86,73.37 145,73.23 147.15,73.23 147.47,72.91 147.47,69.63 147.62,69.48 150.52,69.48 152.95,67.05 152.95,65.89 153.97,64.88
DDR4_C2_DQS3_T: length 61.4
  TOP w0.145: v4(155.56,64.06) U136.B7 ; v2(129.24,73.84) U1.AP31
  03_SIG1 w0.127: v2(129.24,73.84) 129.24,74.07 129.4,74.24 130.51,74.24 130.84,74.57 130.84,75.01 131.07,75.24 132.48,75.24 132.84,75.6 132.84,76.01 133.08,76.24 142.58,76.24 142.63,76.19
  03_SIG1 w0.178: 153.97,64.45 154.04,64.37 154.04,63.66 154.42,63.29 155.01,63.29 155.43,63.7 155.43,63.93 v4(155.56,64.06)
  03_SIG1 w0.208: 153.97,64.45 153.75,64.66 152.65,65.77 152.65,66.92 150.39,69.17 147.5,69.17 147.17,69.5 147.17,72.78 147.03,72.92 144.88,72.92 144.56,73.24 144.56,73.79 144.93,74.17 147.11,74.17 148.46,75.52 148.46,77.8 148.3,77.97 147.87,77.97 147.72,77.82 147.72,75.75 147.11,75.13 146.38,75.13 146.1,75.41 146.1,77.8 145.92,77.98 145.62,77.98 145.52,77.88 145.52,75.51 145.2,75.19 144.64,75.19 144.32,75.51 144.32,77.95 144.12,78.16 143.05,78.16 142.95,78.06 142.95,77.47 143.09,77.33 143.41,77.33 143.74,77 143.74,76.55 143.38,76.19 142.63,76.19
DDR4_C2_DQS4_C: length 42.7
  TOP w0.145: v2(141.24,77.84) U1.BF35 ; v4(158.76,75.75) U137.F3
  07_SIG3 w0.127: v2(141.24,77.84) 140.97,77.84 140.84,77.97 140.84,78.15 140.93,78.24 141.44,78.24 141.96,77.72 142.53,77.72 142.55,77.7
  07_SIG3 w0.178: 154.18,76.02 154.33,76.17 158.84,76.17 159.01,75.99 159.01,75.84 158.93,75.75 v4(158.76,75.75) ; 142.63,77.7 142.55,77.7
  07_SIG3 w0.208: 142.63,77.7 143.05,77.7 143.68,77.06 146.81,77.06 150.21,73.66 150.95,73.66 152.08,72.52 152.08,71.55 153.55,70.08 159.85,70.08 160.23,70.46 160.23,71.22 159.92,71.53 157.12,71.53 156.91,71.74 156.91,72.04 156.7,72.25 156.29,72.25 156.08,72.04 156.08,71.74 155.87,71.53 155.34,71.53 153.96,72.91 153.96,75.8 154.18,76.02
DDR4_C2_DQS4_T: length 42.6
  TOP w0.145: U137.G3 v4(159.56,75.75) ; v2(140.24,77.84) U1.BE35
  07_SIG3 w0.127: v2(140.24,77.84) 140.5,77.84 140.63,77.97 140.63,78.24 140.84,78.45 141.54,78.45 142.06,77.93 142.38,77.93 142.47,78.01
  07_SIG3 w0.178: v4(159.56,75.75) 159.32,75.99 159.32,76.12 158.96,76.48 154.21,76.48 153.97,76.24
  07_SIG3 w0.208: 142.47,78.01 143.16,78.01 143.81,77.37 146.93,77.37 150.34,73.96 151.07,73.96 152.39,72.65 152.39,71.68 153.67,70.39 159.73,70.39 159.92,70.58 159.92,71.1 159.79,71.23 155.21,71.23 153.66,72.78 153.66,75.93 153.97,76.24
DDR4_C2_DQS5_C: length 36.7
  TOP w0.145: U137.A7 v4(154.76,78.15) ; U1.BF39 140.74,81.34 v2(141.24,81.84)
  05_SIG2 w0.127: 142.16,81.5 142.11,81.45 140.99,81.45 140.81,81.62 140.81,81.76 140.89,81.84 v2(141.24,81.84)
  05_SIG2 w0.178: 142.63,81.5 142.16,81.5 ; 154.5,81.29 154.33,81.12 154.33,77.96 154.66,77.63 154.95,77.63 155.14,77.83 155.14,78.15 154.99,78.31 154.91,78.31 v4(154.76,78.15)
  05_SIG2 w0.208: 154.5,81.29 154.71,81.5 154.71,83.13 153.5,84.34 152.73,84.34 152.43,84.63 151.47,84.63 151.18,84.34 146.93,84.34 146.71,84.12 146.71,83.61 147.26,83.06 147.26,82.79 147.08,82.61 146.82,82.61 146,83.43 146,84.48 145.69,84.78 145.18,84.78 144.81,84.41 144.81,82.88 146.23,81.46 147.29,81.46 147.48,81.27 147.48,81.04 147.27,80.82 145.38,80.82 145.24,80.96 145.24,81.45 144.91,81.79 144.37,81.79 143.69,81.11 143.24,81.11 142.85,81.5 142.63,81.5
DDR4_C2_DQS5_T: length 36.9
  TOP w0.145: U1.BE39 139.74,81.34 v2(140.24,81.84) ; v4(155.56,78.15) U137.B7
  05_SIG2 w0.127: v2(140.24,81.84) 140.84,81.24 142.12,81.24 142.16,81.19
  05_SIG2 w0.178: 154.07,81.29 154.03,81.25 154.03,77.83 154.53,77.33 155.08,77.33 155.56,77.81 v4(155.56,78.15) ; 142.63,81.19 142.16,81.19
  05_SIG2 w0.208: 154.07,81.29 154.41,81.63 154.41,83 153.38,84.04 152.6,84.04 152.3,84.33 151.6,84.33 151.3,84.04 147.05,84.04 147.01,83.99 147.01,83.74 147.57,83.18 147.57,82.67 147.2,82.31 146.7,82.31 145.69,83.31 145.69,84.35 145.57,84.48 145.31,84.48 145.11,84.28 145.11,83.01 146.36,81.76 147.42,81.76 147.79,81.4 147.79,80.91 147.39,80.52 145.26,80.52 144.94,80.84 144.94,81.33 144.78,81.48 144.5,81.48 143.82,80.8 143.11,80.8 142.72,81.19 142.63,81.19
DDR4_C2_DQS6_C: length 74.1
  TOP w0.145: U1.BA36 v2(136.24,78.84) ; v4(158.76,89.85) U138.F3
  07_SIG3 w0.127: 142.63,84.68 142.6,84.66 142.54,84.66 142.12,84.24 141.99,84.24 141.85,84.09 141.65,84.09 141.51,84.24 141.07,84.24 140.84,84 140.84,83.59 140.49,83.24 140.08,83.24 139.84,83.01 139.84,82.6 139.48,82.24 139.07,82.24 138.84,82.01 138.84,81.6 138.48,81.24 138.07,81.24 137.84,81.01 137.84,80.6 137.49,80.24 136.02,80.24 135.84,80.06 135.84,78.59 135.99,78.45 136.11,78.45 136.24,78.58 v2(136.24,78.84)
  07_SIG3 w0.178: v4(158.76,89.85) 158.76,89.57 158.88,89.45 159.06,89.45 159.15,89.55 159.15,90.1 159,90.25 154.49,90.25 154.34,90.11 154.34,88.45 153.97,88.07 ; 163.4,87 163.38,87.02 162.37,87.02 162.35,87
  07_SIG3 w0.208: 163.4,87 163.77,86.63 163.77,85.84 163.26,85.33 163.26,84.74 162.8,84.29 162.8,84.06 162.94,83.92 163.56,83.92 163.82,83.66 163.82,81.45 163.4,81.03 162.81,81.03 162.33,81.51 162.33,82.84 162.03,83.13 161.69,83.13 161.55,82.99 161.13,82.99 160.83,83.29 160.83,83.72 160.96,83.86 160.96,84.03 160.1,84.89 159.93,84.89 159.83,84.79 159.41,84.79 159.1,85.09 159.1,85.52 159.21,85.62 159.21,85.79 159.07,85.93 154.18,85.93 153.96,86.14 144.09,86.14 142.63,84.68 ; 153.97,88.07 153.8,87.91 151.05,87.91 150.87,87.72 150.87,87.63 151.06,87.44 154.16,87.44 154.61,86.99 159.59,86.99 160.03,86.54 161.1,86.54 161.42,86.23 161.42,85.17 161.56,85.03 161.84,85.03 161.98,85.17 161.98,86.63 162.35,87
DDR4_C2_DQS6_T: length 74.3
  TOP w0.145: U1.BA35 v2(136.24,77.84) ; U138.G3 v4(159.56,89.85)
  07_SIG3 w0.127: v2(136.24,77.84) 136.24,78.11 136.11,78.24 135.9,78.24 135.63,78.51 135.63,80.15 135.93,80.45 137.4,80.45 137.63,80.68 137.63,81.09 137.99,81.45 138.4,81.45 138.63,81.68 138.63,82.09 138.99,82.45 139.4,82.45 139.63,82.68 139.63,83.09 139.99,83.45 140.4,83.45 140.63,83.68 140.63,84.09 140.99,84.45 142.03,84.45 142.39,84.81 142.39,84.87 142.41,84.89
  07_SIG3 w0.178: v4(159.56,89.85) 159.46,89.95 159.46,90.23 159.13,90.56 154.36,90.56 154.04,90.23 154.04,88.58 153.97,88.5
  07_SIG3 w0.208: 153.97,88.5 153.68,88.21 150.93,88.21 150.56,87.85 150.56,87.5 150.94,87.13 153.99,87.13 154.44,86.68 159.46,86.68 159.9,86.24 160.98,86.24 161.12,86.1 161.12,85.04 161.44,84.72 161.97,84.72 162.29,85.04 162.29,86.51 162.49,86.72 163.25,86.72 163.46,86.51 163.46,85.97 162.95,85.46 162.95,84.87 162.5,84.41 162.5,83.93 162.82,83.61 163.44,83.61 163.51,83.54 163.51,81.57 163.27,81.33 162.94,81.33 162.63,81.64 162.63,82.96 162.16,83.44 161.56,83.44 161.43,83.3 161.25,83.3 161.13,83.42 161.13,83.59 161.27,83.73 161.27,84.16 160.23,85.2 159.81,85.2 159.7,85.09 159.53,85.09 159.41,85.22 159.41,85.39 159.51,85.49 159.51,85.92 159.19,86.23 154.3,86.23 154.09,86.45 143.96,86.45 143.14,85.63 142.41,84.89
DDR4_C2_DQS7_C: length 57.3
  TOP w0.145: v2(134.24,80.84) 133.74,80.34 U1.AW38 ; v4(154.76,92.25) U138.A7
  14_SIG4 w0.107: v2(134.24,80.84) 134.64,80.44 135.45,80.44 135.64,80.63 135.64,82.12 135.96,82.44 137.48,82.44 137.64,82.6 137.64,84.09 137.98,84.43 138.48,84.43 138.69,84.64 138.69,84.8
  14_SIG4 w0.108: v4(154.76,92.25) 154.99,92.02 154.99,91.82 154.82,91.65 154.45,91.65 154.22,91.42 154.02,91.42 153.99,91.45 153.97,91.45
  14_SIG4 w0.13: 141.95,84.99 141.6,85.34 138.95,85.34 138.69,85.08 138.69,84.8
  14_SIG4 w0.14: 153.97,91.45 153.57,91.45 152.92,90.79 152.92,86.42 154.79,84.54 154.79,83.99 155.18,83.61 155.65,83.61 156.03,83.99 156.03,85.22 156.19,85.39 156.53,85.39 156.71,85.2 156.71,83.84 157.03,83.52 157.63,83.52 157.95,83.84 157.95,85.71 158.12,85.89 159.3,85.89 159.57,85.61 159.57,85.08 159.36,84.87 158.85,84.87 158.52,84.54 158.52,83.96 158.85,83.63 159.24,83.63 159.39,83.48 159.39,82.46 159.13,82.19 154.52,82.19 153.79,82.93 148.37,82.93 146.9,84.39 144.02,84.39 143.41,84.99 141.95,84.99
DDR4_C2_DQS7_T: length 57.3
  TOP w0.145: U1.AW37 v2(134.24,79.84) ; U138.B7 v4(155.56,92.25)
  14_SIG4 w0.107: 138.88,84.34 138.68,84.34 138.57,84.23 138.06,84.23 137.84,84 137.84,82.51 137.57,82.24 136.05,82.24 135.84,82.03 135.84,80.55 135.53,80.24 134.37,80.24 134.24,80.11 v2(134.24,79.84)
  14_SIG4 w0.108: 153.97,91.15 153.99,91.15 154.02,91.17 154.33,91.17 154.56,91.4 154.92,91.4 155.24,91.72 155.24,91.93 v4(155.56,92.25)
  14_SIG4 w0.13: 138.88,84.34 141.6,84.34 141.95,84.69
  14_SIG4 w0.14: 153.97,91.15 153.7,91.15 153.22,90.67 153.22,86.54 155.1,84.67 155.1,84.12 155.31,83.91 155.52,83.91 155.73,84.12 155.73,85.35 156.07,85.69 156.65,85.69 157.02,85.32 157.02,83.96 157.16,83.82 157.5,83.82 157.65,83.97 157.65,85.84 158,86.19 159.43,86.19 159.88,85.74 159.88,84.95 159.49,84.57 158.98,84.57 158.82,84.41 158.82,84.09 158.98,83.94 159.37,83.94 159.7,83.61 159.7,82.33 159.25,81.89 154.4,81.89 153.66,82.62 148.24,82.62 146.78,84.08 143.89,84.08 143.29,84.69 141.95,84.69
DDR4_C2_DQS8_C: length 69.4
  TOP w0.145: v2(141.24,67.84) 140.74,67.34 U1.BF25 ; U139.F3 v4(158.76,33.21)
  14_SIG4 w0.107: 142.41,45.08 142.39,45.06 142.39,44.99 142.26,44.86 142.11,44.86 142,44.96 142,47.07 141.62,47.45 141.01,47.45 140.84,47.62 140.84,67.53 140.73,67.64 140.73,68.14 140.85,68.25 141.15,68.25 141.24,68.17 v2(141.24,67.84)
  14_SIG4 w0.108: v4(158.76,33.21) 158.61,33.36 158.61,33.5 158.1,34 154.47,34 154.2,34.27
  14_SIG4 w0.14: 142.41,45.08 142.72,45.39 142.72,48.2 143.07,48.54 143.57,48.54 143.98,48.13 143.98,45.02 143.78,44.82 143.78,44.16 143.98,43.97 143.98,43.22 145.18,42.02 145.18,39.26 145.26,39.18 145.8,39.18 145.87,39.24 145.87,40.71 146.18,41.03 146.8,41.03 146.96,40.86 147.13,40.7 147.13,38.52 147.2,38.45 147.69,38.45 147.79,38.54 147.79,40.62 148.03,40.86 148.53,40.86 148.86,40.53 148.86,38.76 149.06,38.56 149.36,38.56 150.23,37.68 150.7,37.68 151.19,37.2 151.19,36.83 151.66,36.35 151.88,36.35 152.27,36.73 152.72,36.73 153.1,36.36 153.1,35.75 151.91,34.56 151.91,34.3 152.05,34.16 152.24,34.16 153.03,34.95 153.57,34.95 154.2,34.32 154.2,34.27
DDR4_C2_DQS8_T: length 69.6
  TOP w0.145: v4(159.56,33.21) U139.G3 ; U1.BE25 139.74,67.34 v2(140.24,67.84)
  14_SIG4 w0.107: 142.63,44.86 142.61,44.84 142.53,44.84 142.34,44.65 142.03,44.65 141.8,44.88 141.8,46.98 141.54,47.24 140.93,47.24 140.64,47.54 140.64,67.44 v2(140.24,67.84)
  14_SIG4 w0.108: v4(159.56,33.21) 159.17,32.82 158.6,32.82 158.36,33.06 158.36,33.4 158,33.76 154.37,33.76 154.01,34.11 153.98,34.11 153.97,34.13
  14_SIG4 w0.14: 153.97,34.13 153.45,34.65 153.16,34.65 152.36,33.85 151.93,33.85 151.6,34.18 151.6,34.68 152.79,35.87 152.79,36.23 152.6,36.43 152.39,36.43 152.01,36.05 151.54,36.05 150.88,36.7 150.88,37.07 150.58,37.38 150.11,37.38 149.24,38.25 148.93,38.25 148.56,38.63 148.56,40.4 148.4,40.55 148.16,40.55 148.09,40.49 148.09,38.41 147.82,38.14 147.07,38.14 146.82,38.39 146.82,40.57 146.67,40.72 146.31,40.72 146.17,40.58 146.17,39.11 145.93,38.87 145.13,38.87 144.87,39.13 144.87,41.89 143.67,43.09 143.67,43.84 143.48,44.04 143.48,44.95 143.67,45.15 143.67,48 143.44,48.23 143.19,48.23 143.03,48.07 143.03,45.27 142.84,45.07 142.63,44.86
DDR4_C2_DQS9_C: length 60.3
  TOP w0.145: U1.BB26 136.74,68.34 v2(137.24,68.84) ; U139.A7 v4(154.76,35.61)
  03_SIG1 w0.127: v2(137.24,68.84) 137.09,68.99 136.87,68.99 136.75,68.87 136.75,68.63 136.84,68.54 136.84,66.39 137.19,66.04 138.94,66.04 139.19,65.79 139.19,65.43 138.84,65.09 138.84,63.68 139.07,63.45 139.48,63.45 139.84,63.09 139.84,62.68 140.08,62.45 140.49,62.45 140.84,62.09 140.84,61.68 141.08,61.45 141.55,61.45 141.78,61.21 141.84,61.21 141.87,61.19
  03_SIG1 w0.178: 153.97,35.23 154.57,34.62 154.89,34.62 155.13,34.85 155.13,35.5 155.02,35.61 v4(154.76,35.61) ; 142.63,60.43 141.87,61.19
  03_SIG1 w0.208: 142.63,60.43 143.73,59.33 143.73,58.92 143.92,58.72 144.56,58.72 144.97,58.31 144.97,57.87 144.65,57.55 143.87,57.55 143.73,57.41 143.73,56.93 143.84,56.82 144.63,56.82 144.95,56.5 144.95,55.86 144.65,55.57 143.87,55.57 143.73,55.43 143.73,55.05 143.87,54.91 144.65,54.91 144.97,54.59 144.97,54.04 144.65,53.72 143.87,53.72 143.73,53.58 143.73,53.27 143.87,53.13 144.65,53.13 144.97,52.81 144.97,52.26 144.65,51.94 143.87,51.94 143.73,51.8 143.73,51.47 143.87,51.33 144.65,51.33 144.97,51.01 144.97,50.45 144.65,50.14 143.87,50.14 143.73,50 143.73,49.69 143.87,49.55 144.65,49.55 144.97,49.23 144.97,48.68 144.65,48.36 144.17,48.36 144.06,48.24 144.06,47.96 144.23,47.79 144.66,47.79 144.97,47.48 144.97,46.95 144.64,46.61 144.15,46.61 144.03,46.49 144.03,46.24 144.22,46.05 144.67,46.05 144.97,45.75 144.97,44.98 150.31,39.64 150.75,39.64 151.13,39.27 151.13,38.84 153.35,36.62 153.35,35.84 153.97,35.23
DDR4_C2_DQS9_T: length 60.5
  TOP w0.145: v2(136.24,68.84) 135.74,68.34 U1.BA26 ; v4(155.56,35.61) U139.B7
  03_SIG1 w0.127: v2(136.24,68.84) 136.63,68.45 136.63,66.3 137.1,65.83 138.85,65.83 138.98,65.7 138.98,65.52 138.63,65.18 138.63,63.59 138.99,63.24 139.4,63.24 139.63,63.01 139.63,62.6 139.99,62.24 140.4,62.24 140.63,62.01 140.63,61.6 140.99,61.24 141.46,61.24 141.66,61.04 141.66,60.97 141.67,60.95
  03_SIG1 w0.178: 142.63,60 141.67,60.95 ; 153.97,34.79 154.45,34.31 155.02,34.31 155.43,34.73 155.43,35.48 v4(155.56,35.61)
  03_SIG1 w0.208: 142.63,60 143.42,59.2 143.42,58.79 143.79,58.42 144.43,58.42 144.67,58.18 144.67,58 144.53,57.86 143.74,57.86 143.42,57.54 143.42,56.8 143.71,56.51 144.5,56.51 144.64,56.37 144.64,55.99 144.53,55.88 143.74,55.88 143.42,55.56 143.42,54.92 143.74,54.61 144.53,54.61 144.67,54.47 144.67,54.16 144.53,54.02 143.74,54.02 143.42,53.7 143.42,53.15 143.74,52.83 144.53,52.83 144.67,52.69 144.67,52.38 144.53,52.24 143.74,52.24 143.42,51.93 143.42,51.34 143.74,51.02 144.53,51.02 144.67,50.88 144.67,50.58 144.53,50.44 143.74,50.44 143.42,50.12 143.42,49.56 143.74,49.25 144.53,49.25 144.67,49.11 144.67,48.8 144.53,48.66 144.04,48.66 143.75,48.37 143.75,47.84 144.1,47.49 144.53,47.49 144.67,47.35 144.67,47.07 144.51,46.92 144.03,46.92 143.73,46.62 143.73,46.11 144.09,45.75 144.55,45.75 144.67,45.63 144.67,44.85 150.18,39.34 150.63,39.34 150.83,39.14 150.83,38.71 153.05,36.49 153.05,35.71 153.97,34.79
DDR4_C2_ODT: length 180.9
  TOP w0.152: v4(162.76,33.21) U139.K3 ; U137.K3 v4(162.76,75.75) ; U138.K3 v4(162.76,89.85) ; U1.BB29 136.74,71.34 v2(137.24,71.84) ; U136.K3 v4(162.76,61.66) ; U135.K3 v4(162.76,47.56)
  TOP w0.279: v1(151.7,104.86) 151.79,104.76 R926.2
  03_SIG1 w0.173: 142.63,71.18 141.46,72.34 141.46,72.34 137.74,72.34 v2(137.24,71.84) ; 162.8,95.39 163.16,95.03 163.16,90.25 v4(162.76,89.85) 162.36,89.45 162.36,81.54 163.16,80.74 163.16,76.15 v4(162.76,75.75) U137.K3 162.36,73.05 162.25,72.94 162.25,71.89 162.36,71.78 162.36,67.6 163.16,66.8 163.16,62.06 v4(162.76,61.66) U136.K3 162.36,56.52 163.16,55.72 163.16,47.96 v4(162.76,47.56) 162.25,47.05 162.25,42.99 162.4,42.84 162.52,42.84 162.67,42.69 162.67,42.48 162.52,42.32 162.4,42.32 162.25,42.17 162.25,41.96 162.4,41.81 162.52,41.81 162.67,41.65 162.67,41.44 162.52,41.29 162.4,41.29 162.25,41.14 162.25,40.36 163.16,39.46 163.16,38.96 163.08,38.89 162.79,38.89 162.67,38.77 162.67,38.6 162.79,38.48 162.97,38.48 163.16,38.29 163.16,37.04 162.92,36.81 162.51,36.81 162.36,36.65 162.36,35.03 162.76,34.63 v4(162.76,33.21) 162.36,33.21 161.51,34.06 161.27,34.06 161.18,34.15 161.18,34.3 161.09,34.39 160.66,34.39 160.57,34.3 160.57,34.15 160.48,34.06 160.09,34.06 159.96,34.2 159.96,38.51
  03_SIG1 w0.292: 162.8,95.39 161.26,96.93 158.01,96.93 156.75,98.19 156.75,99.36 155.57,100.54 152.01,100.54 151.54,101 151.54,101.59 152.31,102.35 152.31,103.67 151.7,104.28 v1(151.7,104.86) ; 142.63,71.18 144.2,69.61 144.2,69.55 144.22,69.52 144.22,65.68 147.19,62.71 149.05,62.71 151.51,60.25 151.51,54.46 152.17,53.8 157.33,53.8 157.59,53.53 157.59,53.12 157.38,52.91 152.63,52.91 152.42,52.7 152.42,51.19 152.71,50.9 153.24,50.9 153.37,51.03 153.37,51.92 153.52,52.07 153.91,52.07 154.21,51.77 154.21,49.33 154.53,49.01 161.24,49.01 161.45,48.8 161.45,48.39 161.24,48.18 154.48,48.18 154.21,47.91 154.21,47.3 153.77,46.86 153.77,46.13 154.21,45.7 154.21,44.97 154.56,44.62 161,44.62 161.29,44.32 161.29,43.95 161.01,43.67 160.07,43.67 159.82,43.41 159.82,43.05 160.07,42.79 160.65,42.79 160.91,42.53 160.91,42.17 160.65,41.91 160.07,41.91 159.82,41.66 159.82,41.29 160.07,41.04 160.65,41.04 160.91,40.78 160.91,39.6 159.96,38.65 159.96,38.51
DDR4_C2_PAR: length 164.8
  TOP w0.152: U136.T3 v4(167.56,61.66) ; U135.T3 v4(167.56,47.56) ; v2(141.24,71.84) 140.74,71.34 U1.BF29 ; U137.T3 v4(167.56,75.75) ; U138.T3 v4(167.56,89.85) ; U139.T3 v4(167.56,33.21)
  05_SIG2 w0.173: 167.7,95.39 167.16,94.84 167.16,91.19 167.56,90.79 v4(167.56,89.85) 167.16,89.45 167.16,83.62 167.23,83.55 167.23,82.28 167.16,82.21 167.16,76.15 v4(167.56,75.75) U137.T3 167.16,70.16 167.27,70.05 167.27,68.17 167.16,68.06 167.16,62.06 v4(167.56,61.66) U136.T3 167.16,54.9 167.15,54.88 167.15,54.52 167.16,54.51 167.16,47.96 v4(167.56,47.56) 167.16,47.16 167.16,44.85 167.33,44.68 167.76,44.68 167.93,44.5 167.93,44.16 167.76,43.99 167.33,43.99 167.16,43.81 167.16,40.92 167.27,40.81 167.27,39.79 167.36,39.7 167.7,39.7 167.84,39.56 167.84,39.22 167.67,39.04 167.33,39.04 167.16,38.87 167.16,36.19 166.98,36.01 166.59,36.01 166.36,35.77 166.36,35.42 167.56,34.22 v4(167.56,33.21)
  05_SIG2 w0.292: v1(169.27,101.6) 169.27,100.81 167.87,99.42 167.87,95.56 167.7,95.39
  14_SIG4 w0.089: v2(141.24,71.84) 140.76,72.32 140,72.32 139.76,72.08 139.76,72.04 139.76,72.04 139.76,71.64 139.76,71.64 139.76,71.56 139.54,71.34 139.03,71.34 138.74,71.05 138.74,70.64 138.44,70.34 138.12,70.34 137.69,69.91 137.69,69.71 137.35,69.36 137.17,69.36 136.66,68.85 136.66,68.64 136.4,68.39 136.17,68.39 135.71,67.94 135.71,67.68 135.4,67.37 135.15,67.37 134.74,66.96 134.74,66.64 133.74,65.64 133.74,45.55 133.95,45.34 134.54,45.34 134.74,45.14 134.74,44.52 134.91,44.34 135.58,44.34 135.74,44.18 135.74,42.38 135.93,42.19 135.93,41.68 ; 167.93,30.62 167.96,30.64 167.96,32.81 v4(167.56,33.21)
  14_SIG4 w0.157: 167.93,30.62 167.93,30.46 167.79,30.33 167.39,30.33 166.64,29.57 166.01,29.57 165.86,29.73 165.86,29.99 165.7,30.14 165.07,30.14 164.91,29.99 164.91,29.73 164.75,29.57 164.12,29.57 163.97,29.73 163.97,29.99 163.81,30.14 163.18,30.14 163.02,29.99 163.02,29.73 162.86,29.57 161.85,29.57 160.72,28.45 155.23,28.45 155.15,28.53 148.29,28.53 144.58,32.25 142.04,32.25 141.67,32.61 141.67,34.35 141.18,34.84 140.88,34.84 140.68,34.64 140.33,34.64 140.05,34.92 140.05,35.23 140.27,35.45 140.27,35.75 138.46,37.56 137.58,37.56 137.3,37.28 137.02,37.28 136.72,37.58 136.72,37.89 137.15,38.32 137.15,38.65 136.84,38.96 136.54,38.96 136.17,38.58 135.79,38.58 135.52,38.86 135.52,39.35 135.93,39.76 135.93,41.68
  BOTTOM w0.279: v1(169.27,101.6) 170.08,100.78 R925.2
DDR4_C2_REFIN: length 5.6
  TOP w0.152: C1208.1 145.54,105.33 146.04,104.83 R900.2 ; C1208.1 R901.1 ; C1208.1 145.03,105.85 144.73,106.15 v1(144.73,106.27)
  BOTTOM w0.152: v1(144.73,106.27) 145.02,105.98 145.02,105.85 145.59,105.28 U134.1
DDR4_C2_RESET_B: length 164.3
  TOP w0.152: U136.P1 v4(165.96,59.26) ; U135.P1 v4(165.96,45.16) ; U137.P1 v4(165.96,73.35) ; U139.P1 v4(165.96,30.81) ; U138.P1 v4(165.96,87.45) ; v2(139.24,77.84) U1.BD35
  03_SIG1 w0.173: 167.16,95.39 167.16,93.68 166.92,93.45 166.58,93.45 166.36,93.23 166.36,87.85 v4(165.96,87.45) 166.24,87.16 166.24,83.84 166.13,83.73 166.13,82.36 166.36,82.13 166.36,73.75 v4(165.96,73.35) 166.39,72.92 166.39,69.88 166.1,69.59 166.1,68.26 166.36,68 166.36,59.66 v4(165.96,59.26) 166.69,58.53 166.69,56.18 166.14,55.64 166.14,53.08 166.36,52.85 166.36,45.56 v4(165.96,45.16) 167.16,43.96 167.16,43.5 167.31,43.35 167.42,43.35 167.57,43.2 167.57,42.98 167.42,42.83 167.31,42.83 167.16,42.68 167.16,41.16 167.31,41.01 167.31,39.59 167.16,39.45 167.16,36.24 166.92,36.01 165.79,36.01 165.56,35.77 165.56,35.22 166.36,34.42 166.36,31.44 165.96,31.04 v4(165.96,30.81)
  03_SIG1 w0.292: v1(165,101.43) 167.16,99.27 167.16,95.39
  07_SIG3 w0.173: v2(139.24,77.84) 139.02,77.84 138.52,77.34 138.03,77.34 137.74,77.05 137.74,76.64 137.44,76.34 137.03,76.34 136.74,76.05 136.74,75.64 136.44,75.34 134.03,75.34 133.74,75.05 133.74,74.64 133.44,74.34 133.03,74.34 132.74,74.05 132.74,73.64 132.44,73.34 132.03,73.34 131.74,73.05 131.74,72.64 131.44,72.34 131.03,72.34 130.74,72.05 130.74,71.64 130.44,71.34 130.03,71.34 129.74,71.05 129.74,68.65 130.05,68.33 130.45,68.33 130.73,68.05 130.73,67.68 131.01,67.4 131.48,67.4 131.75,67.13 131.75,66.68 132.98,65.45 133.3,65.45 133.72,65.03 133.72,52.63 133.99,52.35 134.5,52.35 134.78,52.08 134.78,51.57 134.96,51.38 135.39,51.38 135.71,51.06 135.71,50.63 136,50.34 136.48,50.34 136.69,50.13 136.69,49.76 137.16,49.29 137.44,49.29 137.78,48.96 137.78,48.65 138.15,48.29 138.42,48.29 138.71,48 138.71,47.75 139.09,47.37 139.37,47.37 139.73,47.02 139.73,44.67 140.02,44.38 140.32,44.38 140.67,44.02 140.67,42.5 140.8,42.37 ; v4(165.96,30.81) 165.77,30.62
  07_SIG3 w0.292: 165.77,30.62 165.55,30.39 165.55,30.22 164.23,28.91 152.03,28.91 150.31,30.63 148.54,30.63 147.01,32.15 147.01,33.81 140.8,40.02 140.8,42.37
  BOTTOM w0.279: R896.1 v1(165,101.43)
DDR4_C2_TEN: length 173.7
  TOP w0.152: U135.N9 v4(165.16,52.36) ; U136.N9 v4(165.16,66.46) ; U1.AY35 v2(135.24,77.84) ; U139.N9 v4(165.16,38.01) ; U138.N9 v4(165.16,94.65) ; U137.N9 v4(165.16,80.55)
  05_SIG2 w0.173: 142.85,56.76 142.45,57.17 142.29,57.17 142.17,57.04 142.17,56.95 142.04,56.82 141.86,56.82 141.73,56.95 141.73,57.17 141.56,57.34 141.03,57.34 140.74,57.64 140.74,58.05 140.44,58.34 140.03,58.34 139.74,58.64 139.74,59.05 139.44,59.34 139.03,59.34 138.74,59.64 138.74,60.05 138.44,60.34 138.03,60.34 137.74,60.64 137.74,61.05 137.44,61.34 137.03,61.34 136.74,61.64 136.74,62.05 136.44,62.34 136.03,62.34 135.74,62.64 135.74,63.05 135.44,63.34 135.03,63.34 134.74,63.64 134.74,64.05 134.44,64.34 134.03,64.34 133.76,64.62 133.76,65.36 132.81,66.31 132.07,66.31 131.74,66.64 131.74,67.05 131.44,67.34 131.03,67.34 130.74,67.64 130.74,71.05 130.44,71.34 130.03,71.34 129.74,71.64 129.74,74.14 129.94,74.34 130.38,74.34 130.73,74.69 130.73,77.04 131.01,77.32 131.44,77.32 131.75,77.62 131.75,78.05 132.05,78.36 132.49,78.36 132.74,78.61 132.74,79.06 133.02,79.34 134.56,79.34 134.75,79.16 134.75,78.61 135.24,78.12 v2(135.24,77.84) ; 153.97,38.63 153.98,38.63 154.27,38.34 154.27,35.22 154.46,35.02 158.68,35.02 158.93,34.78 159.2,34.78 159.45,35.02 159.72,35.02 159.96,34.78 160.24,34.78 160.48,35.02 160.76,35.02 161,34.78 161.27,34.78 161.52,35.02 161.79,35.02 162.04,34.78 162.31,34.78 162.55,35.02 165.39,35.02 165.56,35.2 165.56,35.82 165.56,35.82 165.56,37.9 165.45,38.01 v4(165.16,38.01) 165.16,38.47 165.25,38.56 165.84,38.56 165.93,38.65 165.93,38.92 165.82,39.02 165.23,39.02 165.16,39.09 165.16,41.43 165.33,41.6 165.9,41.6 166,41.7 166,42.02 165.92,42.1 165.32,42.1 165.16,42.26 165.16,43.45 165.24,43.53 165.69,43.53 165.78,43.62 165.78,44.05 165.68,44.15 165.48,44.15 165.34,44.29 165.34,44.67 165.56,44.89 165.56,51.96 v4(165.16,52.36) 165.69,52.89 165.69,56.33 165.56,56.46 165.56,66.06 v4(165.16,66.46) 165.16,72.54 165.56,72.94 165.56,80.15 v4(165.16,80.55) 165.16,85.71 165.56,86.11 165.56,94.25 v4(165.16,94.65) 165.48,94.97 165.48,95.12 165.74,95.39
  05_SIG2 w0.292: 142.85,56.76 143.09,56.52 143.09,56.12 143.35,55.87 143.74,55.87 143.98,55.63 143.98,55.27 144.28,54.98 144.64,54.98 144.88,54.74 144.88,54.35 145.13,54.09 145.53,54.09 145.77,53.85 145.77,53.47 146.04,53.2 146.42,53.2 146.66,52.96 146.66,52.57 146.92,52.31 147.31,52.31 147.55,52.07 147.55,51.7 148.33,50.92 148.33,40.93 149.18,40.07 149.72,40.07 150.4,39.4 150.91,39.4 151.23,39.09 151.59,39.09 151.59,39.09 151.95,39.09 152.25,38.79 152.25,37.91 152.55,37.62 153.14,37.62 153.46,37.94 153.46,38.41 153.68,38.63 153.97,38.63 ; v1(153.42,101.4) 153.7,101.68 153.7,103.17 154.45,103.93 155.76,103.93 157.4,105.57 158.1,105.57 158.43,105.24 158.43,104.55 159.11,103.87 162.6,103.87 163.53,102.95 163.53,102.33 164.34,101.52 164.34,98.68 166.37,96.65 166.37,96.01 165.74,95.39
  BOTTOM w0.279: v1(153.42,101.4) 153.57,101.24 R899.1
DDR4_C2_VREFA: length 3.1
  TOP w0.381: U135.M1 v4(164.36,45.16)
  BOTTOM w0.254: v4(164.36,45.16) 164.4,45.11 C1144.1 164.4,43.39 R936.1 R935.2
DDR4_C2_VREFB: length 3.1
  TOP w0.381: U136.M1 v4(164.36,59.26)
  BOTTOM w0.254: R937.2 R938.1 164.45,57.99 164.4,58.04 C1147.1 164.4,59.21 v4(164.36,59.26)
DDR4_C2_VREFC: length 3.1
  TOP w0.381: U137.M1 v4(164.36,73.35)
  BOTTOM w0.254: v4(164.36,73.35) 164.4,73.31 C1150.1 164.45,72.59 R940.1 R939.2
DDR4_C2_VREFD: length 3.1
  TOP w0.381: U138.M1 v4(164.36,87.45)
  BOTTOM w0.254: v4(164.36,87.45) 164.4,87.4 C1153.1 164.4,86.15 164.45,86.1 R942.1 R941.2
DDR4_C2_VREFE: length 2.9
  TOP w0.381: U139.M1 v4(164.36,30.81)
  BOTTOM w0.254: R943.2 R944.1 164.45,30.04 C1162.1 164.4,30.76 v4(164.36,30.81)
DDR4_C2_VTERM_0V60_PGOOD: length 117.9
  TOP w0.14: Q37.1 v1(205.67,155.14)
  05_SIG2 w0.173: v1(205.67,155.14) 205.11,155.69 204.39,155.69 204.01,155.31 204.01,154.66 203.08,153.73 198.24,153.73 197.44,154.53 193.32,154.53 192.52,153.73 184.86,153.73 181.33,150.19 180.87,150.19 176.1,150.19 171.09,145.18 171.09,139.26 170.62,138.79 170.62,136.08 174.98,131.72 174.98,124.28 173.11,122.41 173.11,112.74 167.44,107.08 159.95,107.08 159.03,107.99 157.16,107.99 156.72,107.55 156.07,107.55 155.17,108.45 150.31,108.45 146.5,104.63 145.68,104.63 v1(144.21,103.17)
  BOTTOM w0.152: v1(144.21,103.17) 144.21,100.03 144.61,99.63 145.54,99.63 145.79,99.87 R929.2 145.79,101.01 145.92,101.14 145.92,101.4 146.09,101.56 U134.9
DDR4_C2_VTERM_EN: length 4.1
  BOTTOM w0.152: U134.7 147.09,100.53 146.43,99.87 146.43,99.24 146.18,98.98 R928.2
DDR4_C2_VTERM_REFOUT: length 1.5
  TOP w0.152: C1142.1 148.32,102.16 v1(148.34,102.14)
  BOTTOM w0.152: v1(148.34,102.14) U134.6
DDR4_C2_VTT: length 74.8
  TOP w0.254: v1(163.73,98.95) 163.74,98.95 Z86.1
  TOP w0.381: C1181.1 v1(150.65,102.7) ; R1106.1 149.3,102.72 v1(149.35,102.67) ; R926.1 151.79,103.11 151.7,103.02 v1(151.7,102.69) ; v1(152.27,99.11) 152.53,99.37 C1158.1
  16_SIG5 w0.381: v1(163.73,98.95) 164.96,100.17 170.18,100.17 170.91,100.9 170.91,102.44 169.64,103.71 169.64,107.28 177.77,115.42 177.77,129.06 176.79,130.04 176.79,139.73 v1(177.73,140.67)
  20_SIG7 w0.381: J88.1 164.16,144.2 170.18,144.2 172.29,142.08 176.31,142.08 v1(177.73,140.67)
  BOTTOM w0.305: U134.3 146.59,106.18 146.63,106.22
DDR4_C2_ZQA: length 1.5
  TOP w0.152: U135.F9 v4(158.76,52.36)
  BOTTOM w0.254: R930.1 158.22,52.89 v4(158.76,52.36)
DDR4_C2_ZQB: length 1.5
  TOP w0.152: U136.F9 v4(158.76,66.46)
  BOTTOM w0.152: v4(158.76,66.46) 158.76,66.57 158.22,67.1 R931.1
DDR4_C2_ZQC: length 1.6
  TOP w0.152: U137.F9 v4(158.76,80.55)
  BOTTOM w0.254: R932.1 158.22,81.09 v4(158.76,80.55)
DDR4_C2_ZQD: length 1.6
  TOP w0.152: U138.F9 v4(158.76,94.65)
  BOTTOM w0.152: R933.1 158.22,95.18 v4(158.76,94.65)
DDR4_C2_ZQE: length 1.6
  TOP w0.152: U139.F9 v4(158.76,38.01)
  BOTTOM w0.254: R7.1 158.22,38.54 v4(158.76,38.01)
DXN: length 96.9
  TOP w0.104: C240.2 v1(177.92,35.43)
  TOP w0.152: v2(120.24,58.84) U1.AE17
  07_SIG3 w0.094: 127.62,41.22 127.62,41.24 127.67,41.29 127.67,45.46 127.62,45.5 127.62,47.31 127.67,47.36 127.67,59.15 127.57,59.25 120.65,59.25 v2(120.24,58.84)
  07_SIG3 w0.135: v1(126.84,36.42) 127.08,36.18 127.27,36.18 127.41,36.31 127.41,36.83 128.19,37.61 128.19,39.8 127.62,40.37 127.62,41.22
  14_SIG4 w0.089: v1(126.84,36.42) 127.11,36.15 128.38,36.15 134.63,29.9 136.13,29.9 136.18,29.96 141.38,29.96 145.89,25.45 151.23,25.45 151.56,25.78 154.15,25.78 154.49,25.45 158.09,25.45 158.66,26.01 166.81,26.01 172,31.2 172.5,31.2 173.06,31.76 173.06,33.32 173.8,34.06 173.8,35.43 174.7,36.33 177.1,36.33 177.56,35.87 177.56,35.6 177.73,35.43 v1(177.92,35.43)
  BOTTOM w0.104: Z8.1 v1(177.92,35.43)
DXP: length 98.3
  TOP w0.104: v1(176.92,35.43) C240.1
  TOP w0.152: U1.AE18 v2(120.24,59.84)
  07_SIG3 w0.094: v2(120.24,59.84) 120.65,59.43 127.64,59.43 127.85,59.23 127.85,47.28 127.8,47.24 127.8,45.58 127.85,45.54 127.85,41.29 127.9,41.24 127.9,41.22
  07_SIG3 w0.135: 127.9,41.22 127.9,40.49 128.47,39.92 128.47,37.5 127.68,36.72 127.68,36.19 127.39,35.9 127.14,35.9 v1(126.84,35.61)
  14_SIG4 w0.089: v1(126.84,35.61) 127.11,35.87 128.26,35.87 134.51,29.62 136.24,29.62 136.3,29.68 141.27,29.68 145.77,25.17 151.51,25.17 151.84,25.5 154.04,25.5 154.37,25.17 158.21,25.17 158.77,25.73 166.93,25.73 172.11,30.92 172.61,30.92 173.34,31.64 173.34,33.21 174.08,33.95 174.08,35.31 174.82,36.05 176.99,36.05 177.28,35.76 177.28,35.6 177.11,35.43 v1(176.92,35.43)
  BOTTOM w0.104: v1(176.92,35.43) 176.5,35.85 176.5,36.22 176.72,36.44 U31.8
ENET_LED_0: length 20.5
  TOP w0.152: v1(39.37,141.07) 39.37,141.58 39.65,141.86 U7.47 ; v1(43.18,145.03) R62.1 ; v1(45.82,141.99) 46.15,142.32 46.61,142.32 47.09,142.8 Q18.1
  05_SIG2 w0.173: v1(39.37,141.07) 40.56,141.07 41.61,142.11 41.61,143.45 v1(43.18,145.03) 43.76,144.45 43.76,142.14 44.4,141.5 45.16,141.5 45.64,141.99 v1(45.82,141.99)
  BOTTOM w0.152: v1(43.18,145.03) R62.1 ; v1(45.82,141.99) 46.1,142.27 46.96,142.27 47.23,142 R198.2 46.86,141.21 R200.1
ENET_LED_0_LS: length 8.1
  TOP w0.152: Q18.3 47.51,143.6 47.14,143.23 46.69,143.23 45.91,144.01 45.91,144.13 45.44,144.6 45.44,145.01 45.66,145.23 45.66,147.03 45.19,147.5 DS1.1
ENET_LED_1: length 11.9
  TOP w0.14: R63.1 v1(42.29,143.18)
  TOP w0.152: R202.1 41.96,143.51 v1(42.29,143.18) 41.63,142.52 41.63,141.96 41.03,141.36 U7.46 ; Q60.1 44.74,145.35 v1(44.37,144.98)
  BOTTOM w0.152: v1(44.37,144.98) 43.66,145.69 43.03,145.69 42.65,145.31 42.65,144.4 42.48,144.23 R202.1 41.96,143.51 v1(42.29,143.18) R63.1
ENET_LED_1_LS: length 16.5
  TOP w0.152: v1(44.07,146.61) 44.18,146.5 Q60.3
  14_SIG4 w0.089: J10.13 32.51,148.31 43.18,148.31 44.07,147.42 v1(44.07,146.61)
ENET_LED_2: length 7.6
  TOP w0.14: R64.1 42.38,142.16 v1(42.28,142.05)
  TOP w0.152: v1(42.28,142.05) 42.18,142.05 41.99,141.86 41.99,141.73 41.11,140.86 U7.45
  BOTTOM w0.152: R203.2 43.11,139.88 R204.1 43.11,142.09 R64.1 42.38,142.16 v1(42.28,142.05) 42.18,142.15 Q59.1
ENET_LED_2_LS: length 8.5
  BOTTOM w0.152: Q59.3 41.2,143.08 40.61,143.66 40.16,143.66 39.62,144.2 39.62,147.24 40.18,147.8 J10.15
ENET_TD_A_N: length 10.8
  TOP w0.104: U7.2 39.05,143.71 39.16,143.82 39.16,149.03 38.66,149.53 38.66,150.79 39.53,151.66 39.53,151.98 J10.10
ENET_TD_A_P: length 10.8
  TOP w0.104: J10.11 39.76,151.98 39.76,151.57 38.89,150.7 38.89,149.62 39.39,149.12 39.39,143.88 39.55,143.71 U7.1
ENET_TD_B_N: length 19.6
  TOP w0.104: v1(37.33,144.83) 37.68,144.48 37.68,143.85 37.55,143.71 U7.5
  07_SIG3 w0.135: J10.5 38.91,155.42 38.77,155.28 38.77,154.68 37.39,153.3 37.39,149.87 39.75,147.51 39.75,143.8 39.26,143.31 38.04,143.31 37.66,143.68 37.66,144.51 v1(37.33,144.83)
ENET_TD_B_P: length 19.7
  TOP w0.104: U7.4 38.05,143.71 37.91,143.85 37.91,144.48 v1(38.26,144.83)
  07_SIG3 w0.135: J10.4 38.36,155.42 38.49,155.28 38.49,154.8 37.11,153.42 37.11,149.76 39.47,147.4 39.47,145.22 39.34,145.09 38.97,145.09 38.84,144.95 38.84,144.69 38.97,144.55 39.34,144.55 39.47,144.42 39.47,143.92 39.14,143.59 38.15,143.59 37.94,143.8 37.94,144.51 v1(38.26,144.83)
ENET_TD_C_N: length 14.2
  TOP w0.104: J10.2 34.37,155.42 34.46,155.33 34.46,154.68 35.94,153.19 35.94,150.7 35.61,150.37 35.61,145.52 36.2,144.93 36.2,143.86 36.05,143.71 U7.8
ENET_TD_C_P: length 14.2
  TOP w0.104: U7.7 36.55,143.69 36.42,143.81 36.42,145.03 35.84,145.61 35.84,150.27 36.17,150.6 36.17,153.29 34.69,154.77 34.69,155.28 34.82,155.42 J10.3
ENET_TD_D_N: length 15.7
  TOP w0.104: U7.11 34.55,143.71 34.68,143.85 34.68,144.64 v1(34.33,144.99)
  05_SIG2 w0.135: J10.9 33.8,152.88 33.7,152.77 33.7,151.8 34.57,150.93 34.57,147.66 33.8,146.89 33.8,146.7 34.03,146.47 34.03,146.27 33.84,146.08 33.65,146.08 33.42,146.32 33.23,146.32 32.92,146.01 32.92,144.88 33.66,144.15 34.33,144.15 34.66,144.47 34.66,144.66 v1(34.33,144.99)
ENET_TD_D_P: length 15.7
  TOP w0.104: U7.10 35.05,143.71 34.91,143.85 34.91,144.64 v1(35.26,144.99)
  05_SIG2 w0.135: J10.8 33.3,152.88 33.42,152.76 33.42,151.68 34.29,150.81 34.29,147.78 32.64,146.13 32.64,144.77 33.54,143.87 34.45,143.87 34.94,144.36 34.94,144.66 v1(35.26,144.99)
ENET_XI: length 12.6
  TOP w0.152: C144.1 28.65,146.9 28.39,146.64 X2.1 27.72,145.71 27.56,145.54 27.56,141.76 27.94,141.38 31.53,141.38 R84.1 32.05,141.36 U7.15
ENET_XO: length 10.8
  TOP w0.152: C143.1 X2.3 30.27,142.57 29.97,142.27 28.06,142.27 27.94,142.14 27.94,141.88 28.09,141.73 31.42,141.73 R84.2 32.05,141.86 U7.14
FAN_FAIL_B: length 15.1
  TOP w0.152: v1(178.82,38.02) 178.82,37.67 178.44,37.3 R192.2
  05_SIG2 w0.173: v1(178.73,28.67) 179.48,29.43 179.48,37.36 v1(178.82,38.02)
  BOTTOM w0.152: Q22.3 178.57,28.52 v1(178.73,28.67) ; U31.4 178.24,38.98 178.82,38.4 v1(178.82,38.02)
FAN_FAIL_LS_B: length 115.6
  TOP w0.152: v1(177.08,24.89) 176.53,25.44 176.53,26.97 174.73,28.78 172.9,28.78 171.32,30.37 154.48,30.37 151.69,33.15 145.75,33.15 144.27,31.67 144.27,30.4 143.79,29.92 142.99,29.92 140.84,27.78 135.04,27.78 133.98,28.83 133.98,33.3 130.95,36.34 v1(128.96,36.34) ; 133.74,75.34 v2(134.24,75.84)
  07_SIG3 w0.173: v1(128.96,36.34) 129.74,37.12 129.74,65 128.88,65.86 127.91,65.86 127.74,66.03 127.74,67.22 127.61,67.34 126,67.34 125.74,67.61 125.74,72.13 125.95,72.34 126.58,72.34 126.74,72.5 126.74,73.03 127.05,73.34 131.43,73.34 131.74,73.64 131.74,74.1 131.98,74.34 132.55,74.34 132.74,74.53 132.74,75.14 133.02,75.43 133.41,75.43 133.83,75.84 v2(134.24,75.84)
  BOTTOM w0.152: Q22.2 176.64,27.09 176.54,26.99 R210.2 176.54,25.43 v1(177.08,24.89)
FAN_OT_B: length 13.7
  TOP w0.152: v1(174.6,36.93) 174.92,37.25 R107.2
  BOTTOM w0.152: Q28.3 174.77,30.13 173.35,31.55 173.35,34.06 174.6,35.31 v1(174.6,36.93) 174.31,36.93 173.82,36.44 U31.9
FAN_OT_LS_B: length 136.4
  TOP w0.152: U1.BC40 137.74,82.34 v2(138.24,82.84)
  03_SIG1 w0.173: v1(143.03,100) 143.79,100 144.24,100.45 144.24,101.23 145.21,102.21 147.09,102.21 149.1,104.22 149.1,104.9 149.72,105.51 149.72,105.98 151.03,107.28 151.03,107.29 158.76,107.29 159.77,106.28 171.15,106.28 172.22,105.2 172.22,94.01 171.69,93.47 171.69,88.98 170.55,87.84 170.55,79.2 169.56,78.21 169.56,68.99 168.28,67.71 168.28,50.29 169.16,49.4 169.16,44.43 170.01,43.58 170.01,39.05 171.08,37.99 171.08,34.87 170.79,34.59 170.79,29.33 v1(171.4,28.72)
  20_SIG7 w0.089: v2(138.24,82.84) 138.73,83.34 138.73,89.69 141.75,92.71 141.75,96.6 142.15,97.01 142.15,97.67 143.03,98.55 v1(143.03,100)
  BOTTOM w0.152: Q28.2 173.51,28.39 173.41,28.49 R219.2 171.63,28.49 v1(171.4,28.72)
FAN_PWR_B: length 4.7
  TOP w0.152: Q61.3 172.77,35.14 171.98,34.34 171.98,32.35 J73.1
FIREFLY_INT_B: length 10.7
  TOP w0.152: v1(43.57,83.83) 44.04,84.3 J6.5
  03_SIG1 w0.173: v1(43.57,83.83) 43.57,83.14 47.71,79 49.11,79 v1(49.29,79.17)
  BOTTOM w0.152: U22.9 v1(49.29,79.17)
FIREFLY_INT_LS_B: length 123.8
  TOP w0.152: v2(141.24,66.84) U1.BF24
  05_SIG2 w0.173: v1(64.86,92.58) 64.86,90.34 64.49,89.97 60.86,89.97 58.86,87.96 58.86,82.41 55.81,79.35 53.37,79.35 52.61,78.6 v1(52.61,77.7)
  BOTTOM w0.113: 137.08,68.33 136.96,68.44 133.89,68.44 133.74,68.6
  BOTTOM w0.152: 133.74,68.6 133.74,70.11 133.5,70.34 133.04,70.34 132.74,70.64 132.74,71.2 132.59,71.34 132.04,71.34 131.74,71.64 131.74,72.15 131.54,72.34 131.04,72.34 130.74,72.64 130.74,73.11 130.5,73.34 130.04,73.34 129.74,73.64 129.74,74.12 129.52,74.34 129.04,74.34 128.74,74.64 128.74,75.1 128.49,75.34 119.96,75.34 119.74,75.57 119.74,76.04 119.44,76.34 118.98,76.34 117.98,77.34 108.04,77.34 107.7,77.68 107.7,78.18 107.49,78.38 107,78.38 106.74,78.64 106.74,79.14 106.5,79.38 105.99,79.38 105.74,79.63 105.74,80.04 105.44,80.34 105.04,80.34 104.75,80.63 104.75,82.09 104.5,82.34 104.04,82.34 103.73,82.65 103.73,83.08 103.47,83.34 103.04,83.34 102.74,83.64 102.74,90.4 101.35,91.8 87.35,91.8 86.39,92.76 83.46,92.76 81.5,90.79 66.65,90.79 v1(64.86,92.58) ; v2(141.24,66.84) 140.73,67.35 140.73,68.09 140.48,68.33 137.08,68.33 ; U22.4 52.42,79.17 52.61,78.98 v1(52.61,77.7)
FIREFLY_MODPRS_B: length 11.1
  TOP w0.152: J6.3 v1(45.64,83.9)
  05_SIG2 w0.173: v1(45.64,83.9) 45.64,81.09 47.81,78.92 48.77,78.92 49.6,78.09 v1(49.6,77.79)
  BOTTOM w0.152: U22.8 49.83,78.77 49.6,78.55 v1(49.6,77.79)
FIREFLY_MODPRS_LS_B: length 111.3
  TOP w0.152: U1.BD22 v2(139.24,63.84)
  03_SIG1 w0.173: v1(65.72,72.32) 64.21,72.32 62.09,74.45 60.62,74.45 56.17,78.9 52.59,78.9 v1(51.95,78.26)
  BOTTOM w0.113: 132.6,60.34 132.7,60.24 134.52,60.24 134.84,60.56 134.84,61.11 134.97,61.24 135.54,61.24 135.84,61.54 135.84,62.03 136.14,62.33 136.55,62.33 136.68,62.46 137.42,62.46 137.7,62.73 137.7,63.09
  BOTTOM w0.152: U22.5 v1(51.95,78.26) ; v2(139.24,63.84) 138.74,63.35 137.96,63.35 137.7,63.09 ; v1(65.72,72.32) 66.68,71.36 66.68,68.83 67.99,67.53 81.06,67.53 82.32,66.27 82.32,61.62 82.54,61.39 83.13,61.39 84.56,59.96 84.56,59.43 85.04,58.95 91.54,58.95 93.93,61.34 107.44,61.34 107.74,61.64 107.74,62.04 108.04,62.34 108.44,62.34 108.74,62.64 108.74,63.09 108.99,63.34 109.44,63.34 109.74,63.64 109.74,63.94 110.14,64.34 113.44,64.34 113.74,64.64 113.74,65.02 114.73,66.01 117.53,66.01 118.24,65.3 127.5,65.3 127.75,65.06 127.75,64.63 128.04,64.34 128.45,64.34 128.74,64.06 128.74,63.64 129.04,63.34 129.44,63.34 129.74,63.04 129.74,62.63 130.02,62.34 130.49,62.34 130.74,62.1 130.74,61.64 131.04,61.34 131.44,61.34 131.74,61.04 131.74,60.64 132.04,60.34 132.6,60.34
FIREFLY_MODSEL_B: length 13.5
  TOP w0.152: J6.4 44.84,84.14 v1(44.55,83.85)
  18_SIG6 w0.089: v1(44.55,83.85) 48.09,80.31 48.52,80.31 49.14,79.69 52.04,79.69 v1(53.58,78.15)
  BOTTOM w0.152: v1(53.58,78.15) U33.8
FIREFLY_MODSEL_LS_B: length 307.8
  TOP w0.152: U1.BC23 v2(138.24,64.84)
  14_SIG4 w0.089: v1(172.47,30.28) 172.47,28.31 171.33,27.17 169.03,27.17 166.98,25.12 159.61,25.12 159.12,24.63 157.7,24.63 157.27,24.2 145.75,24.2 143.74,26.21 142.11,26.21 140.56,27.77 135.94,27.77 134.83,28.88 120.68,28.88 117.88,26.08 117.88,22.24 118.88,21.24 118.88,20.59 121.26,18.21 121.26,16.43 120.47,15.65 117.88,15.65 115.77,13.54 101.73,13.54 101.51,13.75 93.07,13.75 91.88,14.95 88.87,14.95 87.87,13.94 83.96,13.94 82.58,15.33 80.55,15.33 79.87,14.66 66.91,14.66 66.07,15.49 53.37,15.49 51.86,13.98 46.01,13.98 45.54,14.45 38.35,14.45 36.61,16.19 v1(36.61,37.17)
  16_SIG5 w0.089: v1(172.47,30.28) 171.79,30.28 170.75,31.32 170.75,32.4 169.14,34.01 154.73,34.01 144.93,43.81 144.93,47.2 142.68,49.45 138.06,49.45 137.82,49.69 137.82,50.1 137.48,50.44 135.08,50.44 134.82,50.71 134.82,53.05 135,53.24 135.53,53.24 135.84,53.55 135.84,63.25 135.99,63.4 136.47,63.4 136.75,63.68 136.75,64.11 136.97,64.33 137.72,64.33 v2(138.24,64.84)
  20_SIG7 w0.089: v1(55.68,78.19) 56.14,77.72 56.14,76.83 54.69,75.39 54.69,67.47 53.24,66.01 38.61,66.01 36.61,64.01 v1(36.61,37.17)
  BOTTOM w0.152: U33.5 55.38,78.48 v1(55.68,78.19)
FIREFLY_RESET_B: length 21.1
  TOP w0.152: v1(45.06,86.49) 43.59,86.49 43.24,86.14 J6.6
  20_SIG7 w0.089: v1(52.87,76.95) 50.74,76.95 50.4,77.29 49.23,77.29 48.79,77.73 47.78,77.73 47.27,78.25 47.27,80.78 45.12,82.92 45.12,85.46 45.06,85.52 v1(45.06,86.49)
  BOTTOM w0.152: U33.9 53.12,79.17 52.97,79.03 52.97,78.07 53.12,77.91 53.12,77.2 v1(52.87,76.95)
FIREFLY_RESET_LS_B: length 110.9
  TOP w0.152: v2(140.24,66.84) U1.BE24
  18_SIG6 w0.089: v1(66.02,90.23) 61.15,90.23 58.45,87.53 58.45,83.32 v1(55.92,80.78)
  BOTTOM w0.113: 133.63,68.24 136.56,68.24 136.62,68.18 ; 121.64,74.44 124.87,74.44
  BOTTOM w0.152: U33.4 55.85,79.17 56.04,79.36 56.04,80.66 v1(55.92,80.78) ; 124.87,74.44 124.97,74.34 128.44,74.34 128.74,74.04 128.74,73.64 129.04,73.34 129.44,73.34 129.74,73.04 129.74,72.64 130.04,72.34 130.44,72.34 130.74,72.04 130.74,71.64 131.04,71.34 131.44,71.34 131.74,71.04 131.74,70.64 132.04,70.34 132.44,70.34 132.74,70.04 132.74,68.64 133.06,68.32 133.44,68.32 133.52,68.24 133.63,68.24 ; v1(66.02,90.23) 81.95,90.23 82.12,90.4 99.62,90.4 100.74,89.28 100.74,83.64 101.04,83.34 101.44,83.34 101.74,83.04 101.74,82.64 102.04,82.34 102.44,82.34 102.74,82.04 102.74,81.64 103.04,81.34 103.52,81.34 103.74,81.12 103.74,80.64 104.04,80.34 104.44,80.34 104.74,80.04 104.74,79.56 104.95,79.34 105.51,79.34 105.74,79.12 105.74,78.59 105.99,78.33 106.45,78.33 106.74,78.04 106.74,77.69 107.09,77.34 107.44,77.34 107.75,77.03 107.75,76.63 108.04,76.34 117.43,76.34 118.69,75.08 118.69,74.6 118.95,74.34 121.54,74.34 121.64,74.44 ; 136.62,68.18 136.74,68.06 136.74,67.6 137.02,67.32 139.75,67.32 v2(140.24,66.84)
FIREFLY_RX1_N: length 87.4
  TOP w0.104: J6.B18 39.64,67.38 arc(39.64,67.42) 39.67,67.45 39.74,67.53 arc(39.76,67.56) 39.77,67.6 39.77,67.89 arc(39.8,68.05) 39.89,68.18 arc(39.93,68.24) 39.94,68.3 39.94,69.47 arc(39.99,69.69) 40.11,69.88 40.35,70.12 arc(40.51,70.22) 40.69,70.26 arc(40.83,70.29) 40.94,70.36 41.13,70.56 arc(41.24,70.71) 41.27,70.89 41.27,71.47 arc(41.25,71.57) 41.2,71.65 v1(40.89,71.96)
  TOP w0.114: v2(104.24,42.84) 104.74,43.34 U1.K1
  05_SIG2 w0.109: v2(104.24,42.84) 104.24,43.13 arc(104.21,43.21) 104.13,43.24 103.04,43.24 arc(102.76,43.36) 102.65,43.63 102.65,43.98 arc(102.57,44.17) 102.39,44.24 95.04,44.24 arc(94.82,44.28) 94.64,44.41 94.49,44.56 arc(94.43,44.6) 94.36,44.61 93.86,44.61 arc(93.79,44.6) 93.72,44.55
  05_SIG2 w0.152: 93.72,44.55 87.36,44.55 arc(86.73,44.68) 86.2,45.04 84.83,46.4 arc(84.28,46.77) 83.63,46.9 72.2,46.9 arc(71.54,47.03) 70.98,47.41 arc(70.36,47.82) 69.62,47.97 69.24,47.97 arc(68.27,48.16) 67.44,48.71 arc(66.29,50.43) 65.89,52.46 65.89,55.86 arc(65.82,56.2) 65.63,56.49 57.76,64.35 57.31,64.8 arc(55.65,65.91) 53.7,66.29 44.37,66.29 arc(43.53,66.64) 43.18,67.49 43.18,69.65 arc(43.05,69.97) 42.73,70.1 42.03,70.1 arc(41.44,70.34) 41.2,70.93 41.2,71.59 arc(41.18,71.65) 41.15,71.7 v1(40.89,71.96)
FIREFLY_RX1_P: length 87.3
  TOP w0.104: v1(41.89,71.96) 41.58,71.65 arc(41.52,71.57) 41.5,71.46 41.5,70.89 arc(41.45,70.63) 41.3,70.4 41.1,70.2 arc(40.91,70.08) 40.69,70.03 arc(40.6,70.01) 40.52,69.96 40.28,69.72 arc(40.2,69.61) 40.17,69.47 40.17,68.3 arc(40.14,68.15) 40.05,68.02 arc(40.02,67.96) 40,67.89 40,67.6 arc(40.01,67.56) 40.03,67.53 40.11,67.45 arc(40.13,67.42) 40.14,67.38 J6.B17
  TOP w0.114: U1.K2 104.74,44.34 v2(104.24,43.84)
  05_SIG2 w0.109: 93.72,44.93 93.75,44.91 arc(93.85,44.84) 93.97,44.81 94.36,44.81 arc(94.51,44.78) 94.63,44.7 94.78,44.55 arc(94.9,44.47) 95.04,44.44 102.39,44.44 arc(102.71,44.31) 102.85,43.98 102.85,43.63 arc(102.91,43.5) 103.04,43.44 104.13,43.44 arc(104.21,43.48) 104.24,43.55 v2(104.24,43.84)
  05_SIG2 w0.152: v1(41.89,71.96) 41.62,71.7 arc(41.59,71.65) 41.58,71.59 41.58,70.93 arc(41.71,70.61) 42.03,70.48 42.73,70.48 arc(43.32,70.23) 43.56,69.65 43.56,69.15 arc(43.63,68.98) 43.8,68.91 arc(43.97,68.84) 44.04,68.67 44.04,68.39 arc(43.97,68.22) 43.8,68.15 arc(43.63,68.08) 43.56,67.9 43.56,67.49 arc(43.8,66.91) 44.37,66.67 53.7,66.67 arc(55.8,66.26) 57.58,65.07 59.1,63.55 arc(59.1,63.55) 59.1,63.55 59.12,63.54 65.9,56.76 arc(66.17,56.35) 66.27,55.86 66.27,52.46 arc(66.64,50.58) 67.71,48.98 arc(68.41,48.51) 69.24,48.35 69.62,48.35 arc(70.5,48.17) 71.25,47.68 arc(71.68,47.38) 72.2,47.28 83.63,47.28 arc(84.42,47.12) 85.1,46.67 86.47,45.3 arc(86.88,45.03) 87.36,44.93 93.72,44.93
FIREFLY_RX2_N: length 87.3
  TOP w0.104: v1(39.39,63.43) 39.66,63.71 arc(39.74,63.83) 39.77,63.97 39.77,64.46 arc(39.76,64.53) 39.72,64.58 39.67,64.63 arc(39.65,64.67) 39.64,64.72 J6.A18
  TOP w0.114: v2(102.24,42.84) 102.74,43.34 U1.H1
  05_SIG2 w0.109: v2(102.24,42.84) 102.24,43.13 arc(102.2,43.21) 102.13,43.24 102.02,43.24 arc(101.89,43.19) 101.84,43.06 101.84,42.49 arc(101.86,42.4) 101.91,42.32 101.93,42.3 101.93,42.28
  05_SIG2 w0.152: 101.93,42.28 101.93,42.02 arc(101.54,41.07) 100.59,40.68 85.41,40.68 arc(84.59,40.84) 83.89,41.31 82.8,42.4 arc(82.47,42.62) 82.09,42.7 69.86,42.7 arc(68.28,43.01) 66.94,43.91 60.04,50.81 arc(59.23,52.02) 58.95,53.44 58.95,57.13 arc(58.84,57.67) 58.54,58.13 58.13,58.54 arc(57.7,58.82) 57.2,58.92 47.43,58.92 arc(46.53,58.74) 45.76,58.23 44.82,57.29 arc(44.51,57.08) 44.15,57.01 38.7,57.01 arc(38.06,57.28) 37.8,57.92 37.8,59.83 arc(37.9,60.36) 38.2,60.82 38.61,61.22 arc(38.61,61.23) 38.62,61.23 39.57,62.18 arc(39.66,62.32) 39.7,62.49 39.7,63.06 arc(39.68,63.12) 39.65,63.17 v1(39.39,63.43)
FIREFLY_RX2_P: length 87.3
  TOP w0.104: J6.A17 40.14,64.73 arc(40.13,64.67) 40.09,64.62 40.05,64.58 arc(40.01,64.53) 40,64.47 40,63.96 arc(40.03,63.83) 40.1,63.72 v1(40.39,63.43)
  TOP w0.114: U1.H2 102.74,44.34 v2(102.24,43.84)
  05_SIG2 w0.109: 101.55,42.28 101.55,42.3 101.56,42.32 arc(101.62,42.4) 101.64,42.49 101.64,43.06 arc(101.75,43.33) 102.02,43.44 102.13,43.44 arc(102.2,43.48) 102.24,43.55 v2(102.24,43.84)
  05_SIG2 w0.152: v1(40.39,63.43) 40.12,63.17 arc(40.09,63.12) 40.08,63.06 40.08,62.49 arc(40.01,62.18) 39.83,61.91 39.65,61.72 arc(39.6,61.61) 39.65,61.49 arc(39.72,61.33) 39.65,61.16 39.44,60.95 arc(39.28,60.89) 39.11,60.95 arc(39,61) 38.88,60.95 38.47,60.55 arc(38.25,60.22) 38.18,59.83 38.18,59.46 arc(38.23,59.33) 38.35,59.28 arc(38.48,59.23) 38.53,59.1 38.53,58.69 arc(38.48,58.57) 38.35,58.52 arc(38.23,58.46) 38.18,58.34 38.18,57.92 arc(38.33,57.55) 38.7,57.39 44.15,57.39 arc(44.37,57.44) 44.55,57.56 45.49,58.5 arc(46.38,59.09) 47.43,59.3 57.2,59.3 arc(57.85,59.17) 58.39,58.81 58.81,58.4 arc(59.19,57.82) 59.33,57.13 59.33,53.44 arc(59.58,52.17) 60.31,51.08 67.21,44.18 arc(68.43,43.36) 69.86,43.08 82.09,43.08 arc(82.62,42.97) 83.07,42.67 84.16,41.58 arc(84.73,41.19) 85.41,41.06 100.59,41.06 arc(101.27,41.34) 101.55,42.02 101.55,42.28
FIREFLY_RX3_N: length 80.9
  TOP w0.104: v1(40.89,68.52) 41.18,68.23 arc(41.25,68.13) 41.27,68 41.27,67.49 arc(41.26,67.43) 41.23,67.38 41.18,67.33 arc(41.15,67.28) 41.14,67.23 J6.B15
  TOP w0.114: v2(100.24,42.84) 100.74,43.34 U1.F1
  05_SIG2 w0.109: v2(100.24,42.84) 100.24,43.13 arc(100.2,43.21) 100.13,43.24 99.98,43.24 arc(99.87,43.2) 99.83,43.09 99.83,42.48 arc(99.67,42.12) 99.31,41.97 98.93,41.97 arc(98.85,41.95) 98.78,41.91 98.75,41.88 98.73,41.88
  05_SIG2 w0.152: v1(40.89,68.52) 41.15,68.26 arc(41.18,68.21) 41.2,68.15 41.2,65.42 arc(41.18,65.36) 41.15,65.31 41.14,65.3 arc(41.11,65.25) 41.1,65.19 41.1,62.85 arc(41.38,62.17) 42.06,61.89 46.98,61.89 arc(47.14,61.86) 47.27,61.77 arc(47.56,61.58) 47.91,61.51 55.61,61.51 arc(56.83,61.26) 57.87,60.57 60.16,58.28 arc(60.72,57.44) 60.92,56.44 60.92,54.08 arc(61.38,51.79) 62.67,49.85 67.78,44.74 arc(68.9,43.99) 70.22,43.73 78.83,43.73 arc(79.34,43.83) 79.78,44.12 arc(80.22,44.41) 80.74,44.52 81.45,44.52 arc(82.33,44.34) 83.07,43.85 83.57,43.35 84.25,42.67 arc(85.12,42.09) 86.15,41.88 98.73,41.88
FIREFLY_RX3_P: length 80.9
  TOP w0.104: J6.B14 41.64,67.24 arc(41.63,67.29) 41.6,67.33 41.55,67.38 arc(41.51,67.43) 41.5,67.5 41.5,67.98 arc(41.53,68.13) 41.61,68.25 v1(41.89,68.52)
  TOP w0.114: U1.F2 100.74,44.34 v2(100.24,43.84)
  05_SIG2 w0.109: v2(100.24,43.84) 100.24,43.55 arc(100.2,43.48) 100.13,43.44 99.98,43.44 arc(99.73,43.34) 99.62,43.09 99.62,42.48 arc(99.53,42.26) 99.31,42.17 98.93,42.17 arc(98.85,42.19) 98.78,42.24 98.75,42.26 98.73,42.26
  05_SIG2 w0.152: 98.73,42.26 86.15,42.26 arc(85.26,42.44) 84.51,42.94 83.34,44.12 arc(82.47,44.69) 81.45,44.9 80.74,44.9 arc(80.07,44.76) 79.51,44.39 arc(79.2,44.18) 78.83,44.11 70.22,44.11 arc(69.05,44.34) 68.05,45.01 62.94,50.12 arc(61.73,51.93) 61.3,54.08 61.3,56.44 arc(61.07,57.58) 60.43,58.55 58.14,60.84 arc(56.98,61.61) 55.61,61.89 47.91,61.89 arc(47.71,61.93) 47.54,62.04 arc(47.28,62.21) 46.98,62.27 42.06,62.27 arc(41.65,62.44) 41.48,62.85 41.48,65.03 arc(41.49,65.09) 41.53,65.15 arc(41.56,65.2) 41.58,65.27 41.58,65.61 arc(41.65,65.79) 41.84,65.87 arc(42.02,65.94) 42.1,66.13 42.1,66.37 arc(42.02,66.55) 41.84,66.63 arc(41.65,66.7) 41.58,66.89 41.58,68.15 arc(41.59,68.21) 41.62,68.26 v1(41.89,68.52)
FIREFLY_RX4_N: length 72.4
  TOP w0.104: v1(42.87,63.12) 42.51,63.47 arc(42.48,63.49) 42.44,63.5 41.81,63.5 arc(41.43,63.66) 41.27,64.04 41.27,64.36 arc(41.26,64.4) 41.24,64.43 41.17,64.5 arc(41.14,64.54) 41.14,64.58 J6.A15
  TOP w0.114: U1.D1 98.74,43.34 v2(98.24,42.84)
  05_SIG2 w0.109: v2(98.24,42.84) arc(98.12,43.12) 97.84,43.24 95.25,43.24 arc(95.14,43.22) 95.04,43.15
  05_SIG2 w0.152: v1(42.87,63.12) 43.13,63.38 arc(43.18,63.41) 43.24,63.42 43.99,63.42 arc(44.46,63.62) 44.65,64.09 44.65,64.46 arc(44.78,64.77) 45.09,64.9 53.79,64.9 arc(55.16,64.63) 56.32,63.85 62.14,58.03 arc(62.43,57.59) 62.53,57.08 62.53,52.89 arc(62.75,51.78) 63.38,50.84 66.93,47.29 arc(68.66,46.13) 70.71,45.73 83.34,45.73 arc(83.76,45.64) 84.11,45.41 85.17,44.35 arc(86.49,43.46) 88.06,43.15 95.04,43.15
