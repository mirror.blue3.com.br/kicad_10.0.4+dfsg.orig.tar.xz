# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RLD3_C3_VTERM_0V6_PGOOD: length 227.2
  TOP w0.14: Q41.1 v1(209.91,155.2) ; v1(56.67,129.8) 57.21,130.33 57.59,130.33 57.79,130.54 R1008.2
  07_SIG3 w0.173: v1(49.56,155.42) 49.81,155.17 49.99,155.17 53.88,151.29 53.88,150.22 55.54,148.56 55.54,130.93 v1(56.67,129.8)
  14_SIG4 w0.089: v1(180.51,159.22) 187.11,159.22 189.1,161.21 197.35,161.21 198.8,159.76 204.16,159.76 205.31,158.62 205.31,157.33 205.82,156.82 206.53,156.82 206.71,157.01 209.49,157.01 209.91,156.58 v1(209.91,155.2)
  16_SIG5 w0.089: v1(180.51,159.22) 178.81,160.93 178.81,170.47 176.79,172.49 120.8,172.49 120.24,173.05 107.59,173.05 107.54,173.1 56.79,173.1 54.83,171.14 49.96,171.14 47.82,169 47.82,157.16 v1(49.56,155.42)
  BOTTOM w0.152: U143.9 v1(56.67,129.8)
RLD3_EN: length 4
  TOP w0.14: R1009.2 58.83,129.7 v1(58.4,129.27)
  BOTTOM w0.152: U143.7 57.67,130.59 58.4,129.86 v1(58.4,129.27)
RLD3_REFIN: length 3.5
  BOTTOM w0.152: C1289.1 R992.1 55.63,135.36 55.67,135.4 R991.2 56.24,134.88 56.17,134.81 U143.1
RLD3_REFOUT: length 3
  TOP w0.14: C1247.1 v1(59.93,130.23)
  BOTTOM w0.152: U143.6 58.17,130.78 58.72,130.23 v1(59.93,130.23)
RLD3_SENSE: length 92
  TOP w0.152: v1(94.63,107.17) 94.63,106.41 95.3,105.74 102.99,105.74 v1(104.48,107.23)
  BOTTOM w0.152: U143.5 58.17,134.7 58.34,134.87 58.9,134.87 59.29,134.49 59.29,133.98 59.64,133.62 59.64,131.59 60.85,130.38 65.83,130.38 68.45,133 103.25,133 108.24,128 108.24,111 v1(104.48,107.23) ; v1(94.63,107.17) 94.06,106.6 Z87.2
RX_CTRL: length 5.5
  TOP w0.14: U7.38 40.87,137.36 v1(41.14,137.08) 41.91,137.08 42.54,137.72 R65.1
  BOTTOM w0.152: R57.2 41.65,136.58 v1(41.14,137.08)
SDIO_CD: length 31.8
  TOP w0.152: U111.D8 v5(19.5,134.97)
  05_SIG2 w0.173: v1(18.4,155.75) 18.4,151.11 17.96,150.67 17.96,148.29 16.68,147.01 16.68,142.99 16.45,142.76 16.45,134.9 17.11,134.24 18.77,134.24 v5(19.5,134.97)
  BOTTOM w0.152: J83.13 v1(18.4,155.75) 19.56,155.75 20.29,156.49 R1101.2
SDIO_CLK: length 50.7
  TOP w0.152: U111.B7 v5(21.1,135.77)
  18_SIG6 w0.089: v1(10.01,164.13) 14.53,159.61 14.53,159.18 14.44,159.09 13.6,159.09 13.48,158.97 13.48,158.72 13.65,158.55 14.44,158.55 14.53,158.46 14.53,158.11 14.44,158.02 13.27,158.02 13.18,157.92 13.18,157.58 13.26,157.49 14.44,157.49 14.53,157.4 14.53,157.04 14.44,156.95 12.97,156.95 12.88,156.86 12.88,156.51 12.97,156.42 14.44,156.42 14.53,156.33 14.53,155.98 14.44,155.89 12.97,155.89 12.88,155.8 12.88,155.44 12.97,155.35 14.44,155.35 14.53,155.26 14.53,154.01 15.09,153.45 15.09,149.05 18,146.14 18,143.47 18.63,142.84 19.77,142.84 21.5,141.11 21.5,136.17 v5(21.1,135.77)
  BOTTOM w0.152: R1103.1 R1104.1 10.01,162.12 v1(10.01,164.13) 9.48,164.66 U154.12
SDIO_CMD: length 42.7
  TOP w0.152: U111.B10 v5(21.1,132.57)
  18_SIG6 w0.089: v1(10.01,166.29) 16.37,159.93 16.37,157.18 16.24,157.05 15.72,157.05 15.63,156.97 15.63,156.61 15.72,156.52 16.24,156.52 16.33,156.43 16.33,150.97 16.62,150.68 16.62,148.88 19.07,146.43 19.07,144.5 22.3,141.28 22.3,135.51 22.16,135.37 21.68,135.37 21.5,135.19 21.5,132.97 v5(21.1,132.57)
  BOTTOM w0.152: U154.10 9.67,165.96 v1(10.01,166.29)
SDIO_CONN_CLK: length 18.3
  03_SIG1 w0.173: v1(7.72,162.71) 7.72,164.07 8.56,164.91 8.56,166.56 9.76,167.75 10.59,167.75 12.4,165.94 15.77,165.94 16.1,166.26 v1(16.1,167.87)
  BOTTOM w0.152: v1(7.72,162.71) 7.36,163.07 U154.14 ; J83.5 v1(16.1,167.87)
SDIO_CONN_CMD: length 17.5
  03_SIG1 w0.173: v1(18.3,167.87) 18.3,166.35 18.14,166.19 17.42,166.19 17.25,166.37 17.25,167.87 15.55,169.57 9.83,169.57 v1(8.93,168.67)
  BOTTOM w0.152: J83.3 v1(18.3,167.87) ; v1(8.93,168.67) 8.01,167.75 U154.8
SDIO_CONN_DATA0: length 17.2
  03_SIG1 w0.173: v1(6.71,162.77) 6.71,163.84 8.01,165.14 8.01,166.85 10.02,168.86 11.89,168.86 12.29,168.45 12.29,167.11 12.6,166.8 13.61,166.8 13.9,167.09 v1(13.9,167.87)
  BOTTOM w0.152: U154.15 v1(6.71,162.77) ; J83.7 v1(13.9,167.87)
SDIO_CONN_DATA1: length 22.5
  BOTTOM w0.152: J83.8 12.8,168.93 12.52,168.66 10.74,168.66 9.96,169.44 9.96,173.08 9.8,173.23 9.14,173.23 8.99,173.08 8.99,170.36 8.66,170.03 8.13,170.03 7.8,170.36 7.8,172.75 7.62,172.92 7.06,172.92 6.86,172.72 6.86,169.85 6.06,169.05 U154.5
SDIO_CONN_DATA2: length 19.4
  03_SIG1 w0.173: v1(6.71,168.75) 8.73,170.76 17.61,170.76 v1(20.5,167.87)
  BOTTOM w0.152: U154.6 v1(6.71,168.75) ; J83.1 v1(20.5,167.87)
SDIO_CONN_DATA3: length 17
  03_SIG1 w0.173: v1(7.8,168.7) 9.26,170.17 17.34,170.17 19.4,168.11 v1(19.4,167.87)
  BOTTOM w0.152: v1(7.8,168.7) 7.36,168.27 U154.7 ; J83.2 v1(19.4,167.87)
SDIO_DATA0: length 51.1
  TOP w0.152: U111.D6 v5(19.5,136.57)
  18_SIG6 w0.089: v1(1.17,163.14) 2.04,162.27 2.04,159.58 2.86,158.76 2.86,158.63 2.49,158.26 2.49,158.14 2.75,157.88 2.87,157.88 3.24,158.25 3.37,158.25 3.62,158 3.62,157.88 3.25,157.51 3.25,157.38 3.5,157.13 3.63,157.13 3.99,157.5 4.12,157.5 4.37,157.25 4.37,157.12 4,156.75 4,156.63 4.25,156.38 4.38,156.38 4.75,156.75 4.87,156.75 5.13,156.49 5.13,156.37 4.76,156 4.76,155.87 5.01,155.62 5.13,155.62 5.5,155.99 5.77,155.99 6.12,155.64 6.12,155.41 5.69,154.98 5.69,154.75 5.85,154.59 6.08,154.59 6.51,155.02 6.74,155.02 6.9,154.85 6.9,154.62 6.47,154.19 6.47,153.96 6.64,153.8 6.87,153.8 7.3,154.23 7.53,154.23 7.69,154.07 7.69,153.84 7.26,153.41 7.26,153.18 7.42,153.02 7.65,153.02 8.08,153.45 8.31,153.45 11.72,150.04 11.72,149.66 12.52,148.85 12.52,147.79 14.15,146.17 14.15,143.45 15.07,142.53 15.56,142.53 16.32,141.77 16.32,137.4 16.75,136.97 19.1,136.97 v5(19.5,136.57)
  BOTTOM w0.152: v1(1.17,163.14) 1.39,162.92 4.46,162.92 5.2,163.66 U154.1
SDIO_DATA1: length 51
  TOP w0.152: U111.C6 v5(20.3,136.57)
  18_SIG6 w0.089: v5(20.3,136.57) 20.3,136.8 19.9,137.2 19.9,140.82 19.25,141.47 18.12,141.47 16.59,143.01 16.01,143.01 15.42,143.6 15.42,146.12 13.08,148.47 13.08,149.08 12.43,149.73 12.43,150.69 11.44,151.68 11.44,151.9 11.84,152.3 11.84,152.53 11.68,152.69 11.45,152.69 11.05,152.3 10.82,152.3 10.66,152.46 10.66,152.69 11.06,153.09 11.06,153.32 10.9,153.48 10.67,153.48 10.27,153.08 10.04,153.08 8.43,154.69 8.43,154.92 8.9,155.4 8.9,155.63 8.74,155.79 8.51,155.79 8.04,155.31 7.81,155.31 7.09,156.03 6.97,156.03 6.81,155.87 6.69,155.87 6.43,156.13 6.43,156.25 6.59,156.4 6.59,156.53 6.41,156.71 6.28,156.71 6.1,156.53 5.98,156.53 5.73,156.78 5.73,156.91 5.91,157.09 5.91,157.21 5.65,157.46 5.53,157.46 5.35,157.29 5.22,157.29 4.97,157.54 4.97,157.66 5.15,157.84 5.15,157.97 4.9,158.22 4.77,158.22 4.59,158.04 4.47,158.04 4.22,158.29 4.22,158.42 4.4,158.6 4.4,158.72 4.15,158.97 4.02,158.97 3.84,158.79 3.71,158.79 3.46,159.05 3.46,159.17 3.64,159.35 3.64,159.48 2.64,160.48 2.64,165.29 v1(1.41,166.52)
  BOTTOM w0.152: v1(1.41,166.52) 1.97,165.96 U154.3
SDIO_DATA2: length 48.8
  TOP w0.152: U111.B9 v5(21.1,133.37)
  18_SIG6 w0.089: v1(1.41,167.82) 3.3,165.93 3.3,161.01 6.99,157.33 8.1,157.33 13.84,151.59 13.84,149.18 16.67,146.35 16.67,143.71 18.22,142.16 19.4,142.16 20.7,140.86 U111.B9 v5(21.1,133.37)
  BOTTOM w0.152: U154.4 2.62,166.61 v1(1.41,167.82)
SDIO_DATA3: length 49.3
  TOP w0.152: U111.D10 v5(19.5,132.57)
  18_SIG6 w0.089: v1(10.01,167.16) 17.68,159.49 17.68,154.02 17.77,153.93 17.92,153.93 18.01,153.84 18.01,153.48 17.92,153.4 17.77,153.4 17.68,153.31 17.68,151.17 18.1,150.75 18.1,148.68 19.85,146.93 19.85,144.51 23.42,140.94 23.42,139.29 22.78,138.66 22.78,136.83 23.8,135.81 23.8,131.78 23.32,131.29 22.61,131.29 22.33,131.57 22.33,131.98 22.14,132.17 19.9,132.17 v5(19.5,132.57)
  BOTTOM w0.152: v1(10.01,167.16) 9.71,167.16 9.15,166.61 U154.9
SI570_0_OUTPUT_N: length 40.2
  TOP w0.104: U157.4 177.09,17.07 177.23,16.93 177.38,16.93 177.47,17.02 177.47,17.83 177.34,17.96 176.95,17.96 v1(176.65,17.66) ; R36.1 204.95,15.15 204.95,14.78 v1(204.6,14.43)
  18_SIG6 w0.089: v1(204.6,14.43) 204.82,14.66 205.03,14.66 205.25,14.88 205.25,15.07 205.08,15.24 200.06,15.24 198.39,13.56 186.63,13.56 182.11,18.07 177.69,18.07 177.6,17.99 177.6,17.78 177.51,17.69 177.25,17.69 177.16,17.78 177.16,17.99 177.07,18.07 176.74,18.07 176.65,17.99 v1(176.65,17.66)
  BOTTOM w0.104: U18.5 204.85,16.11 204.95,16 204.95,14.78 v1(204.6,14.43)
SI570_0_OUTPUT_P: length 40.3
  TOP w0.104: v1(176.65,18.59) 177.05,18.19 177.43,18.19 177.7,17.92 177.7,16.93 177.47,16.7 177.18,16.7 177.04,16.57 U157.3 ; R36.2 205.18,15.15 205.18,14.78 v1(205.53,14.43)
  18_SIG6 w0.089: v1(176.65,18.59) 176.89,18.35 182.23,18.35 186.74,13.84 198.27,13.84 199.95,15.52 205.2,15.52 205.53,15.19 v1(205.53,14.43)
  BOTTOM w0.104: v1(205.53,14.43) 205.18,14.78 205.18,16 205.28,16.11 U18.4
SI570_1_OUTPUT_N: length 10.6
  TOP w0.104: R687.1 110.64,25.59 v1(110.72,25.66) 110.72,25.07 110.79,25 U32.5 ; v1(109.13,24.07) 109.08,24.12 U104.7
  14_SIG4 w0.089: v1(109.13,24.07) 109.13,23.87 109.04,23.79 108.42,23.79 108.16,24.05 108.16,24.53 109.69,26.06 109.8,26.06 109.88,25.97 109.88,25.75 109.97,25.66 110.15,25.66 110.24,25.75 110.24,25.97 110.33,26.06 110.63,26.06 110.72,25.97 v1(110.72,25.66)
SI570_1_OUTPUT_P: length 10.7
  TOP w0.104: U32.4 111.31,27.54 110.97,27.2 110.97,26.75 v1(110.74,26.53) 110.68,26.59 R687.2 ; v1(109.1,23.31) 108.79,23.62 U104.6
  14_SIG4 w0.089: v1(109.1,23.31) 108.9,23.51 108.31,23.51 107.88,23.93 107.88,24.65 109.57,26.34 110.56,26.34 v1(110.74,26.53)
SI5328_CLOCK1_C_N: length 47.8
  TOP w0.104: v2(111.24,49.84) U1.U8 ; C24.2 v1(91.44,22.45)
  16_SIG5 w0.076: 108.9,42.27 108.9,42.29 108.86,42.33 108.86,44.26 108.82,44.3 108.82,46.39 108.86,46.43 108.86,49.13 108.84,49.15 108.84,51.02 109.06,51.24 110.53,51.24 110.66,51.11 110.66,50.69 110.88,50.47 111.13,50.47 111.24,50.36 v2(111.24,49.84)
  16_SIG5 w0.089: v1(91.44,22.45) 91.38,22.4 91.38,22.21 91.15,21.98 90.75,21.98 90.58,22.15 90.58,22.68 91.17,23.27 98.16,23.27 103.72,28.83 103.72,30.87 102.72,31.88 102.72,34.9 106.85,39.03 108.9,41.08 108.9,42.27
SI5328_CLOCK1_C_P: length 47.7
  TOP w0.104: v1(91.35,21.36) 90.72,21.36 C23.2 ; v2(111.24,50.84) U1.U9
  16_SIG5 w0.076: 108.62,42.27 108.62,42.29 108.66,42.33 108.66,44.17 108.62,44.21 108.62,46.48 108.66,46.52 108.66,49.05 108.64,49.07 108.64,51.1 108.98,51.44 110.61,51.44 110.86,51.19 110.86,50.77 110.94,50.69 111.08,50.69 v2(111.24,50.84)
  16_SIG5 w0.089: 108.62,42.27 108.62,41.19 102.44,35.01 102.44,31.76 103.44,30.76 103.44,28.95 98.05,23.55 91.06,23.55 90.3,22.8 90.3,22.03 90.64,21.7 91.01,21.7 v1(91.35,21.36)
SI5328_CLOCK1_N: length 2.1
  TOP w0.104: U57.29 88.44,22.1 88.57,21.97 89.19,21.97 C24.1
SI5328_CLOCK1_P: length 2.1
  TOP w0.104: U57.28 88.44,21.6 88.57,21.74 89.24,21.74 C23.1
SI5328_CLOCK2_C_N: length 37.8
  TOP w0.104: C1363.2 91.47,24.31 91.48,24.31 v1(91.48,24.44) ; v2(107.24,49.84) U1.N8
  16_SIG5 w0.076: 104.9,42.24 104.9,42.26 104.86,42.3 104.86,44.4 104.82,44.44 104.82,47.32 104.85,47.35 104.85,49.36 104.84,49.37 104.84,51.05 105.03,51.24 106.42,51.24 106.65,51.01 106.65,50.42 106.81,50.25 107.12,50.25 107.24,50.14 v2(107.24,49.84)
  16_SIG5 w0.089: v1(91.48,24.44) 91.61,24.44 91.9,24.74 92.36,24.74 98.15,30.53 98.15,34.33 104.9,41.08 104.9,42.24
SI5328_CLOCK2_C_P: length 37.8
  TOP w0.104: C1364.2 v1(91.74,25.45) ; v2(107.24,50.84) U1.N9
  16_SIG5 w0.076: v2(107.24,50.84) 107.24,50.54 107.15,50.45 106.91,50.45 106.84,50.52 106.84,51.09 106.5,51.44 104.95,51.44 104.64,51.13 104.64,49.29 104.66,49.27 104.66,47.43 104.62,47.4 104.62,44.36 104.66,44.32 104.66,42.3 104.62,42.26 104.62,42.24
  16_SIG5 w0.089: v1(91.74,25.45) 91.74,25.14 91.86,25.02 92.24,25.02 97.87,30.65 97.87,34.45 102.08,38.66 104.62,41.2 104.62,42.24
SI5328_CLOCK2_N: length 2.1
  TOP w0.104: C1363.1 89.24,24.74 88.57,24.74 88.44,24.6 U57.34
SI5328_CLOCK2_P: length 2.1
  TOP w0.104: U57.35 88.44,25.1 88.57,24.97 89.19,24.97 C1364.1
SI5328_INT_ALM: length 30.1
  TOP w0.152: U57.3 v1(86.08,27.15)
  18_SIG6 w0.089: v1(61.38,30.56) 62.5,29.44 83.79,29.44 v1(86.08,27.15)
  BOTTOM w0.152: U17.12 61.7,30.35 61.49,30.56 v1(61.38,30.56)
SI5328_INT_ALM_LS: length 68.3
  TOP w0.152: v2(102.24,61.84) U1.H20
  18_SIG6 w0.089: v2(102.24,61.84) 101.96,61.84 101.46,61.34 97.98,61.34 97.74,61.1 97.74,49.59 97.49,49.34 94.99,49.34 93.65,48 93.65,37.7 88.6,32.65 68.64,32.65 67.97,33.32 63.61,33.32 v1(62.05,34.88)
  BOTTOM w0.152: v1(62.05,34.88) 61.7,34.53 U17.9
SI5328_RST_B: length 88.6
  TOP w0.152: U57.1 v1(87.08,27.15)
  05_SIG2 w0.173: v1(66.24,59.41) 64.76,59.41 56.93,67.25 v1(55.46,67.25)
  16_SIG5 w0.089: v1(55.46,67.25) 62.54,60.16 62.54,47.29 61.93,46.68 61.93,40.86 66.6,36.19 66.6,31.89 68.77,29.72 87.08,29.72 87.6,29.2 87.6,27.66 v1(87.08,27.15)
  BOTTOM w0.152: v1(66.24,59.41) 65.43,59.41 61.05,55.04 U3.13
SI5328_RST_LS_B: length 109.7
  TOP w0.152: v2(138.24,62.84) U1.BC21
  03_SIG1 w0.173: v1(63.83,66.17) 63.83,68.38 v1(66.14,70.69)
  BOTTOM w0.113: v2(138.24,62.84) 138.13,62.84 137.54,62.26 136.93,62.26 136.74,62.06
  BOTTOM w0.152: 136.74,62.06 136.74,61.64 136.44,61.34 136.09,61.34 135.74,60.98 135.74,60.64 135.44,60.34 134.98,60.34 134.74,60.1 134.74,59.64 134.44,59.34 132.04,59.34 131.74,59.64 131.74,60.04 131.43,60.35 131.03,60.35 130.76,60.62 130.76,61.02 130.44,61.34 130.04,61.34 129.74,61.64 129.74,62.06 129.45,62.34 129.04,62.34 128.74,62.64 128.74,63.04 128.44,63.34 128.02,63.34 127.74,63.63 127.74,64.04 127.44,64.34 118.77,64.34 117.43,65.67 115.18,65.67 114.74,65.23 114.74,64.64 114.44,64.34 114.04,64.34 113.74,64.04 113.74,63.64 113.44,63.34 110.04,63.34 109.8,63.11 109.8,62.71 109.42,62.33 109.03,62.33 108.71,62.02 108.71,61.62 108.44,61.34 108.04,61.34 107.74,61.04 107.74,59.64 107.44,59.34 94.42,59.34 91.69,56.61 84.73,56.61 84,57.34 84,59.07 83.05,60.02 82.43,60.02 81.96,60.49 81.96,65.96 80.91,67.01 67.87,67.01 66.14,68.73 v1(66.14,70.69) ; U3.8 61.05,60.78 62.84,62.56 R1092.2 63.44,63.36 63.83,63.75 v1(63.83,66.17)
SI5328_SCL: length 218.2
  TOP w0.152: U57.22 84.58,20.39 83.75,19.56 80.22,19.56 78.7,18.04 v1(77.78,18.04)
  18_SIG6 w0.089: v1(59.85,147.95) 59.74,148.06 59.62,148.06 57.92,146.36 57.92,146.24 58.48,145.68 58.48,145.55 58.29,145.36 58.17,145.36 57.61,145.92 57.48,145.92 57.3,145.73 57.3,145.61 57.93,144.97 57.93,144.85 57.74,144.66 57.62,144.66 56.98,145.29 56.86,145.29 56.67,145.1 56.67,144.98 57.3,144.35 57.3,144.22 57.11,144.03 56.99,144.03 56.35,144.66 56.23,144.66 52.99,141.43 51.23,141.43 49.58,139.78 49.58,134.32 46.76,131.5 46.76,128.24 43.95,125.43 43.95,119.98 43.28,119.3 43.28,116.79 41.12,114.63 37.95,114.63 32.69,109.37 31.15,109.37 27.07,105.29 21.49,105.29 19.2,103 19.2,94.39 22.48,91.11 22.48,87.16 23.38,86.26 23.38,74.61 30.38,67.61 30.38,55.53 31.74,54.17 31.74,32.91 44.91,19.74 44.91,18.66 46.39,17.18 48.15,17.18 48.89,17.93 52.6,17.93 52.79,17.73 61.6,17.73 62.51,16.81 73.51,16.81 74.17,17.48 74.17,18.24 74.55,18.62 77.2,18.62 v1(77.78,18.04)
  BOTTOM w0.152: U28.14 59.09,147.19 v1(59.85,147.95) R612.2
SI5328_SDA: length 219.6
  TOP w0.152: U57.23 85.08,20.39 83.78,19.08 80.25,19.08 78.92,17.75 78.92,16.43 77.88,15.39 74.93,15.39 74.3,16.03 74.3,17.47 v1(74.9,18.07)
  18_SIG6 w0.089: v1(59.84,149.1) 59.84,148.94 52.86,141.96 51.09,141.96 49.11,139.98 49.11,134.51 46.29,131.69 46.29,128.44 43.48,125.63 43.48,120.37 42.7,119.58 42.7,117.09 40.79,115.19 37.82,115.19 32.47,109.84 30.96,109.84 26.87,105.76 21.3,105.76 18.73,103.19 18.73,94.19 22,90.93 22,86.98 22.91,86.06 22.91,74.42 29.91,67.42 29.91,55.72 29.91,55.33 31.27,53.97 31.27,32.71 44.44,19.54 44.44,18.47 46.19,16.71 48.35,16.71 49.09,17.46 52.4,17.46 52.6,17.26 61.4,17.26 62.32,16.34 73.7,16.34 74.65,17.29 74.65,17.83 v1(74.9,18.07)
  BOTTOM w0.152: U28.13 58.58,147.84 v1(59.84,149.1) arc(59.86,149.08) 59.89,149.08 R611.2
SI5328_VCC: length 4.3
  TOP w0.254: U57.5 85.08,27.4 ; U57.10 v1(81.43,25.6) ; v1(88.75,24.23) 88.75,24.01 88.34,23.6 U57.32
  BOTTOM w0.305: v1(81.43,25.6) 81.79,25.96 C26.1
  vias: v1(86.08,28.04) v1(87.08,28.04)
SI5328_XTAL_XA: length 5
  TOP w0.152: U57.6 84.58,27.1 84.45,27.23 84.45,30.02 84.05,30.43 X5.1
SI5328_XTAL_XB: length 5
  TOP w0.152: U57.7 84.08,26.97 83.82,27.23 81.41,27.23 81.2,27.43 X5.3
SIT9122_N: length 3.9
  BOTTOM w0.152: U21.6 34.78,80.05 34.92,80.18 R37.2 34.92,81.41 34.8,81.53 U14.5
SIT9122_P: length 3.9
  BOTTOM w0.152: U21.7 36.05,80.08 35.92,80.21 R37.1 35.92,81.44 36.07,81.58 U14.4
SM_FAN_PWM: length 5.1
  TOP w0.152: v1(173.74,37.64) 173.72,37.66 Q61.1 174.27,38.92 174.77,39.41 R422.2
  BOTTOM w0.152: U31.12 173.04,38.34 v1(173.74,37.64)
SM_FAN_TACH: length 14.1
  BOTTOM w0.152: U31.11 171.31,37.71 171.1,37.5 171.1,37.28 171.31,37.07 U31.10 173.93,37.07 174.32,37.47 175.01,37.47 175.62,36.86 175.62,36.27 176.07,35.81 176.07,33.33 J73.3 178.33,32.34 R1327.2
SYS1V0_LX: length 6.2
  TOP w0.203: 13.52,118.94 13.52,118.81 13.9,118.43 U124.A2
  TOP w0.381: L63.1 15.13,121.18 13.52,119.57 13.52,118.94
  vias: v1(16.33,125.23) v1(16.33,124.08) v1(16.33,122.94) v1(17.09,125.23) v1(17.09,124.08) v1(17.09,122.94)
SYS2V5_LX: length 0.8
  TOP w0.305: U151.A2 59.67,122.16
SYS_1V0: length 59.3
  TOP w0.254: U7.31 37.05,135.08 v1(37.21,134.92) ; U7.42 41.22,139.36 v1(41.27,139.41) ; v1(37.08,144.07) 37.05,144.04 U7.6 ; U7.24 v1(33.32,136.25)
  TOP w0.381: v1(8.59,123.5) 8.59,122.85 C867.1 7.32,122.85 v1(7.32,123.5) ; U111.G10 v5(17.1,132.57) ; 9.54,123.97 J86.1 ; J86.1 9.54,125.58 ; J86.1 11.15,123.97 ; J86.1 9.28,124.78 ; J86.1 10.35,123.71 ; J86.1 11.42,124.78 ; J86.1 11.15,125.58 ; U111.F9 v5(17.9,133.37) ; v1(4.53,123.5) 4.53,122.85 C868.1 5.8,122.85 v1(5.8,123.5) ; U111.J10 v5(14.7,132.57) ; U111.L10 v5(13.1,132.57) ; U111.E10 v5(18.7,132.57) ; v1(36.58,145.64) 36.63,145.7 C78.1 ; U111.K5 v5(13.9,137.37) ; C134.1 v1(42.41,138.93) ; U111.H5 v5(15.5,137.37) ; U111.G6 v5(17.1,136.57)
  09_PWR1 w0.381: 9.54,123.97 J86.1 ; J86.1 11.15,125.58 ; J86.1 11.42,124.78 ; J86.1 10.35,123.71 ; J86.1 9.28,124.78 ; J86.1 11.15,123.97 ; J86.1 9.54,125.58 ; J86.1 10.35,125.84
  BOTTOM w0.203: v1(30.47,113.87) 30.67,113.67 30.76,113.67 30.95,113.48 U128.16
  BOTTOM w0.254: C111.1 v1(37.08,144.07)
  BOTTOM w0.381: v1(36.58,145.64) 36.9,145.97 C82.1 ; C136.1 33.15,136.07 v1(33.32,136.25) 33.41,136.33 C103.1 ; C135.1 C109.1 37.33,135.05 v1(37.21,134.92) ; C820.1 v1(18.22,127.84) ; C806.1 v1(9.78,127.62) ; R817.1 29.6,114.34 29.84,114.1 30.25,114.1 v1(30.47,113.87) ; C798.1 23.26,128.53 v1(23.04,128.31) ; v1(42.41,138.93) 42.67,138.68 C133.1 ; R814.1 v1(9.44,117.11) ; C865.1 v1(9.3,120.32) ; C821.1 v1(10.66,141.73) ; C834.1 v1(15.36,141.86) ; v1(28.69,128.38) 29.67,129.36 30.23,129.36 30.4,129.54 C788.1 30.4,130.08 30.2,130.28 28.73,130.28 v1(28.6,130.15) ; C833.1 v1(9.08,128.01) ; C822.1 17.71,133.56 v5(17.9,133.37) ; C879.1 v1(14.38,116.26) ; v1(41.27,139.41) 41.27,139.78 40.95,140.11 C110.1
  vias: v1(7.21,125.93) v1(7.21,125.07) v1(9.35,122.78) v1(9.35,121.77) v1(10.49,122.78) v1(10.49,121.77) v1(11.76,122.78) v1(11.76,121.77)
SYS_1V0_PGOOD: length 290.6
  TOP w0.305: U124.C3 15.28,117.29 v1(15.53,117.54)
  TOP w0.381: Q36.1 v1(214.27,155.16)
  03_SIG1 w0.381: v1(14.16,121.59) 14.78,121.59 15.92,120.44 18.84,120.44 22.26,123.86 29.15,123.86 31.6,126.31 31.6,133.1 32.33,133.83 32.33,136.59 33.27,137.53 33.27,141.17 28.55,145.9 28.55,155.02 30.73,157.2 44.66,157.2 v1(45.4,157.94)
  14_SIG4 w0.381: v1(179.11,154.88) 179.58,154.88 182.69,157.99 194.76,157.99 195.91,159.14 202.96,159.14 203.78,158.32 203.78,157.31 204.98,156.11 208.48,156.11 209.17,155.42 209.17,154.93 209.12,154.88 209.12,154.86 209.53,154.45 213.11,154.45 213.81,155.16 v1(214.27,155.16)
  16_SIG5 w0.381: v1(45.4,157.94) 45.4,169.73 49.88,174.22 177.41,174.22 182.25,169.39 182.25,157.46 179.66,154.88 v1(179.11,154.88) ; v1(15.53,117.54) 14.84,118.22 11.93,118.22 11.35,118.81 11.35,119.65 11.61,119.91 12.49,119.91 v1(14.16,121.59)
  BOTTOM w0.381: R828.2 v1(14.16,121.59)
SYS_1V0_POR_B: length 22.3
  TOP w0.305: U124.B3 14.65,117.79 15.04,118.18 15.97,118.18 v1(15.99,118.16)
  TOP w0.381: v1(15.99,118.16) 15.99,118.69 R823.2
  03_SIG1 w0.381: v1(15.99,118.16) 15.99,117.85 18.75,115.09 22.1,115.09 23.83,113.36 28.68,113.36 29.84,114.53 30.78,114.53 31.2,114.12 v1(31.2,114.01)
  BOTTOM w0.203: v1(31.2,114.01) 31.35,113.86 U128.17
SYS_1V8: length 420.5
  TOP w0.254: v1(163.84,16.31) 164.29,16.76 U122.15 ; U7.41 40.89,138.86 v1(41.14,138.61) ; U7.30 36.55,135.16 v1(36.32,134.92) ; v1(167.39,18.75) 167.39,18.75 U122.20 ; U122.24 167.07,20.75 v1(167.36,21.03) ; U7.19 v1(32.51,139.36) ; v1(160.85,20.5) 161.1,20.75 U122.7 ; v1(161.41,18.2) 161.96,18.75 U122.11 ; U122.16 164.79,16.39 v1(164.86,16.31)
  TOP w0.381: R854.1 v1(12.48,113.75) ; U111.J4 v5(14.7,138.17) ; U111.J8 v5(14.7,134.97) ; U111.L6 v5(13.1,136.57) ; v1(168.78,15.04) 168.4,14.66 168.25,14.66 168.19,14.72 R802.1 ; U111.K9 v5(13.9,133.37) ; R39.1 44.49,139.7 v1(45.09,139.7) ; 29.66,131.63 29.66,132.14 29.67,132.15 v1(29.67,132.36) ; v1(43.56,132) 42.92,132.64 42.92,133.09 ; U111.K8 v5(13.9,134.97) ; U111.M3 v5(12.3,138.97) ; U111.E14 v5(18.7,129.37) ; SW16.8 32.46,114.35 v1(32.28,114.17) ; U111.B3 v5(21.1,138.97) ; U111.E4 v5(18.7,138.17) ; R857.1 v1(12.48,106.13) ; U111.B13 v5(21.1,130.17) ; U111.D7 v5(19.5,135.77) ; U111.J6 v5(14.7,136.57) ; U111.H9 v5(15.5,133.37) ; U111.E6 v5(18.7,136.57) ; v1(45.08,142.16) 45.08,141.7 44.53,141.15 R34.1 ; SW15.6 v1(23.89,109.51) ; v1(28.68,131.04) 29.28,130.43 30.28,130.43 30.53,130.18 C796.1 30.53,129.82 30.25,129.54 28.91,129.54 v1(28.65,129.29) ; v1(30.94,132.4) 30.86,132.47 30.86,133.06 L60.1 v1(31.36,134.55) ; U111.A6 v5(21.9,136.57) ; U111.F1 v5(17.9,140.57) ; C780.1 15.45,115.83 v1(15.85,116.23) ; R855.1 v1(12.48,111.21) ; R30.1 v1(28.83,135.53) ; U111.H4 v5(15.5,138.17) ; R206.2 36.86,134.38 v1(36.32,134.92) ; U111.J2 v5(14.7,139.77) ; U111.R4 v5(9.9,138.17) ; SW15.7 v1(23.89,110.78) ; v1(45.09,136.32) 44.83,136.58 R68.1 ; R856.1 v1(12.48,108.67) ; v1(3.81,128.32) 3.57,128.56 R748.1 ; R26.1 v1(28.83,139.34) ; U111.N10 v5(11.5,132.57) ; U111.G4 v5(17.1,138.17) ; R31.1 v1(28.83,136.8) ; U111.P7 v5(10.7,135.77) ; SW15.5 v1(23.89,108.24) ; R1197.1 v1(24.44,143.04) ; R61.1 v1(36.72,131.14) ; U111.M13 v5(12.3,130.17) ; SW15.8 v1(23.89,112.05) ; R205.2 v1(40.8,134.07) ; R803.1 160.96,14.73 v1(161.32,14.38) ; U111.C10 v5(20.3,132.57) ; U111.J12 v5(14.7,130.97) ; R27.1 v1(28.83,140.61) ; U111.R14 v5(9.9,129.37) ; C825.1 v1(8.05,140.52) ; R60.1 v1(41.53,131.12)
  05_SIG2 w0.381: v1(175.87,25.83) 176.45,25.25 176.45,24.18 176.89,23.75 180.85,23.75 181.23,23.37 181.23,21.46 185.93,16.76 194.69,16.76 197.23,19.3 205.82,19.3 208.23,16.89 v1(208.23,14.88)
  11_PWR2 w0.381: 37.32,112.21 J70.1 ; J70.1 39.19,111.4 ; J70.1 37.06,111.4 ; J70.1 38.13,112.47 ; J70.1 38.13,110.34 ; J70.1 38.93,110.6 ; J70.1 37.32,110.6 ; J70.1 38.93,112.21 ; 10.27,102.86 J82.1 ; J82.1 11.07,103.12 ; J82.1 10.01,102.05 ; J82.1 11.88,102.86 ; J82.1 10.27,101.25 ; J82.1 11.88,101.25 ; J82.1 11.07,100.99 ; J82.1 12.14,102.05
  18_SIG6 w0.381: v1(217.98,156.9) 217.28,156.9 216.87,156.48 214.48,156.48 213.56,155.55 213.56,154.76 212.23,153.43 212.23,147.37 210.86,146.01 206.25,146.01 205.12,144.88 195.76,144.88 195.3,144.42 189.15,144.42 189.1,144.38 188.59,144.38 188.54,144.42 185.01,144.42 183.88,143.29 183.88,137.88 184.57,137.19 187.78,137.19 193.19,131.78 207.16,131.78 213.34,125.6 213.34,101.8 212.9,101.36 212.9,93.63 213.34,93.19 213.34,91.31 212.78,90.75 212.78,84.06 213.46,83.38 213.46,82.03 216.6,78.89 216.7,78.89 217.33,78.26 217.33,77.16 217.18,77.01 217.18,59.18 218.79,57.58 226.17,57.58 229.92,53.82 230.36,53.82 231.67,52.51 231.67,37.92 v1(230.86,37.1) 231.19,36.77 231.19,16.61 228.93,14.35 208.76,14.35 v1(208.23,14.88)
  BOTTOM w0.203: U128.13 29.27,111.75 v1(28.83,112.19)
  BOTTOM w0.305: U125.9 37.7,106.67 37.39,106.98
  BOTTOM w0.381: 10.01,102.05 J82.1 ; J82.1 12.14,103.12 ; J82.1 10.01,103.12 ; J82.1 11.07,103.12 ; J82.1 10.01,100.99 ; J82.1 12.14,100.99 ; J82.1 12.14,102.05 ; J82.1 11.07,100.99 ; R1103.2 v1(7.92,159.66) ; R816.1 v1(26.24,111.36) ; C842.1 v1(8.7,138.31) ; C837.1 v1(8.7,130.17) ; U154.2 4.63,165.31 v1(4.07,164.74) 3.57,165.24 C1566.1 ; v1(49.05,140.67) 49.05,140.76 R198.1 ; C849.1 163.89,17.49 163.89,16.36 v1(163.84,16.31) ; R726.1 6.88,128.8 7.15,128.53 v1(7.15,128.36) ; v1(36.32,134.92) 36.19,135.05 C141.1 ; C850.1 161.82,18.62 v1(161.41,18.2) ; C830.1 13.76,133.52 v5(13.9,133.37) ; v5(15.5,133.37) 15.65,133.22 C843.1 ; v1(32.49,132.18) 32.26,132.41 C115.1 ; R860.2 v1(9.53,69.65) ; v1(167.39,18.75) 167.33,18.81 C853.1 ; C848.1 161.12,20.78 v1(160.85,20.5) ; C841.1 15.9,138.57 v5(15.5,138.17) ; R832.1 v1(33.91,107.49) ; R334.1 217.49,156.4 v1(217.98,156.9) ; C140.1 33.15,140 v1(32.51,139.36) 33.01,138.86 C116.1 ; R1101.1 v1(23.16,156.49) ; R56.1 v1(45.08,142.16) ; C805.1 23.7,142.04 v1(24.13,141.6) ; v5(23.09,130.02) 23.28,129.82 R826.1 ; R724.1 29.23,133.55 29.67,133.12 v1(29.67,132.36) ; C828.1 v1(12.11,141.72) ; C79.1 v1(26.67,145.97) ; R776.1 24.81,136.62 v1(25.1,136.91) ; v1(230.86,37.1) R820.1 227.18,37.1 227.08,37 Q23.1 ; v1(41.14,138.61) 40.89,138.86 C83.1 40.13,138.75 C114.1 ; v1(45.16,144.15) 45.11,144.2 R54.1 R55.1 ; R68.1 44.83,136.58 v1(45.09,136.32) ; v1(41.96,145.97) R201.1 ; R1196.1 22.27,134.11 v5(22.86,133.53) ; C852.1 165.05,17.44 165.05,16.51 v1(164.86,16.31) ; R203.1 44.29,139.7 v1(45.09,139.7) ; C775.1 27.25,125.71 v1(27.25,125.22) ; C801.1 v1(20.51,127.65) ; v1(175.87,25.83) 174.96,24.93 D15.3 ; C851.1 v1(167.36,21.03) ; U109.2 v1(24.45,122.4) ; C810.1 16.31,128.04 v1(16.06,127.79) C811.1 ; v1(15.85,116.23) 15.43,115.81 U114.2 ; C825.1 v1(8.05,140.52) ; C808.1 v1(11.87,127.57) ; C803.1 v1(22.23,143.13) ; C142.1 v1(29.6,134.8)
  vias: v1(5.64,127.28) v1(6.5,127.28) v1(13.34,143.81) v1(14.86,143.81) v1(16.03,143.84) v1(17.4,143.84) v1(18.67,143.84) v1(21.34,145.97) v1(21.32,145.1) v1(22.1,145.97) v1(22.1,145.08) v1(37.35,107.74)
SYS_1V8_POR_B: length 70.2
  TOP w0.305: U10.5 45.89,140.34 R163.2
  TOP w0.381: R163.2 45.91,140.99 v1(45.64,141.25)
  07_SIG3 w0.381: v1(42.29,104.32) 37.54,104.32 35.29,106.56 31.1,106.56 29.93,107.74 29.93,110.3 v1(28.88,111.35)
  20_SIG7 w0.381: v1(42.29,104.32) 40.64,105.97 40.64,108.18 39.78,109.04 39.78,115.31 34.55,120.54 34.55,131.04 40.11,136.6 40.11,139.26 41.24,140.39 43.56,140.39 44.37,141.2 45.59,141.2 v1(45.64,141.25)
  BOTTOM w0.203: U128.12 v1(28.88,111.35)
  BOTTOM w0.254: v1(42.29,104.32) R824.2 42.26,105.17 U125.5
SYS_2V2: length 245.7
  TOP w0.152: v1(135.62,114.37) 135.63,114.36 R601.1
  TOP w0.305: v1(47.7,135.08) 47.39,135.39 U10.9
  TOP w0.381: v1(206.63,158.17) 205.96,158.17 R164.1 ; J28.1 52.9,135.14 ; J28.1 51.29,135.14 ; J28.1 52.9,136.75 ; J28.1 51.03,135.94 ; J28.1 51.29,136.75 ; J28.1 52.1,137.01 ; J28.1 53.16,135.94 ; J28.1 52.1,134.87 ; U80.24 134.7,116.32 v1(134.49,116.11) ; R355.1 51.31,140.59 v1(51.97,139.93) ; R166.1 v1(48.11,131.38)
  05_SIG2 w0.381: v1(151.05,143.56) 151.84,142.77 151.84,141.58 151.13,140.87 151.13,139.65 151.94,138.84 151.94,137.36 151.26,136.68 151.26,133.81 148.77,131.32 148.77,130.15 145.68,127.06 145.68,122.5 144.7,121.52 144.23,121.52 143.83,121.12 143.83,120.63 143.43,120.23 142.83,120.23 142.28,119.67 142.28,118.39 v1(139.53,115.64)
  14_SIG4 w0.381: v1(206.63,158.17) 204.42,160.38 200.75,160.38 198.87,162.26 188.57,162.26 186.33,160.02 180.14,160.02 179.35,159.23 179.35,157.99 174.4,153.03 157.65,153.03 151.05,146.44 v1(151.05,143.56)
  18_SIG6 w0.381: v1(57.95,140.08) 57.95,139.83 58.8,138.98 62.31,138.98 62.58,138.71 62.97,138.71 64.87,140.61 v1(65.16,140.61)
  20_SIG7 w0.381: 51.29,136.75 J28.1 ; J28.1 52.9,135.14 ; J28.1 51.29,135.14 ; J28.1 51.03,135.94 ; J28.1 52.1,137.01 ; J28.1 52.9,136.75 ; J28.1 53.16,135.94 ; J28.1 52.1,134.87
  BOTTOM w0.152: v1(135.62,114.37) 135.75,114.37 ; 64.93,140.61 v1(65.16,140.61)
  BOTTOM w0.381: U28.24 57.34,140.69 v1(57.95,140.08) ; R75.1 62.23,140.11 63.05,140.11 63.38,139.78 64.1,139.78 64.93,140.61 ; R354.1 v1(50.9,138.35) ; v1(65.16,140.61) 67.27,140.61 70.66,143.99 103.02,143.99 115.41,131.61 127.92,131.61 129.59,129.93 129.59,125.56 132.25,122.91 132.25,119.72 133.05,118.92 134.82,118.92 135.31,118.44 135.31,116.73 134.92,116.35 134.73,116.35 v1(134.49,116.11) 134.49,115.09 135.21,114.37 v1(135.62,114.37) 135.62,112.46 136.33,111.75 138.96,111.75 140.28,113.07 R602.1 140.28,115.63 R580.1 v1(139.53,115.64) ; 135.75,114.37 C522.1 ; C75.1 v1(56.18,139.83)
  vias: v1(48.46,135.25) v1(51,134.92)
SYS_2V5: length 104.2
  TOP w0.254: C555.1 69.37,56.55 v4(69.16,56.34) ; v4(69.16,42.24) 69.37,42.45 C560.1 ; v4(69.16,84.53) 69.37,84.74 C955.1 ; C697.1 69.37,70.65 v4(69.16,70.44) ; C604.1 80.15,34.84 v4(80.36,35.04) ; C704.1 80.15,63.03 v4(80.36,63.24) ; C707.1 80.15,91.23 v4(80.36,91.43) ; v4(69.16,98.63) 69.37,98.84 C700.1 ; U7.3 v1(38.55,144.07) ; U7.9 v1(35.55,144.07)
  TOP w0.381: U142.M1 v2(70.32,123.17) ; C1054.1 80.18,76.61 80.36,76.79 v4(80.36,77.33) ; J99.1 68.11,126.31 ; J99.1 67.84,127.11 ; J99.1 65.97,126.31 ; J99.1 66.23,127.11 ; J99.1 67.84,125.5 ; J99.1 66.23,125.5 ; J99.1 67.04,127.37 ; J99.1 67.04,125.24 ; v1(60.02,117.86) 59.63,118.26 R1096.1 ; U138.R9 v4(166.76,94.65) ; U137.B1 v4(155.56,73.35) ; U135.B1 v4(155.56,45.16) ; U141.B13 v2(100.23,122.32) ; C603.1 80.36,49.05 v4(80.36,49.14) ; U141.B1 v2(87.23,122.32) ; U135.R9 v4(166.76,52.36) ; v1(41.35,146.63) 41.1,146.39 C80.1 ; U138.B1 v4(155.56,87.45) ; U136.B1 v4(155.56,59.26) ; U141.M1 v2(87.23,111.32) ; U142.M13 v2(70.32,110.17) ; U142.B1 v2(81.32,123.17) ; U139.R9 v4(166.76,38.01) ; U139.B1 v4(155.56,30.81) ; U141.M13 v2(100.23,111.32) ; U137.R9 v4(166.76,80.55) ; U136.R9 v4(166.76,66.46) ; U142.B13 v2(81.32,110.17)
  09_PWR1 w0.381: J99.1 67.84,127.11 ; J99.1 67.04,127.37 ; J99.1 68.11,126.31 ; J99.1 67.84,125.5 ; J99.1 65.97,126.31 ; J99.1 66.23,127.11 ; J99.1 66.23,125.5 ; J99.1 67.04,125.24
  20_SIG7 w0.381: 67.04,125.24 J99.1 ; J99.1 65.97,126.31 ; J99.1 66.23,127.11 ; J99.1 67.04,127.37 ; J99.1 66.23,125.5
  BOTTOM w0.203: U128.10 29.28,110.55 29.23,110.5 28.81,110.5 v1(28.63,110.31)
  BOTTOM w0.254: C1170.1 166.68,66.53 v4(166.76,66.46) ; C1154.1 155.56,87.2 v4(155.56,87.45) ; C1176.1 166.68,94.73 v4(166.76,94.65) ; v4(155.56,30.81) 155.56,30.55 C1160.1 ; v1(38.55,144.07) 38.6,144.01 C113.1 ; v4(155.56,73.35) 156.02,72.89 C1151.1 ; v4(166.76,52.36) 166.68,52.43 C1167.1 ; v4(155.56,45.16) 155.56,44.91 C1145.1 ; v4(166.76,38.01) 166.68,38.08 C1182.1 ; C84.1 35.43,143.95 v1(35.55,144.07) ; C1148.1 155.56,59 v4(155.56,59.26) ; C1173.1 166.68,80.63 v4(166.76,80.55)
  BOTTOM w0.381: R819.1 v1(26.19,107.55) ; U62.R9 v4(69.16,98.63) ; U63.B1 v4(80.36,77.33) ; J99.1 67.04,127.37 ; J99.1 66.23,127.11 ; J99.1 67.04,125.24 ; J99.1 66.23,125.5 ; J99.1 67.84,125.5 ; J99.1 67.84,127.11 ; J99.1 68.11,126.31 ; v1(41.35,146.63) 40.81,146.09 C112.1 ; C1343.1 15.73,121.61 v1(16.18,121.16) ; v2(87.23,122.32) 86.52,123.03 C1281.1 85.1,123.12 84.35,123.88 C1287.1 81.09,123.88 81.09,123.87 ; 81.09,123.87 81.09,123.4 v2(81.32,123.17) ; 81.09,123.87 81.09,125.48 80.36,126.2 72.16,126.2 70.38,124.42 C1301.1 70.38,123.22 v2(70.32,123.17) ; C137.1 v1(33.4,143.04) ; U61.B1 v4(80.36,63.24) ; U61.R9 v4(69.16,70.44) ; v2(101.23,110.32) 101.29,110.38 C1294.1 ; C139.1 v1(40.51,143.04) ; C1288.1 70.13,109.97 v2(70.32,110.17) ; U60.B1 v4(80.36,35.04) ; U63.R9 v4(69.16,84.53) ; v2(87.23,111.32) 87.12,111.43 C1295.1 ; C1280.1 101.16,122.32 v2(100.23,122.32) ; U64.R9 v4(69.16,56.34) ; U64.B1 v4(80.36,49.14) ; C1359.1 v1(60.02,117.86) ; C1300.1 81.54,108.95 81.32,109.17 v2(81.32,109.17) ; U62.B1 v4(80.36,91.43) ; U60.R9 v4(69.16,42.24)
  vias: v1(65.37,127.62) v1(65.37,126.35) v1(65.37,125.08) v1(65.37,123.81) v2(79.32,109.17) v2(101.23,111.32)
SYS_2V5_PGOOD: length 250.4
  TOP w0.305: U151.C3 61.05,120.34 v1(61.3,120.58)
  TOP w0.381: Q6.1 v1(218.93,155.21)
  07_SIG3 w0.381: v1(61.3,120.58) 60.45,120.58 59.56,121.47 59.56,126.86 59.2,127.23 59.2,132.02 59.84,132.66 59.84,134.24 59.08,135 59.08,140.23 56.81,142.5 56.81,148.24 55.45,149.61 55.45,151.2 52.37,154.28 52.37,154.96 v1(50.79,156.54)
  18_SIG6 w0.381: v1(180.43,158.01) 178.59,159.86 178.59,172.84 177.31,174.12 53.21,174.12 46.91,167.82 46.91,157.95 48.43,156.44 50.68,156.44 v1(50.79,156.54)
  20_SIG7 w0.381: v1(180.43,158.01) 194.89,158.01 195.94,159.05 202.9,159.05 203.61,158.34 203.61,157.53 204.41,156.73 208.39,156.73 208.76,157.1 209.68,157.1 210.72,156.06 218.08,156.06 v1(218.93,155.21)
  BOTTOM w0.381: v1(61.3,120.58) 61.08,120.36 R1100.2
SYS_2V5_POR_B: length 47.7
  TOP w0.305: v1(61.39,121.77) 60.84,121.22 60.81,121.22 60.42,120.84 U151.B3
  05_SIG2 w0.381: v1(28.83,109.5) 28.83,108.66 30.84,106.65 33.01,106.65 33.04,106.62 34.62,106.62 36.96,108.96 37.82,108.96 39.88,111.02 39.88,113.09 43.92,117.13 51.98,117.13 53.34,115.77 54.81,115.77 57.29,118.26 59.05,118.26 60.13,119.34 60.13,120.51 v1(61.39,121.77)
  BOTTOM w0.203: v1(28.83,109.5) 29.08,109.75 29.08,109.94 29.28,110.14 29.38,110.14 29.38,110.15 U128.9
  BOTTOM w0.381: R1192.2 62.06,121.07 61.39,121.74 v1(61.39,121.77)
SYSCLK1_300_C_N: length 4.5
  TOP w0.104: U157.10 173.01,16.57 172.87,16.7 172.63,16.7 172.39,16.94 172.39,17.63 173.2,18.44 173.2,19.15 C651.1
SYSCLK1_300_C_P: length 4.5
  TOP w0.104: C650.1 173.6,19.57 173.43,19.4 173.43,18.34 172.62,17.53 172.62,17.03 172.72,16.93 172.87,16.93 173.01,17.07 U157.9
SYSCLK1_300_N: length 168.5
  TOP w0.104: v1(85.34,69.35) 85.26,69.27 R595.1 R597.2 R1177.1 ; v1(170.25,14.38) 169.85,14.77 169.85,19.32 172.02,21.49 173.26,21.49 173.36,21.38 173.36,21.23 173.26,21.13 172.88,21.13 172.78,21.03 C651.2 ; v2(100.24,73.84) U1.F31
  05_SIG2 w0.109: 141.67,47.3 141.67,47.33 141.71,47.37 141.71,48.11 141.57,48.24 137.99,48.24 137.64,48.59 137.64,52.01 137.4,52.24 99.94,52.24 99.64,52.55 99.64,71.09 99.99,71.44 100.46,71.44 100.64,71.62 100.64,73.73 100.53,73.84 v2(100.24,73.84)
  05_SIG2 w0.135: 141.67,47.3 141.67,42.58 140.03,40.95 140.03,35.77 136.78,32.51 136.78,30.96 135.66,29.84 135.66,26.62 137.74,24.54 137.74,20.98 139.57,19.15 139.57,15.77 141.89,13.46 169.51,13.46 170.04,13.99 170.04,14.17 v1(170.25,14.38)
  BOTTOM w0.104: v1(85.34,69.35) 85.34,69.56 85.44,69.66 85.55,69.66 86.08,69.66 90.14,73.72 94.58,73.72 94.94,73.36 99.76,73.36 v2(100.24,73.84)
SYSCLK1_300_P: length 169.1
  TOP w0.104: v1(85.34,70.22) 85.27,70.22 85.22,70.27 R594.1 R596.2 R1177.2 ; v2(101.24,73.84) U1.G31 ; v1(169.32,14.38) 169.63,14.68 169.63,19.41 171.93,21.71 173.35,21.71 173.59,21.48 173.59,21.03 C650.2
  05_SIG2 w0.109: 141.95,47.3 141.95,47.33 141.91,47.37 141.91,48.19 141.66,48.44 138.07,48.44 137.84,48.68 137.84,52.09 137.49,52.44 100.02,52.44 99.84,52.63 99.84,71.01 100.07,71.24 100.55,71.24 100.84,71.53 100.84,73.73 100.95,73.84 v2(101.24,73.84)
  05_SIG2 w0.135: 141.95,47.3 141.95,42.47 140.31,40.83 140.31,35.65 137.06,32.4 137.06,30.85 135.94,29.73 135.94,26.73 138.02,24.65 138.02,21.1 139.85,19.27 139.85,15.89 142,13.74 169.4,13.74 169.76,14.11 169.76,14.24 169.63,14.38 v1(169.32,14.38)
  BOTTOM w0.104: v1(85.34,70.22) 85.67,69.89 85.98,69.89 90.04,73.95 94.57,73.95 94.93,74.31 100.77,74.31 v2(101.24,73.84)
SYSCLK2_300_N: length 83
  TOP w0.104: U157.12 173.08,15.57 172.97,15.67 172.87,15.67 172.74,15.54 172.74,15.25 172.41,14.91 172.31,14.91 v1(171.94,14.54) ; v1(107.36,21.18) 107.01,21.53 107.01,21.76 107.14,21.9 U104.4
  07_SIG3 w0.135: v1(171.94,14.54) 171.64,14.84 170.05,14.84 169.19,15.7 167.94,15.7 167.18,14.94 161.76,14.94 161.38,15.31 154.85,15.31 153.89,14.35 135.65,14.35 135.15,14.85 134.08,14.85 133.45,15.47 132.76,15.47 132.06,14.78 130.57,14.78 129.31,16.04 128.03,16.04 127.15,15.16 125.74,15.16 125.32,14.73 122.04,14.73 120.59,16.18 118.12,16.18 116.86,17.44 114.09,17.44 113.32,16.67 109.55,16.67 108.98,17.25 106.78,17.25 104.61,19.41 104.61,20.71 105.99,22.08 106.67,22.08 107.03,21.72 107.03,21.51 v1(107.36,21.18)
  BOTTOM w0.104: v1(107.36,21.18) 107.36,21.3 107.31,21.35 R38.1
SYSCLK2_300_P: length 83
  TOP w0.104: U157.11 173.14,16.07 172.97,15.9 172.78,15.9 172.52,15.64 172.52,15.34 172.31,15.14 172.22,15.14 v1(171.94,15.42) ; U104.3 106.64,21.91 106.78,21.77 106.78,21.53 v1(106.43,21.18)
  07_SIG3 w0.135: v1(106.43,21.18) 106.75,21.5 106.75,21.6 106.55,21.8 106.1,21.8 104.89,20.59 104.89,19.52 106.89,17.52 109.1,17.52 109.67,16.95 113.21,16.95 113.97,17.72 116.98,17.72 118.24,16.46 120.7,16.46 122.15,15.01 125.2,15.01 125.63,15.44 127.03,15.44 127.92,16.32 129.42,16.32 130.69,15.06 131.95,15.06 132.64,15.75 133.57,15.75 134.2,15.13 135.27,15.13 135.76,14.63 153.77,14.63 154.73,15.59 161.5,15.59 161.87,15.21 162.36,15.21 162.49,15.35 162.49,15.59 162.63,15.72 162.9,15.72 163.03,15.59 163.03,15.35 163.17,15.21 163.44,15.21 163.57,15.35 163.57,15.59 163.71,15.72 163.97,15.72 164.11,15.59 164.11,15.35 164.24,15.21 167.07,15.21 167.83,15.98 169.31,15.98 170.12,15.16 171.69,15.16 v1(171.94,15.42)
  BOTTOM w0.104: R38.2 106.31,21.3 v1(106.43,21.18)
SYSCLK_300_N: length 17.1
  TOP w0.104: U122.21 167.09,19.25 167.23,19.39 167.49,19.39 167.89,19.79 168.03,19.79 168.23,19.59 168.38,19.59 168.53,19.73 168.53,19.88 168.33,20.08 168.33,20.23 169.16,21.06 169.16,21.39 171.15,23.37 174.21,23.37 175.83,21.75 175.83,20.77 175.72,20.67 175.54,20.67 175.44,20.57 R1140.1 175.44,19.48 175,19.03 175,18.56 174.86,18.42 U157.7
SYSCLK_300_P: length 17.1
  TOP w0.104: U157.6 175.36,18.42 175.23,18.56 175.23,18.94 175.5,19.21 175.61,19.21 R1140.2 176.44,20.57 176.34,20.67 176.16,20.67 176.05,20.77 176.05,21.85 174.3,23.6 171.05,23.6 168.94,21.48 168.94,21.16 167.39,19.61 167.23,19.61 167.09,19.75 U122.22
SYSCLK_OEB_ALL: length 3.6
  TOP w0.152: U122.5 163.79,21.92 163.52,22.19 163.52,22.58 162.89,23.22 162.56,23.22 162.18,23.6 R792.1
SYSCLK_RESET: length 3.5
  TOP w0.152: R793.1 163.39,23.48 163.63,23.24 163.96,23.24 164.79,22.42 U122.3
SYSCTLR_AGND: length 3.5
  TOP w0.381: v1(23.93,139.02) 24.1,139.19 U155.3 ; U111.F8 v5(17.9,134.97) ; U111.G8 v5(17.1,134.97)
  BOTTOM w0.381: C1567.2 16.51,134.38 v5(17.1,134.97)
  vias: v1(24.1,140.69) v1(24.08,139.83) v1(25.37,141.33) v1(27.69,136.7) v1(27.69,135.81)
SYSCTLR_CFG_JTAG_TCK: length 4.3
  TOP w0.152: U111.N7 v5(11.5,135.77)
  BOTTOM w0.113: v5(11.5,135.77) 11.09,136.18 11.09,136.73 10.86,136.96 9.54,136.96 9.34,137.16
  BOTTOM w0.152: R810.2 9.34,137.16
SYSCTLR_CFG_JTAG_TDI: length 3.5
  TOP w0.152: U111.P8 v5(10.7,134.97)
  BOTTOM w0.113: v5(10.7,134.97) 10.3,135.37 10.3,136.01 10.15,136.17 9.38,136.17
  BOTTOM w0.152: 9.38,136.17 9.23,136.02 R811.2
SYSCTLR_CFG_JTAG_TMS: length 3.8
  TOP w0.152: U111.N8 v5(11.5,134.97)
  BOTTOM w0.152: R812.2 9.33,133.71 9.78,134.16 10.7,134.16 v5(11.5,134.97)
SYSCTLR_CLK: length 267.1
  TOP w0.152: R799.2 160.7,17.02 160.4,16.72 160.4,15.19 v1(159.74,14.53) ; U111.C7 v5(20.3,135.77)
  03_SIG1 w0.173: v1(159.74,14.53) 159.38,14.17 135.51,14.17 135.05,13.72 128.7,13.72 128.27,13.28 124.31,13.28 120.37,17.22 117.81,17.22 117.34,16.76 v1(116.53,16.76)
  14_SIG4 w0.089: v1(30.15,93.34) 27.89,95.61 24.36,95.61 21.79,98.17 21.79,104.2 21.01,104.99 21.01,110.24 17.35,113.91 17.35,118.97 15.63,120.68 15.63,126.14 16.57,127.08 16.57,128.08 16.55,128.09 16.55,133.57 17.17,134.19 19.45,134.19 19.9,134.63 U111.C7 v5(20.3,135.77)
  20_SIG7 w0.089: v1(30.15,93.34) 30,93.2 30,69.17 32.26,66.9 32.26,19.88 37.23,14.91 46.72,14.91 47.44,14.19 53.36,14.19 55.11,15.93 72.99,15.93 72.99,15.93 73.49,15.93 74.47,16.91 78.53,16.91 79,16.44 92.38,16.44 92.7,16.76 v1(116.53,16.76)
SYSCTLR_CLK_R: length 2.1
  TOP w0.14: R799.1 160.99,19.77 161.51,19.25 U122.10
SYSCTLR_DONE: length 17
  TOP w0.14: R748.2 Q3.1
  TOP w0.152: R748.2 v1(1.36,128.56) ; U111.M7 v5(12.3,135.77)
  18_SIG6 w0.089: v1(1.36,128.56) 4.8,132 7.16,132 9.61,134.45 11.55,134.45 11.9,134.8 11.9,135.37 v5(12.3,135.77)
SYSCTLR_ENABLE: length 264.2
  TOP w0.152: R1087.1 124.58,30.77 124.33,30.53 123.89,30.53 v1(123.66,30.3) ; U111.K12 v5(13.9,130.97) ; v1(32.26,122.1) 32.46,122.3 SW16.1
  14_SIG4 w0.089: v1(28.96,93.34) 27.46,94.84 20.52,94.84 18.9,96.47 18.9,110.79 15.06,114.63 15.06,116.64 13.5,118.2 13.5,130.57 v5(13.9,130.97) ; v1(118.29,19.48) 118.29,21.17 117.36,22.09 117.36,26.35 120.01,29 120.01,30.12 120.54,30.65 123.3,30.65 v1(123.66,30.3)
  16_SIG5 w0.089: v5(13.9,130.97) 14.31,130.57 14.31,129.99 14.52,129.78 14.89,129.78 15.1,129.56 15.1,129.19 15.32,128.97 15.83,128.97 16.54,128.27 16.54,127.53 17.7,126.36 17.7,121.56 18.24,121.03 27.04,121.03 28.04,122.03 28.04,122.42 28.45,122.83 31.52,122.83 v1(32.26,122.1)
  20_SIG7 w0.089: v1(28.96,93.34) 29.21,93.09 29.21,69 31.47,66.73 31.47,19.71 36.95,14.23 46.43,14.23 47.18,13.48 57.6,13.48 59.43,15.31 82.87,15.31 83.56,14.62 88.57,14.62 88.94,14.99 116.63,14.99 117.14,15.51 117.14,18.33 v1(118.29,19.48)
SYSCTLR_ERR_LED: length 20.4
  TOP w0.14: Q35.1 4.6,136.71 4.53,136.63 4.53,136.63 4.38,136.47 R96.1 3.81,135.37 v1(3.81,135.31)
  TOP w0.152: U111.G12 v5(17.1,130.97)
  03_SIG1 w0.173: v1(3.81,135.31) 5.16,135.31 5.58,135.72 5.58,136.15 5.88,136.45 6.61,136.45 6.69,136.54 7.58,136.54 9.79,134.33 15.85,134.33 16.49,133.69 16.49,131.58 v5(17.1,130.97)
SYSCTLR_GPIO_5: length 187.9
  TOP w0.152: v2(139.24,62.84) U1.BD21 ; U111.D13 v5(19.5,130.17)
  20_SIG7 w0.089: v1(64.21,73.46) 62.99,74.67 60.96,74.67 56.52,79.11 55.12,79.11 52.97,81.26 52.97,82.66 45.55,90.08 44.18,90.08 37.44,96.82 37.44,106.35 36.73,107.05 36.73,109.87 35.97,110.63 35.97,114.66 30.43,120.19 25.63,120.19 23.77,122.05 23.77,122.78 23.14,123.41 21.91,123.41 17.7,127.63 17.7,128.21 17.5,128.4 17.5,128.74 17.74,128.97 18.87,128.97 19.1,129.2 19.1,129.77 v5(19.5,130.17)
  BOTTOM w0.152: v2(139.24,62.84) 138.99,62.84 138.51,62.36 138,62.36 137.74,62.1 137.74,61.64 137.44,61.34 137.04,61.34 136.74,61.04 136.74,60.64 136.44,60.34 136.04,60.34 135.74,60.04 135.74,59.51 135.57,59.34 135.04,59.34 134.74,59.04 134.74,58.64 134.44,58.34 132.04,58.34 131.74,58.64 131.74,59.04 131.44,59.34 131.04,59.34 130.74,59.64 130.74,60.04 130.43,60.35 130.03,60.35 129.74,60.64 129.74,61.04 129.44,61.34 129.04,61.34 128.74,61.64 128.74,62.04 128.44,62.34 128.02,62.34 127.74,62.63 127.74,63.06 127.45,63.34 118.93,63.34 117.75,64.52 117.75,64.97 117.39,65.34 116.01,65.34 115.74,65.06 115.74,64.64 115.44,64.34 115.04,64.34 114.74,64.04 114.74,63.59 114.49,63.34 114.04,63.34 113.74,63.04 113.74,62.64 113.44,62.34 110.04,62.34 109.78,62.08 109.78,61.69 109.41,61.32 109.01,61.32 108.74,61.04 108.74,59.64 108.43,59.33 108.03,59.33 107.74,59.04 107.74,58.59 107.49,58.34 94.36,58.34 91.41,55.4 84.97,55.4 83.39,56.98 83.39,58.55 83.06,58.88 82.47,58.88 81.58,59.77 81.58,65.81 80.91,66.49 67.8,66.49 65.2,69.09 65.2,73.09 64.84,73.46 v1(64.21,73.46)
SYSCTLR_GPIO_6: length 274.7
  TOP w0.152: v2(136.24,67.84) 135.74,67.34 U1.BA25 ; U111.A12 v5(21.9,130.97)
  14_SIG4 w0.089: v5(21.9,130.97) 24.5,130.97 25.94,129.53 27.24,129.53 28.04,128.73 28.04,128.07 28.47,127.63 29.13,127.63 36.61,120.15 36.61,110.6 38.07,109.14 38.07,97.96 33.35,93.24 v1(31.39,93.24)
  16_SIG5 w0.089: v1(108.07,26.68) 108.07,26.75 108.84,27.52 108.84,36.17 112.93,40.27 112.93,42.44 112.74,42.64 112.74,60.05 113.03,60.34 113.44,60.34 113.74,60.64 113.74,65.05 114.59,65.9 115,65.9 115.74,66.64 115.74,67.05 116.03,67.34 116.44,67.34 116.74,67.64 116.74,68.05 117.03,68.34 117.44,68.34 118.44,69.34 130.51,69.34 130.61,69.44 133.85,69.44 133.95,69.34 135.51,69.34 135.74,69.11 135.74,68.34 v2(136.24,67.84)
  20_SIG7 w0.089: v1(31.39,93.24) 30.68,92.53 30.68,69.45 32.94,67.19 32.94,25.64 40.4,18.18 40.4,16.8 41.61,15.59 47,15.59 47.7,14.89 53.22,14.89 54.86,16.53 73.24,16.53 74.22,17.51 79.04,17.51 79.51,17.03 92.14,17.03 92.46,17.35 99.76,17.35 105.22,22.82 105.22,23.65 106.72,25.15 107.06,25.15 108.12,26.2 108.12,26.63 v1(108.07,26.68)
SYSCTLR_GPIO_7: length 169.9
  TOP w0.152: U111.C13 v5(20.3,130.17) ; U1.BA24 v2(136.24,66.84)
  20_SIG7 w0.089: v1(66.22,88.04) 66.19,88.06 66.19,88.1 65.46,88.84 65.46,90.33 65.83,90.7 66.37,90.7 67.16,89.91 67.16,86.9 66.43,86.17 64.84,86.17 64.62,86.39 64.22,86.39 64.17,86.34 61.51,86.34 60.58,87.27 60.58,87.97 59.98,88.57 52.58,88.57 41.71,99.44 41.71,101.4 38.21,104.89 38.21,109.05 36.44,110.83 36.44,114.87 30.56,120.75 27.13,120.75 25.96,121.92 25.96,122.73 24.71,123.98 22.83,123.98 19.99,126.82 19.99,127.87 20.29,128.17 20.47,128.17 20.7,128.4 20.7,129.77 v5(20.3,130.17)
  BOTTOM w0.113: 131.76,67.65 132.17,67.24 135.52,67.24 135.92,66.84 v2(136.24,66.84)
  BOTTOM w0.152: v1(66.22,88.04) 66.22,88.04 66.37,88.19 79.04,88.19 79.25,87.99 93.17,87.99 94.84,86.31 98.58,86.31 98.74,86.16 98.74,83.61 99,83.34 99.49,83.34 99.74,83.09 99.74,82.56 99.95,82.34 100.44,82.34 100.74,82.04 100.74,81.66 101.05,81.34 101.44,81.34 101.74,81.04 101.74,80.64 102.04,80.34 102.44,80.34 102.74,80.04 102.74,79.64 103.04,79.34 103.44,79.34 103.74,79.04 103.74,78.69 104.08,78.34 104.49,78.34 104.74,78.09 104.74,77.68 105.08,77.34 105.44,77.34 105.74,77.04 105.74,76.64 106.04,76.34 106.44,76.34 106.76,76.02 106.76,75.62 107.02,75.36 107.52,75.36 107.74,75.14 107.74,74.69 108.08,74.34 117.51,74.34 118.62,73.23 118.62,72.8 119.07,72.34 121.44,72.34 121.82,72.73 121.82,73.12 122.04,73.34 124.44,73.34 124.74,73.04 124.74,72.64 125.04,72.34 128.42,72.34 128.74,72.02 128.74,71.59 128.99,71.34 129.47,71.34 129.74,71.08 129.74,70.57 129.96,70.34 130.44,70.34 130.74,70.04 130.74,68.66 130.73,68.66 130.73,68.65 131.06,68.32 131.45,68.32 131.75,68.02 131.75,67.66 131.76,67.65
SYSCTLR_INIT_B: length 25.2
  TOP w0.152: DS42.4 4.47,130.49 v1(4.47,128.83) Q7.1 ; U111.D5 v5(19.5,137.37)
  18_SIG6 w0.089: v5(19.5,137.37) 19.5,137.16 19.9,136.76 19.9,134.67 19.32,134.09 9.96,134.09 7.77,131.9 7.77,131.06 5.54,128.83 v1(4.47,128.83)
  BOTTOM w0.152: R726.2 4.5,128.8 v1(4.47,128.83)
SYSCTLR_MODE0: length 30.1
  TOP w0.152: SW15.4 v1(16.27,108.24) R727.1 ; U111.E15 v5(18.7,128.57)
  05_SIG2 w0.113: 22.04,127.37 22.3,127.63 22.3,128.74 22.07,128.97 19.1,128.97 v5(18.7,128.57)
  05_SIG2 w0.173: v1(16.27,108.24) 19.87,111.83 19.87,117.39 20.52,118.04 20.52,118.53 19.78,119.27 19.78,120.49 20.46,121.17 20.46,125.79 22.04,127.37
SYSCTLR_MODE1: length 29.6
  TOP w0.152: SW15.3 v1(16.27,109.51) R728.1 ; U111.C11 v5(20.3,131.77)
  05_SIG2 w0.113: 16.56,127.43 16.56,128.8 16.73,128.97 17.27,128.97 17.5,129.2 17.5,129.6 17.67,129.77 18.07,129.77 18.3,130 18.3,130.41 18.46,130.57 18.87,130.57 19.1,130.8 19.1,131.14 19.34,131.37 19.9,131.37 v5(20.3,131.77)
  05_SIG2 w0.173: 16.56,127.43 16.56,126.7 15.62,125.76 15.62,120.92 17.27,119.27 17.27,117.81 16.58,117.12 16.58,113.33 15.6,112.35 15.6,110.18 v1(16.27,109.51)
SYSCTLR_MODE2: length 22.4
  TOP w0.152: SW15.2 v1(16.27,110.78) R729.1 ; U111.D15 v5(19.5,128.57)
  05_SIG2 w0.173: v5(19.5,128.57) 19.9,128.17 19.9,121.66 19.15,120.9 19.15,118.92 19.46,118.61 19.46,117.83 19.06,117.43 19.06,113.57 v1(16.27,110.78)
SYSCTLR_MODE3: length 25.8
  TOP w0.152: R730.1 v1(16.27,112.05) SW15.1 ; U111.A14 v5(21.9,129.37)
  05_SIG2 w0.113: 17.62,127.53 17.62,128 17.5,128.11 17.5,128.76 17.71,128.97 18.07,128.97 18.3,129.2 18.3,129.2 18.3,129.54 18.54,129.77 21.27,129.77 21.5,129.77 v5(21.9,129.37)
  05_SIG2 w0.173: 17.62,127.53 17.62,120.76 18.4,119.97 18.4,118.03 17.88,117.5 17.88,113.66 v1(16.27,112.05)
SYSCTLR_POR_B: length 48.6
  TOP w0.152: SW14.1 v1(21.18,121.84) SW14.2 ; U111.C9 v5(20.3,133.37)
  03_SIG1 w0.173: v1(21.18,121.84) 22.55,123.21 30.79,123.21 31.72,122.28 31.72,121.49 33.38,119.84 33.38,116.61 33.1,116.33 v1(33.1,113.92)
  07_SIG3 w0.173: v5(20.3,133.37) 20.79,133.86 22.15,133.86 22.38,133.63 22.38,131.65 23.8,130.23 23.8,126.5 22.25,124.95 22.25,122.91 v1(21.18,121.84)
  BOTTOM w0.152: U128.20 32.55,113.5 32.97,113.92 v1(33.1,113.92) 33.1,114.79 R13.2
SYSCTLR_QSPI_IO0: length 43.2
  TOP w0.152: U111.A8 v5(21.9,134.97)
  05_SIG2 w0.173: v1(16.51,107.11) 20.46,111.06 20.46,117.14 21.07,117.75 21.07,118.76 20.34,119.5 20.34,119.9 21.77,121.34 21.77,125.37 23.62,127.23 23.62,128.65 22.4,129.87 22.4,133.62 22.17,133.86 19.92,133.86 19.75,134.03 19.75,134.29 19.91,134.45 21.73,134.45 21.9,134.62 v5(21.9,134.97)
  14_SIG4 w0.089: v5(22.99,132.77) 22.56,132.77 22.38,132.94 22.38,134.49 v5(21.9,134.97)
  BOTTOM w0.152: v1(16.51,107.11) 16.13,106.73 15.75,106.73 15.43,106.42 U114.15 ; v5(22.99,132.77) 23.62,133.4 R774.1
SYSCTLR_QSPI_IO1: length 46.4
  TOP w0.152: U111.A7 v5(21.9,135.77)
  05_SIG2 w0.173: v5(21.9,135.77) 22.34,136.21 23.45,136.21 24.43,135.23 25.68,135.23 26.59,134.32 26.59,133.91 26.44,133.76 25.53,133.76 25.3,133.53 25.3,133.17 24.84,132.72 24.84,132.16 25.12,131.88 25.81,131.88 25.92,131.76 25.92,131.38 25.74,131.2 25.19,131.2 25.02,131.02 25.02,130.68 25.19,130.51 25.71,130.51 25.89,130.33 25.89,130.04 25.8,129.95 24.9,129.95 24.8,129.85 24.8,129.57 24.88,129.49 25.82,129.49 25.91,129.4 25.91,129.13 25.82,129.04 24.88,129.04 24.8,128.96 24.8,128.68 24.88,128.6 25.58,128.6 25.78,128.39 25.78,128.03 25.61,127.86 25.01,127.86 24.84,127.69 24.84,127.34 25.01,127.17 25.71,127.17 25.89,127 25.89,126.65 25.71,126.48 25.01,126.48 24.84,126.31 24.84,125.96 25.01,125.79 25.71,125.79 25.89,125.62 25.89,125.15 25.12,124.38 25.12,124.1 25.29,123.93 25.61,123.93 25.78,123.76 25.78,123.41 25.61,123.24 23.92,123.24 23.72,123.04 23.72,119.89 23.03,119.19 22.77,119.19 22.59,119.01 22.59,118.68 22.75,118.52 23.18,118.52 23.31,118.4 23.31,117.95 23.15,117.8 22.78,117.8 22.39,117.41 22.39,115.8 22.56,115.63 22.93,115.63 23.05,115.75 v1(23.05,116.45)
  14_SIG4 w0.089: v5(21.9,135.77) 22.9,135.77 23.24,135.43 23.24,134.67 v5(22.99,134.42)
  BOTTOM w0.152: U114.8 v1(23.05,116.45) ; v5(22.99,134.42) 23.24,134.67 R773.1
SYSCTLR_QSPI_IO2: length 47.5
  TOP w0.152: U111.C8 v5(20.3,134.97)
  05_SIG2 w0.113: 23.63,134.34 23.52,134.45 23.52,135.23 23.06,135.69 22.5,135.69 22.19,135.37 20.7,135.37 v5(20.3,134.97)
  05_SIG2 w0.173: v1(23.05,107.05) 21.06,109.05 21.06,116.89 21.67,117.5 21.67,119.79 21.97,120.09 22.68,120.09 22.86,120.27 22.86,121.79 22.35,122.3 22.35,124.97 22.61,125.22 23.06,125.22 23.19,125.09 23.19,124.05 23.37,123.87 24.11,123.87 24.33,124.09 24.33,125.55 24.24,125.64 24.24,130.13 24.18,130.19 24.18,133.05 24.68,133.54 24.68,134.03 24.5,134.21 23.77,134.21 23.63,134.34
  14_SIG4 w0.089: v5(22.99,131.88) 22.68,132.18 21.64,132.18 21.5,132.32 21.5,133.77 v5(20.3,134.97)
  BOTTOM w0.152: v5(22.99,131.88) 23.24,132.13 R772.1 ; U114.9 v1(23.05,107.05)
