# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FMC_HPC1_LA13_P: length 146.2
  TOP w0.104: J2.D17 v1(156.62,162.05) ; U1.AY8 v2(135.24,49.84)
  18_SIG6 w0.076: v2(135.24,49.84) 135.24,49.42 135.32,49.34 135.48,49.34 135.64,49.49 135.64,49.59 135.64,50.59 135.64,51.14 135.94,51.45 136.07,51.45 136.07,51.44 137.48,51.44 137.64,51.6 137.64,56.09 137.99,56.44 141.66,56.44 141.7,56.48
  18_SIG6 w0.089: v1(156.62,162.05) 156.75,161.91 156.75,161.58 156.44,161.26 155.97,161.26 155.87,161.36 155.87,162.18 156.23,162.55 156.95,162.55 157.11,162.38 157.11,157.81 161.65,153.27 161.65,148.76 160.78,147.9 160.78,147.02 161.11,146.69 161.4,146.69 161.65,146.44 161.65,142.56 163.34,140.86 163.34,134.18 162.09,132.93 162.09,131.74 163.55,130.28 163.55,129.17 166.36,126.36 166.36,118.26 164.78,116.67 163.61,116.67 161.87,114.93 161.87,113.83 160.41,112.37 160.41,111.24 159.15,109.98 158.74,109.98 158.18,109.42 158.18,107.94 158.92,107.2 158.92,106.69 158.2,105.97 158.2,104.59 155.89,102.29 154.56,102.29 154.13,101.86 154.13,101.22 153.76,100.85 152.95,100.85 152.64,100.53 150.14,100.53 149.02,99.41 149.02,98.28 150.2,97.1 150.2,93.91 145.58,89.28 145.58,71.74 141.76,67.92 141.76,60.82 141.96,60.62 141.96,56.75 141.7,56.48
FMC_HPC1_LA14_N: length 145.8
  TOP w0.104: v1(154.08,160.78) J2.C19 ; U1.AW7 v2(134.24,48.84)
  20_SIG7 w0.076: v2(134.24,48.84) 133.64,49.44 133.64,51.09 133.48,51.25 132.89,51.25 132.64,51.5 132.64,63.19 132.89,63.44 134.43,63.44 134.64,63.65 134.64,67.15 134.94,67.45 141.66,67.45 141.7,67.49 141.72,67.49
  20_SIG7 w0.089: v1(154.08,160.78) 154.57,160.29 154.57,157.73 160.75,151.55 160.75,143.25 161.78,142.22 161.78,136.8 164.79,133.79 164.79,131.77 166.33,130.23 166.33,126.46 168.51,124.29 168.51,107.54 166.78,105.81 166.78,104.59 165.7,103.5 158.69,103.5 158.34,103.16 158.34,102.22 157.94,101.82 157.94,98.75 154.04,94.86 154.04,89.51 147.47,82.94 147.47,70.82 144.13,67.49 141.72,67.49
FMC_HPC1_LA14_P: length 147.3
  TOP w0.104: J2.C18 v1(155.35,160.78) ; U1.AW8 v2(134.24,49.84)
  20_SIG7 w0.076: 141.72,67.21 141.7,67.21 141.66,67.25 135.02,67.25 134.84,67.07 134.84,63.57 134.51,63.24 132.97,63.24 132.84,63.11 132.84,51.58 132.97,51.44 133.56,51.44 133.68,51.33 133.84,51.17 133.84,49.52 134,49.36 134.35,49.36 134.45,49.47 134.45,49.63 v2(134.24,49.84)
  20_SIG7 w0.089: v1(155.35,160.78) 155.35,161.06 155.22,161.18 154.81,161.18 154.68,161.06 154.68,160.57 154.85,160.4 154.85,157.85 161.03,151.67 161.03,143.36 162.06,142.33 162.06,136.92 165.07,133.9 165.07,131.89 166.61,130.35 166.61,126.58 168.79,124.41 168.79,107.42 167.06,105.69 167.06,104.47 165.81,103.23 158.8,103.23 158.62,103.04 158.62,102.1 158.22,101.7 158.22,98.64 154.32,94.74 154.32,89.39 147.75,82.82 147.75,70.71 144.25,67.21 141.72,67.21
FMC_HPC1_LA15_N: length 152.2
  TOP w0.104: U1.BC16 v2(138.24,57.84) ; J2.H20 v1(152.81,167.13)
  18_SIG6 w0.076: 141.8,69.48 141.77,69.48 141.74,69.44 140.93,69.44 140.64,69.15 140.64,57.68 140.4,57.44 138.04,57.44 137.93,57.55 137.93,57.76 138.02,57.84 v2(138.24,57.84)
  18_SIG6 w0.089: v1(152.81,167.13) 153.3,166.64 153.3,157.5 153.67,157.13 156.35,157.13 156.77,156.72 156.77,155.76 157.06,155.47 158.09,155.47 158.23,155.32 158.23,154.81 157.71,154.28 157.71,153.54 158.04,153.21 160.39,153.21 160.68,152.92 160.68,152.49 160.59,152.41 158.04,152.41 157.74,152.11 157.74,151.34 158.04,151.04 159.25,151.04 159.39,150.9 159.39,150.16 159.68,149.86 160.36,149.86 160.45,149.77 160.45,149.14 160.36,149.05 159.14,149.05 158.22,148.12 158.22,144.74 161.79,141.17 161.79,136.08 160.35,134.65 160.35,130.22 160.81,129.76 161.23,129.76 161.85,130.37 162.04,130.37 162.42,129.99 162.42,129.8 161.8,129.19 161.8,128.77 163.81,126.76 163.81,125.84 164.11,125.54 165.11,125.54 165.25,125.41 165.25,124.87 165.11,124.73 164.11,124.73 163.81,124.43 163.81,123.66 164.11,123.37 165.11,123.37 165.25,123.23 165.25,122.69 165.11,122.56 164.11,122.56 163.81,122.26 163.81,120.43 160.72,117.34 160.72,114.1 159.2,112.58 159.2,111.54 158.62,110.97 158.09,110.97 157.01,109.88 157.01,107.34 156.81,107.15 156.81,105.2 156,104.39 153.15,104.39 152.23,103.48 152.23,102.41 151.94,102.12 149.47,102.12 148.77,101.42 148.77,100.48 148.09,99.79 148.09,98.98 145.9,96.79 145.9,92.26 144.63,91 144.63,72.12 141.99,69.48 141.8,69.48
FMC_HPC1_LA15_P: length 153.4
  TOP w0.104: v1(154.08,167.13) J2.H19 ; v2(137.24,57.84) 136.74,58.34 U1.BB16
  18_SIG6 w0.076: 141.8,69.2 141.77,69.2 141.74,69.24 141.01,69.24 140.84,69.07 140.84,57.59 140.49,57.24 137.96,57.24 137.73,57.47 137.73,57.73 137.62,57.84 v2(137.24,57.84)
  18_SIG6 w0.089: 141.8,69.2 142.11,69.2 144.91,72 144.91,90.88 146.17,92.15 146.17,96.67 148.37,98.86 148.37,99.67 149.05,100.36 149.05,101.3 149.59,101.84 152.06,101.84 152.51,102.29 152.51,103.36 153.26,104.12 156.12,104.12 157.09,105.09 157.09,107.03 157.28,107.22 157.28,109.76 158.21,110.69 158.74,110.69 159.48,111.43 159.48,112.46 161,113.98 161,117.22 164.09,120.31 164.09,122.14 164.23,122.28 165.23,122.28 165.53,122.58 165.53,123.35 165.23,123.65 164.23,123.65 164.09,123.78 164.09,124.32 164.23,124.45 165.23,124.45 165.53,124.75 165.53,125.52 165.23,125.82 164.23,125.82 164.09,125.95 164.09,126.87 162.08,128.88 162.08,129.07 162.7,129.69 162.7,130.11 162.15,130.65 161.73,130.65 161.12,130.04 160.93,130.04 160.63,130.33 160.63,134.53 162.07,135.97 162.07,141.28 158.5,144.85 158.5,148.01 159.26,148.77 160.48,148.77 160.73,149.02 160.73,149.88 160.48,150.14 159.8,150.14 159.67,150.27 159.67,151.02 159.37,151.32 158.15,151.32 158.02,151.45 158.02,151.99 158.15,152.13 160.71,152.13 160.96,152.38 160.96,153.04 160.5,153.49 158.15,153.49 157.99,153.66 157.99,154.16 158.51,154.69 158.51,155.43 158.2,155.74 157.18,155.74 157.04,155.88 157.04,156.83 156.46,157.41 153.79,157.41 153.58,157.62 153.58,167 153.72,167.13 v1(154.08,167.13)
FMC_HPC1_LA16_N: length 145.4
  TOP w0.104: U1.AV8 v2(133.24,49.84) ; v1(154.08,165.86) J2.G19
  20_SIG7 w0.076: v2(133.24,49.84) 132.83,50.25 131.99,50.25 131.64,50.6 131.64,64.1 131.98,64.44 132.45,64.44 132.64,64.63 132.64,65.44 133.64,66.44 133.64,68.1 133.98,68.44 141.68,68.44 141.72,68.48
  20_SIG7 w0.089: v1(154.08,165.86) 154.57,165.37 154.57,163.09 154.31,162.83 153.66,162.83 153.3,162.46 153.3,156.87 158.64,151.54 158.64,135.21 160.47,133.37 160.47,132.5 163.17,129.8 163.17,124.93 161.17,122.93 161.17,121.32 158.98,119.13 158.98,118.53 158.56,118.11 157.95,118.11 154.56,114.72 154.56,113.2 153.82,112.46 153.82,110.58 154.58,109.82 154.58,108.8 156.82,106.55 156.82,102.12 156.55,101.84 156.55,100.8 155.31,99.57 155.31,98.33 152.98,96 152.98,89.76 146.54,83.32 146.54,72.04 142.98,68.48 141.72,68.48
FMC_HPC1_LA16_P: length 145.6
  TOP w0.104: U1.AV9 v2(133.24,50.84) ; J2.G18 v1(155.35,165.86)
  20_SIG7 w0.076: v2(133.24,50.84) 133.24,50.55 133.13,50.44 132.07,50.44 131.84,50.68 131.84,64.02 132.06,64.24 132.53,64.24 132.84,64.55 132.84,65.36 133.84,66.36 133.84,68.02 134.06,68.24 141.68,68.24 141.71,68.2
  20_SIG7 w0.089: 141.71,68.2 143.09,68.2 146.82,71.93 146.82,83.2 153.26,89.64 153.26,95.88 155.59,98.22 155.59,99.45 156.82,100.69 156.82,101.73 157.1,102.01 157.1,106.67 154.86,108.91 154.86,109.94 154.1,110.69 154.1,112.34 154.84,113.08 154.84,114.6 158.07,117.83 158.67,117.83 159.26,118.41 159.26,119.01 161.44,121.2 161.44,122.81 163.45,124.82 163.45,129.92 162.93,130.44 160.75,132.62 160.75,133.49 158.91,135.32 158.91,151.65 153.58,156.98 153.58,162.35 153.78,162.55 154.43,162.55 154.85,162.97 154.85,165.73 154.99,165.86 v1(155.35,165.86)
FMC_HPC1_LA17_CC_N: length 154.8
  TOP w0.104: v2(131.24,55.84) 130.74,56.34 U1.AT14 ; J2.D21 v1(151.54,162.05)
  20_SIG7 w0.076: v2(131.24,55.84) 130.95,55.84 130.84,55.95 130.84,65.08 131.11,65.35 132.12,65.35 132.84,66.06 132.84,69.01 133.07,69.24 141.6,69.24 141.64,69.2
  20_SIG7 w0.089: v1(151.54,162.05) 151.77,161.82 152.1,161.82 152.21,161.93 152.21,162.25 151.92,162.55 151.25,162.55 151.04,162.34 151.04,157.34 151.18,157.21 152.22,157.21 152.48,156.95 152.48,156.34 151.89,155.76 151.89,155.37 152.42,154.84 153.4,154.84 153.8,154.44 153.8,153.87 153.4,153.47 152.15,153.47 152.02,153.34 152.02,152.8 152.15,152.67 154.28,152.67 154.94,152 154.94,151.58 153.47,150.1 153.47,149.91 153.75,149.62 153.94,149.62 155.42,151.1 155.84,151.1 156.29,150.65 156.29,150.23 154.81,148.75 154.81,148.56 155.1,148.27 156.89,148.27 157.49,147.68 157.49,146.42 157.01,145.95 156.38,145.95 156.25,145.82 156.25,145.41 156.38,145.28 156.88,145.28 157.37,144.78 157.37,133.32 158.47,132.22 158.47,131.87 157.83,131.22 157.83,131.1 158.08,130.85 158.2,130.85 158.85,131.49 159.2,131.49 159.62,131.07 159.62,130.72 158.98,130.07 158.98,129.95 159.23,129.7 159.35,129.7 159.99,130.34 160.35,130.34 162.42,128.27 162.42,125.58 160.45,123.61 160.45,122.11 158.35,120.01 157.61,120.01 157.16,119.56 157.16,118.44 153.96,115.25 153.96,113.64 152.95,112.63 152.95,109.94 152.52,109.52 152.52,104.48 153.72,103.28 153.72,102.43 154.29,101.85 154.29,100.72 153.07,99.5 153.07,97.15 152.33,96.41 152.33,95.03 145.91,88.61 145.91,72.28 142.83,69.2 141.64,69.2
FMC_HPC1_LA17_CC_P: length 154.7
  TOP w0.104: v2(130.24,55.84) 129.74,56.34 U1.AR14 ; J2.D20 v1(152.81,162.05)
  20_SIG7 w0.076: v2(130.24,55.84) 130.64,56.25 130.64,65.16 131.03,65.55 132.04,65.55 132.64,66.15 132.64,69.09 132.99,69.44 141.6,69.44 141.64,69.48
  20_SIG7 w0.089: 141.64,69.48 142.71,69.48 145.63,72.4 145.63,88.72 152.05,95.15 152.05,96.53 152.79,97.27 152.79,99.61 154.01,100.84 154.01,101.74 153.44,102.31 153.44,103.16 152.24,104.36 152.24,109.63 152.67,110.06 152.67,112.75 153.68,113.75 153.68,115.36 156.88,118.56 156.88,119.67 157.49,120.29 158.23,120.29 160.17,122.22 160.17,123.72 162.14,125.69 162.14,128.15 160.24,130.06 160.11,130.06 159.47,129.42 159.11,129.42 158.7,129.83 158.7,130.19 159.34,130.83 159.34,130.96 159.09,131.21 158.96,131.21 158.32,130.57 157.96,130.57 157.55,130.98 157.55,131.34 158.19,131.98 158.19,132.11 157.09,133.2 157.09,144.67 156.76,145 156.26,145 155.97,145.3 155.97,145.93 156.26,146.23 156.89,146.23 157.21,146.54 157.21,147.56 156.77,148 154.98,148 154.53,148.44 154.53,148.87 156.01,150.35 156.01,150.54 155.73,150.82 155.54,150.82 154.06,149.34 153.64,149.34 153.19,149.79 153.19,150.21 154.66,151.69 154.66,151.88 154.16,152.39 152.04,152.39 151.74,152.68 151.74,153.45 152.04,153.75 153.28,153.75 153.52,153.99 153.52,154.32 153.28,154.56 152.31,154.56 151.61,155.26 151.61,155.88 152.2,156.46 152.2,156.84 152.11,156.93 151.06,156.93 150.76,157.22 150.76,162.46 151.13,162.83 152.03,162.83 v1(152.81,162.05)
FMC_HPC1_LA18_CC_N: length 157
  TOP w0.104: U1.AR12 v2(130.24,53.84) ; J2.C23 v1(149,160.78)
  20_SIG7 w0.076: v2(130.24,53.84) 129.84,54.24 129.84,65.23 130.6,65.99 131.23,65.99 131.84,66.59 131.84,70.03 132.05,70.24 141.57,70.24 141.61,70.2
  20_SIG7 w0.089: v1(149,160.78) 149.19,160.59 149.45,160.59 149.6,160.74 149.6,161.05 149.38,161.28 148.74,161.28 148.5,161.04 148.5,157.6 148.64,157.47 149.74,157.47 150.04,157.17 150.04,156.4 149.74,156.1 149.48,156.1 149.35,155.97 149.35,155.55 149.61,155.29 150.72,155.29 151.26,154.76 151.26,154.25 150.93,153.93 149.43,153.93 149.2,153.7 149.2,153.31 149.39,153.12 150.72,153.12 151.02,152.82 151.02,152.05 150.72,151.75 149.61,151.75 149.48,151.62 149.48,151.08 149.61,150.95 150.72,150.95 151.02,150.65 151.02,146.67 151.16,146.52 151.86,146.52 151.99,146.65 151.99,147.82 152.44,148.27 153.19,148.27 153.73,147.73 153.73,146.79 153.86,146.66 154.95,146.66 155.25,146.36 155.25,145.73 154.95,145.43 153.86,145.43 153.73,145.29 153.73,144.89 153.86,144.75 154.23,144.75 154.56,144.43 154.56,143.79 154.29,143.52 153.86,143.52 153.73,143.39 153.73,142.28 154.61,141.4 155.98,141.4 156.45,140.93 156.45,134.3 155.38,133.23 155.38,131.3 158.24,128.44 160.88,128.44 161.42,127.9 161.42,126.19 160.42,125.19 159.88,125.19 155.42,120.73 155.42,118.75 153.58,116.9 153.58,116.38 153.08,115.89 153.08,114.4 151.96,113.28 151.96,110.56 151.15,109.75 151.15,104.33 152.53,102.95 152.53,102.35 151.77,101.58 151.77,98.2 151.38,97.81 151.38,95.42 144.97,89.01 144.97,72.59 142.59,70.2 141.61,70.2
FMC_HPC1_LA18_CC_P: length 157.2
  TOP w0.104: U1.AP12 v2(129.24,53.84) ; J2.C22 v1(150.27,160.78)
  20_SIG7 w0.076: 141.61,70.48 141.57,70.44 131.97,70.44 131.64,70.11 131.64,66.67 131.15,66.18 130.52,66.18 129.64,65.31 129.64,54.25 v2(129.24,53.84)
  20_SIG7 w0.089: 141.61,70.48 142.47,70.48 144.69,72.71 144.69,89.13 151.1,95.53 151.1,97.93 151.49,98.32 151.49,101.69 152.25,102.46 152.25,102.83 150.87,104.22 150.87,109.86 151.68,110.67 151.68,113.4 152.8,114.52 152.8,116 153.3,116.5 153.3,117.02 155.14,118.87 155.14,120.84 159.77,125.47 160.3,125.47 161.14,126.31 161.14,127.78 160.76,128.16 158.13,128.16 155.1,131.19 155.1,133.34 156.18,134.42 156.18,140.81 155.87,141.12 154.49,141.12 153.45,142.17 153.45,143.5 153.75,143.8 154.17,143.8 154.28,143.91 154.28,144.31 154.11,144.47 153.75,144.47 153.45,144.77 153.45,145.41 153.75,145.71 154.83,145.71 154.97,145.84 154.97,146.24 154.83,146.38 153.75,146.38 153.45,146.68 153.45,147.62 153.07,147.99 152.56,147.99 152.27,147.7 152.27,146.53 151.98,146.24 151.05,146.24 150.74,146.55 150.74,150.53 150.6,150.67 149.5,150.67 149.2,150.96 149.2,151.73 149.5,152.03 150.6,152.03 150.74,152.17 150.74,152.71 150.6,152.84 149.28,152.84 148.92,153.2 148.92,153.81 149.32,154.21 150.81,154.21 150.98,154.37 150.98,154.64 150.6,155.01 149.5,155.01 149.07,155.44 149.07,156.09 149.36,156.38 149.63,156.38 149.76,156.52 149.76,157.05 149.63,157.19 148.52,157.19 148.22,157.49 148.22,161.16 148.62,161.56 149.49,161.56 v1(150.27,160.78)
FMC_HPC1_LA19_N: length 151
  TOP w0.104: J2.H23 v1(149,167.13) ; U1.AY12 v2(135.24,53.84)
  18_SIG6 w0.076: 141.66,72.19 141.65,72.19 141.6,72.25 139.08,72.25 138.92,72.09 138.92,72.09 138.84,72 138.84,60.59 138.83,60.59 138.83,59.6 138.83,59.6 138.83,59.53 138.55,59.25 136.03,59.25 135.84,59.05 135.84,54.59 135.49,54.24 134.93,54.24 134.84,54.15 134.84,53.93 134.93,53.84 v2(135.24,53.84)
  18_SIG6 w0.089: v1(149,167.13) 149.36,167.13 149.49,167.27 149.49,167.46 149.32,167.63 148.72,167.63 148.5,167.4 148.5,157.93 150.9,155.53 152.47,155.53 152.98,155.02 152.98,154.18 152.72,153.91 151.45,153.91 151.32,153.78 151.32,153.24 151.45,153.1 153.66,153.1 153.96,152.81 153.96,152.04 153.66,151.74 151.64,151.74 151.4,151.49 151.4,149.46 151.8,149.05 151.8,148.63 151.16,147.98 151.16,147.79 151.54,147.41 151.73,147.41 152.88,148.56 153.4,148.56 153.87,148.1 153.87,147.62 152.69,146.44 152.69,146.25 153.07,145.87 153.26,145.87 153.91,146.52 154.33,146.52 156.8,144.05 156.8,135.2 156.24,134.63 156.24,132.68 155.72,132.17 152.11,132.17 151.84,131.89 151.84,125.89 153.05,124.68 153.05,122.59 151.68,121.22 151.68,112.48 150.49,111.29 150.49,108.19 146.95,104.64 145.6,104.64 145.2,104.24 145.2,102.31 144.75,101.86 144.75,99.28 144.02,98.54 144.02,96.2 143.02,95.21 143.02,73.11 142.1,72.19 141.66,72.19
FMC_HPC1_LA19_P: length 151.9
  TOP w0.104: J2.H22 v1(150.27,167.13) ; U1.AW12 v2(134.24,53.84)
  18_SIG6 w0.076: 141.66,72.47 141.64,72.44 138.99,72.44 138.78,72.23 138.77,72.23 138.72,72.17 138.72,72.17 138.64,72.09 138.64,59.68 138.63,59.68 138.63,59.61 138.47,59.44 135.95,59.44 135.64,59.14 135.64,54.68 135.4,54.44 134.93,54.44 134.93,54.44 134.85,54.44 134.64,54.24 134.64,53.91 134.57,53.84 v2(134.24,53.84)
  18_SIG6 w0.089: 141.66,72.47 141.99,72.47 142.74,73.23 142.74,95.32 143.74,96.32 143.74,98.66 144.48,99.39 144.48,101.98 144.92,102.42 144.92,104.35 145.49,104.92 146.83,104.92 150.21,108.3 150.21,111.41 151.4,112.6 151.4,121.34 152.77,122.71 152.77,124.56 151.56,125.77 151.56,132.01 151.99,132.45 155.61,132.45 155.96,132.79 155.96,134.75 156.52,135.31 156.52,143.94 154.22,146.24 154.03,146.24 153.38,145.59 152.96,145.59 152.41,146.14 152.41,146.56 153.59,147.74 153.59,147.98 153.29,148.29 153,148.29 151.84,147.13 151.42,147.13 150.88,147.67 150.88,148.1 151.52,148.74 151.52,148.93 151.12,149.34 151.12,151.61 151.53,152.02 153.54,152.02 153.68,152.15 153.68,152.69 153.54,152.82 151.34,152.82 151.04,153.12 151.04,153.89 151.34,154.19 152.6,154.19 152.7,154.29 152.7,154.91 152.36,155.25 150.78,155.25 148.22,157.81 148.22,167.52 148.61,167.91 149.44,167.91 149.77,167.57 149.77,167.27 149.91,167.13 v1(150.27,167.13)
FMC_HPC1_LA20_N: length 150.3
  TOP w0.104: J2.G22 v1(150.27,165.86) ; U1.AY10 v2(135.24,51.84)
  18_SIG6 w0.076: 141.75,71.2 141.72,71.2 141.68,71.24 139.95,71.24 139.84,71.13 139.84,58.57 139.51,58.24 136.99,58.24 136.83,58.09 136.83,52.53 136.55,52.25 135.64,52.25 v2(135.24,51.84)
  18_SIG6 w0.089: 141.75,71.2 142.48,71.2 143.96,72.69 143.96,93.51 144.97,94.52 144.97,98.23 147.51,100.77 147.51,102.07 149,103.56 150.1,103.56 151.14,104.61 151.14,105.37 157.31,111.54 157.31,114.48 159.17,116.34 159.17,116.96 161.7,119.49 161.7,127.78 159.83,129.64 158.04,129.64 157.44,130.25 157.44,132.71 158.93,134.21 158.93,143.17 157.02,145.07 157.02,150.71 155.96,151.78 155.05,151.78 154.91,151.91 154.91,152.45 155.05,152.58 156.69,152.58 156.95,152.84 156.95,153.7 156.69,153.95 154.33,153.95 154.05,154.23 154.05,154.61 154.2,154.76 155.75,154.76 156.05,155.06 156.05,156.05 155.64,156.46 151.31,156.46 149.77,158 149.77,166.1 150.03,166.36 150.65,166.36 150.91,166.09 150.91,165.81 150.82,165.72 150.41,165.72 v1(150.27,165.86)
FMC_HPC1_LA20_P: length 151.1
  TOP w0.104: U1.AW11 v2(134.24,52.84) ; J2.G21 v1(151.54,165.86)
  18_SIG6 w0.076: v2(134.24,52.84) 134.62,52.84 135.02,52.44 136.47,52.44 136.64,52.61 136.64,58.17 136.91,58.44 139.43,58.44 139.64,58.65 139.64,71.22 139.86,71.44 141.68,71.44 141.72,71.48 141.75,71.48
  18_SIG6 w0.089: v1(151.54,165.86) 150.76,166.64 149.92,166.64 149.49,166.21 149.49,157.89 151.2,156.18 155.52,156.18 155.77,155.94 155.77,155.17 155.63,155.04 154.08,155.04 153.77,154.73 153.77,154.11 154.21,153.67 156.58,153.67 156.67,153.58 156.67,152.95 156.58,152.86 154.93,152.86 154.63,152.56 154.63,151.79 154.93,151.5 155.84,151.5 156.74,150.6 156.74,144.96 158.65,143.05 158.65,134.32 157.16,132.83 157.16,130.14 157.93,129.37 159.71,129.37 161.42,127.66 161.42,119.6 158.89,117.08 158.89,116.46 157.03,114.59 157.03,111.65 150.86,105.49 150.86,104.72 149.98,103.84 148.89,103.84 147.23,102.18 147.23,100.89 144.69,98.35 144.69,94.63 143.68,93.63 143.68,72.8 142.36,71.48 141.75,71.48
FMC_HPC1_LA21_N: length 149.9
  TOP w0.104: J2.H26 v1(145.19,167.13) ; U1.AV11 v2(133.24,52.84)
  18_SIG6 w0.076: 140.88,89.37 140.88,89.35 140.84,89.31 140.84,74.59 140.49,74.24 136.98,74.24 136.84,74.1 136.84,62.64 136.84,62.63 136.84,62.01 136.84,62.01 136.84,61.59 136.49,61.24 133.01,61.24 132.84,61.07 132.84,53.16 132.76,53.08 132.76,52.95 132.87,52.84 v2(133.24,52.84)
  18_SIG6 w0.089: 140.88,89.37 140.88,98.2 141.99,99.31 141.99,100.48 141.22,101.24 141.22,103.95 142.45,105.17 142.45,105.66 144.47,107.68 146.62,107.68 148.34,109.4 148.34,115.57 149.75,116.98 149.75,119.52 149.21,120.07 149.21,124.92 148.18,125.95 148.18,126.46 148.31,126.6 149.3,126.6 149.6,126.89 149.6,127.66 149.3,127.96 148.31,127.96 148.18,128.1 148.18,134.41 146.84,135.74 146.84,135.93 147.36,136.45 147.36,136.91 146.82,137.46 146.44,137.46 145.88,136.89 145.66,136.89 145.31,137.24 144.25,137.24 143.94,137.56 143.94,139.9 143.64,140.2 143.13,140.2 143,140.33 143,140.87 143.13,141 145.4,141 145.64,141.25 145.64,142.02 145.29,142.37 143.48,142.37 143.23,142.62 143.23,143.73 149.2,149.7 149.2,154.66 147.01,156.85 145.45,156.85 144.69,157.61 144.69,167.49 144.83,167.63 145.57,167.63 145.84,167.35 145.84,167 145.73,166.88 145.43,166.88 v1(145.19,167.13)
FMC_HPC1_LA21_P: length 149.7
  TOP w0.104: U1.AU11 v2(132.24,52.84) ; J2.H25 v1(146.46,167.13)
  18_SIG6 w0.076: v2(132.24,52.84) 132.64,53.24 132.64,61.16 132.92,61.44 136.4,61.44 136.44,61.49 136.45,61.49 136.64,61.68 136.64,62.09 136.64,62.09 136.64,62.59 136.64,62.59 136.64,74.19 136.89,74.44 140.4,74.44 140.64,74.68 140.64,89.31 140.6,89.35 140.6,89.37
  18_SIG6 w0.089: v1(146.46,167.13) 145.68,167.91 144.72,167.91 144.41,167.6 144.41,157.49 145.33,156.57 146.89,156.57 148.92,154.54 148.92,149.82 142.95,143.85 142.95,142.51 143.36,142.09 145.17,142.09 145.36,141.9 145.36,141.36 145.28,141.28 143.02,141.28 142.72,140.99 142.72,140.22 143.02,139.92 143.52,139.92 143.66,139.78 143.66,137.44 144.14,136.96 145.19,136.96 145.54,136.61 145.99,136.61 146.56,137.18 146.7,137.18 147.09,136.8 147.09,136.56 146.56,136.04 146.56,135.62 147.9,134.29 147.9,127.98 148.19,127.68 149.18,127.68 149.32,127.55 149.32,127.01 149.18,126.88 148.19,126.88 147.9,126.58 147.9,125.84 148.93,124.8 148.93,119.95 149.47,119.41 149.47,117.1 148.06,115.69 148.06,109.52 146.51,107.96 144.36,107.96 142.17,105.77 142.17,105.29 140.94,104.07 140.94,101.13 141.71,100.37 141.71,99.43 140.6,98.32 140.6,89.37
FMC_HPC1_LA22_N: length 152.5
  TOP w0.104: U1.AY13 134.74,55.34 v2(135.24,54.84) ; J2.G25 v1(146.46,165.86)
  18_SIG6 w0.076: 141.6,73.2 141.57,73.2 141.53,73.24 138.02,73.24 137.84,73.06 137.84,62.59 137.84,62.59 137.84,62.09 137.84,62.09 137.84,61.59 137.84,61.59 137.84,61.09 137.84,61.09 137.84,60.59 137.49,60.24 135.07,60.24 134.84,60.01 134.84,54.95 134.95,54.84 v2(135.24,54.84)
  18_SIG6 w0.089: v1(146.46,165.86) 146.69,166.1 146.69,166.22 146.56,166.36 146.24,166.36 145.96,166.08 145.96,157.92 146.17,157.71 147.4,157.71 150.24,154.88 150.24,148.32 149.77,147.86 149.77,147.67 152.38,145.05 152.38,144.57 151.9,144.09 151.41,144.09 150.73,144.78 150.54,144.78 149.75,143.99 149.33,143.99 148.79,144.54 148.79,144.96 149.57,145.74 149.57,145.93 148.8,146.7 148.61,146.7 146.6,144.69 146.6,140.55 146.14,140.09 145.45,140.09 145.26,139.9 145.26,139.28 145.43,139.11 146.78,139.11 148.86,137.03 151.01,137.03 151.53,136.51 151.53,135.25 151.67,135.12 153.94,135.12 154.24,134.82 154.24,134.05 153.94,133.75 151.67,133.75 151.53,133.61 151.53,132.92 150.83,132.22 150.83,125.02 150.96,124.89 151.52,124.89 151.81,124.59 151.81,123.82 151.52,123.52 150.9,123.52 150.14,122.76 150.14,120.6 150.74,119.99 150.74,114.99 149.35,113.6 149.35,109.04 145.89,105.58 145.2,105.58 144.12,104.5 144.12,103.9 143.71,103.49 143.71,101.72 143.85,101.59 143.85,99.71 142.1,97.97 142.1,73.51 141.79,73.2 141.6,73.2
FMC_HPC1_LA22_P: length 153.9
  TOP w0.104: J2.G24 v1(147.73,165.86) ; v2(134.24,54.84) 133.74,55.34 U1.AW13
  18_SIG6 w0.076: 141.64,73.48 141.57,73.48 141.53,73.44 137.93,73.44 137.64,73.15 137.64,62.64 137.63,62.63 137.63,62.01 137.64,62.01 137.64,61.68 137.63,61.68 137.63,61.01 137.64,61.01 137.64,60.68 137.4,60.44 134.99,60.44 134.64,60.09 134.64,54.95 134.53,54.84 v2(134.24,54.84)
  18_SIG6 w0.089: v1(147.73,165.86) 147.17,165.86 146.97,166.06 146.97,166.34 146.67,166.64 146.12,166.64 145.68,166.2 145.68,157.81 146.05,157.44 147.29,157.44 149.96,154.77 149.96,148.44 149.49,147.97 149.49,147.55 152.1,144.94 152.1,144.69 151.78,144.37 151.53,144.37 150.84,145.06 150.42,145.06 149.64,144.27 149.45,144.27 149.07,144.65 149.07,144.84 149.85,145.63 149.85,146.05 148.92,146.98 148.5,146.98 146.32,144.81 146.32,140.67 146.02,140.37 145.33,140.37 144.98,140.01 144.98,139.17 145.32,138.83 146.66,138.83 146.66,138.83 148.74,136.75 150.9,136.75 151.25,136.39 151.25,135.13 151.55,134.84 153.83,134.84 153.96,134.7 153.96,134.16 153.83,134.03 151.55,134.03 151.25,133.73 151.25,133.04 150.55,132.34 150.55,124.91 150.85,124.61 151.4,124.61 151.53,124.47 151.53,123.94 151.4,123.8 150.79,123.8 149.86,122.88 149.86,120.48 150.46,119.88 150.46,115.11 149.07,113.72 149.07,109.16 145.77,105.86 145.09,105.86 143.84,104.62 143.84,104.01 143.43,103.61 143.43,101.61 143.57,101.47 143.57,99.83 141.82,98.08 141.82,73.63 141.68,73.48 141.64,73.48
FMC_HPC1_LA23_N: length 154
  TOP w0.104: J2.D24 v1(147.73,162.05) ; U1.AP16 v2(129.24,57.84)
  20_SIG7 w0.076: 141.69,71.2 141.65,71.24 131.04,71.24 130.84,71.04 130.84,67.51 130.57,67.24 129.07,67.24 129.07,67.24 129.04,67.24 128.84,67.04 128.84,57.95 128.95,57.84 v2(129.24,57.84)
  20_SIG7 w0.089: 141.69,71.2 142.31,71.2 144.06,72.96 144.06,89.64 146.23,91.81 146.23,96.23 149.09,99.09 149.09,101.29 150.14,102.34 150.14,103.24 149.04,104.34 149.04,104.9 149.7,105.55 149.7,106.18 150.15,106.63 150.15,113.56 151.59,115 151.59,116.03 152.06,116.51 152.06,118.25 152.48,118.66 153.39,118.66 154.54,119.81 154.54,121.83 153.4,122.98 153.4,132.68 153.15,132.93 152.2,132.93 152.09,133.05 152.09,133.29 152.26,133.47 153.15,133.47 153.4,133.72 153.4,134.25 152.01,135.64 152.01,137.91 150.54,139.37 150.54,145.18 149.98,145.75 149.76,145.75 149.67,145.84 149.67,148.26 149.41,148.51 148.83,148.51 148.57,148.26 148.57,145.84 148.49,145.75 146.96,145.75 146.51,146.2 146.51,147.46 146.64,147.6 147.58,147.6 147.9,147.92 147.9,148.44 147.51,148.83 146.64,148.83 146.51,148.96 146.51,149.37 146.64,149.5 148.34,149.5 148.64,149.8 148.64,150.44 148.34,150.73 146.64,150.73 146.51,150.87 146.51,151.81 146.64,151.94 147.83,151.94 148.21,152.32 148.21,153.01 147.91,153.31 146.64,153.31 146.51,153.44 146.51,153.98 146.64,154.12 147.91,154.12 148.21,154.41 148.21,155.18 147.91,155.48 146.21,155.48 145.92,155.77 145.92,156.07 146.14,156.29 146.93,156.29 147.23,156.59 147.23,162.35 147.43,162.55 148.11,162.55 148.32,162.34 148.32,161.98 148.22,161.88 147.9,161.88 v1(147.73,162.05)
FMC_HPC1_LA23_P: length 154.2
  TOP w0.104: U1.AN16 v2(128.24,57.84) ; J2.D23 v1(149,162.05)
  20_SIG7 w0.076: v2(128.24,57.84) 128.56,57.84 128.64,57.92 128.64,67.12 128.96,67.44 128.99,67.44 128.99,67.44 130.49,67.44 130.64,67.59 130.64,71.13 130.95,71.44 141.65,71.44 141.7,71.48
  20_SIG7 w0.089: v1(149,162.05) 148.22,162.83 147.31,162.83 146.95,162.47 146.95,156.7 146.82,156.57 146.02,156.57 145.64,156.19 145.64,155.65 146.09,155.2 147.79,155.2 147.93,155.07 147.93,154.53 147.79,154.4 146.53,154.4 146.23,154.1 146.23,153.33 146.53,153.03 147.79,153.03 147.93,152.89 147.93,152.44 147.71,152.22 146.53,152.22 146.23,151.92 146.23,150.75 146.53,150.46 148.22,150.46 148.36,150.32 148.36,149.92 148.22,149.78 146.53,149.78 146.23,149.48 146.23,148.85 146.53,148.55 147.39,148.55 147.62,148.32 147.62,148.04 147.46,147.88 146.53,147.88 146.23,147.58 146.23,146.09 146.85,145.47 148.6,145.47 148.85,145.72 148.85,148.14 148.94,148.23 149.3,148.23 149.39,148.14 149.39,145.72 149.64,145.47 149.86,145.47 150.26,145.07 150.26,139.26 151.73,137.79 151.73,135.52 153.12,134.13 153.12,133.83 153.03,133.75 152.14,133.75 151.81,133.41 151.81,132.93 152.09,132.65 153.03,132.65 153.12,132.56 153.12,122.86 154.26,121.72 154.26,119.93 153.28,118.94 152.36,118.94 151.78,118.36 151.78,116.62 151.31,116.15 151.31,115.12 149.87,113.68 149.87,106.74 149.42,106.3 149.42,105.67 148.77,105.01 148.77,104.22 149.87,103.12 149.87,102.46 148.81,101.4 148.81,99.21 145.95,96.35 145.95,91.92 143.79,89.76 143.79,73.07 142.19,71.48 141.7,71.48
FMC_HPC1_LA24_N: length 157.5
  TOP w0.104: J2.H29 v1(141.38,167.13) ; U1.AR13 v2(130.24,54.84)
  18_SIG6 w0.076: 138.9,89.78 138.9,89.75 138.85,89.7 138.85,87.36 138.82,87.33 138.82,84.65 138.84,84.63 138.84,76.57 138.52,76.24 135.01,76.24 134.84,76.07 134.84,63.58 134.5,63.24 131.07,63.24 130.84,63.02 130.84,55.58 130.51,55.25 129.93,55.25 129.83,55.15 129.83,54.95 129.93,54.84 v2(130.24,54.84)
  18_SIG6 w0.089: 138.9,89.78 138.9,92.71 138.02,93.59 138.02,100.24 139.19,101.4 139.19,109.46 139.96,110.24 140.92,110.24 141.99,111.31 141.99,112.71 141.51,113.2 141.51,115.89 141.6,115.98 142.17,115.98 142.42,116.23 142.42,116.73 142.17,116.98 141.6,116.98 141.51,117.07 141.51,117.29 142.37,118.15 142.37,123.62 142.93,124.18 145.78,124.18 146.28,124.67 146.28,129.6 145.35,130.53 145.35,131.92 140.96,136.31 140.96,143.53 140.22,144.26 140.22,145.82 140.31,145.9 141.05,145.9 141.3,146.16 141.3,146.74 141.05,147 140.31,147 140.22,147.09 140.22,148.19 139.79,148.62 139.79,150.33 140.29,150.83 141.74,150.83 141.87,150.69 141.87,150.19 141.74,150.06 141.07,150.06 140.77,149.76 140.77,148.99 141.07,148.69 141.74,148.69 141.87,148.56 141.87,146.71 142.17,146.41 142.94,146.41 143.24,146.71 143.24,148.32 143.37,148.45 145.21,148.45 145.51,148.75 145.51,149.52 145.21,149.82 143.37,149.82 143.24,149.95 143.24,150.69 143.37,150.83 143.68,150.83 144.07,151.22 144.07,152.78 143.4,153.45 143.4,156.15 143,156.55 141.26,156.55 140.88,156.93 140.88,167.39 141.12,167.63 141.76,167.63 142.02,167.36 142.02,167.02 141.92,166.92 141.58,166.92 v1(141.38,167.13)
FMC_HPC1_LA24_P: length 157.7
  TOP w0.104: J2.H28 v1(142.65,167.13) ; U1.AP13 v2(129.24,54.84)
  18_SIG6 w0.076: v2(129.24,54.84) 129.55,54.84 129.63,54.92 129.63,55.23 129.85,55.44 130.42,55.44 130.64,55.66 130.64,63.1 130.98,63.44 134.42,63.44 134.64,63.66 134.64,76.15 134.93,76.44 138.43,76.44 138.64,76.65 138.64,84.55 138.62,84.57 138.62,87.41 138.66,87.45 138.66,89.72 138.63,89.75 138.63,89.78
  18_SIG6 w0.089: v1(142.65,167.13) 141.87,167.91 141,167.91 140.6,167.51 140.6,156.81 141.14,156.27 142.89,156.27 143.12,156.03 143.12,153.33 143.79,152.67 143.79,151.33 143.56,151.11 143.26,151.11 142.96,150.81 142.96,149.84 143.26,149.54 145.09,149.54 145.23,149.4 145.23,148.86 145.09,148.73 143.26,148.73 142.96,148.43 142.96,146.83 142.83,146.69 142.29,146.69 142.15,146.83 142.15,148.67 141.85,148.97 141.19,148.97 141.05,149.1 141.05,149.64 141.19,149.78 141.85,149.78 142.15,150.08 142.15,150.81 141.85,151.11 140.18,151.11 139.51,150.44 139.51,148.5 139.94,148.08 139.94,146.97 140.19,146.72 140.93,146.72 141.02,146.63 141.02,146.27 140.93,146.18 140.19,146.18 139.94,145.93 139.94,144.15 140.68,143.41 140.68,136.19 145.07,131.81 145.07,130.42 146,129.48 146,124.79 145.67,124.46 142.81,124.46 142.09,123.73 142.09,118.27 141.23,117.41 141.23,116.95 141.48,116.7 142.05,116.7 142.14,116.61 142.14,116.35 142.05,116.26 141.48,116.26 141.23,116 141.23,113.08 141.71,112.6 141.71,111.43 140.8,110.51 139.85,110.51 138.91,109.58 138.91,101.52 137.74,100.36 137.74,93.47 138.63,92.59 138.63,89.78
FMC_HPC1_LA25_N: length 151.9
  TOP w0.104: U1.AU12 v2(132.24,53.84) ; J2.G28 v1(142.65,165.86)
  18_SIG6 w0.076: v2(132.24,53.84) 131.92,53.84 131.83,53.93 131.83,62.01 132.07,62.24 135.5,62.24 135.83,62.58 135.83,75.05 136.03,75.25 139.52,75.25 139.83,75.56 139.83,84.44 139.85,84.46 139.85,87.27 139.83,87.29 139.83,89.79 139.88,89.84 139.88,89.86
  18_SIG6 w0.089: v1(142.65,165.86) 142.99,165.52 143.15,165.52 143.23,165.6 143.23,166.15 143.03,166.36 142.4,166.36 142.15,166.11 142.15,157.82 142.38,157.59 143.66,157.59 144.34,156.91 144.34,156.01 144.47,155.87 146.42,155.87 146.73,155.56 146.73,154.82 146.41,154.51 144.69,154.51 144.55,154.37 144.55,153.84 144.69,153.7 147.74,153.7 148.04,153.4 148.04,152.63 147.74,152.33 145.63,152.33 145.54,152.24 145.54,151.61 145.63,151.52 147.74,151.52 148.04,151.22 148.04,149.97 141.99,143.93 141.99,136.56 143.42,135.13 146.06,135.13 147.23,133.96 147.23,121.78 147.75,121.26 147.75,120.08 148.63,119.2 148.63,117.33 147.22,115.92 147.22,115.12 146.91,114.82 143.41,114.82 143.29,114.7 143.29,110.13 142.88,109.72 141.65,109.72 141.18,109.25 140.28,109.25 140.12,109.09 140.12,101.09 139.32,100.29 139.32,94.2 139.88,93.64 139.88,89.86
FMC_HPC1_LA25_P: length 151.9
  TOP w0.104: J2.G27 v1(143.92,165.86) ; U1.AT12 v2(131.24,53.84)
  18_SIG6 w0.076: 139.6,89.86 139.6,89.84 139.63,89.81 139.63,87.21 139.66,87.18 139.66,84.54 139.64,84.52 139.64,75.64 139.44,75.44 135.95,75.44 135.64,75.13 135.64,62.66 135.42,62.44 131.99,62.44 131.64,62.09 131.64,53.93 131.55,53.84 v2(131.24,53.84)
  18_SIG6 w0.089: v1(143.92,165.86) 143.14,166.64 142.28,166.64 141.87,166.22 141.87,157.7 142.26,157.31 143.55,157.31 144.06,156.8 144.06,155.89 144.36,155.59 146.3,155.59 146.45,155.45 146.45,154.93 146.3,154.78 144.58,154.78 144.27,154.48 144.27,153.72 144.58,153.42 147.62,153.42 147.76,153.28 147.76,152.75 147.62,152.61 145.52,152.61 145.26,152.36 145.26,151.5 145.52,151.24 147.62,151.24 147.76,151.11 147.76,150.08 141.71,144.04 141.71,136.44 143.31,134.85 145.95,134.85 146.95,133.84 146.95,121.66 147.47,121.15 147.47,119.97 148.35,119.08 148.35,117.44 146.94,116.03 146.94,115.24 146.8,115.1 143.29,115.1 143.01,114.81 143.01,110.24 142.76,110 141.53,110 141.07,109.53 140.16,109.53 139.84,109.21 139.84,101.21 139.04,100.41 139.04,94.08 139.6,93.53 139.6,89.86
FMC_HPC1_LA26_N: length 160.1
  TOP w0.104: J2.D27 v1(143.92,162.05) ; U1.AL15 v2(126.24,56.84)
  20_SIG7 w0.076: 141.62,73.2 141.58,73.24 129.02,73.24 128.84,73.06 128.84,69.59 128.49,69.24 126.07,69.24 125.84,69.01 125.84,57.16 125.72,57.04 125.72,56.79 125.87,56.63 126.02,56.63 v2(126.24,56.84)
  20_SIG7 w0.089: 141.62,73.2 141.85,73.2 142.14,73.49 142.14,90.37 143.75,91.97 143.75,96.91 146.07,99.23 146.07,101.81 145.34,102.54 145.34,105.06 148.31,108.03 148.31,115.32 150.3,117.3 150.3,119.83 150.07,120.06 150.07,127.72 150.77,128.41 150.77,130.35 145.53,135.58 145.53,136.4 142.04,139.89 142.04,140.68 142.17,140.81 143.61,140.81 143.74,140.68 143.74,139.52 144.07,139.19 144.84,139.19 145.11,139.47 145.11,140.68 145.24,140.81 145.65,140.81 145.95,141.11 145.95,141.88 145.65,142.18 142.17,142.18 142.04,142.31 142.04,143.08 142.17,143.22 144.86,143.22 145.16,143.52 145.16,144.29 144.86,144.58 140.89,144.58 140.15,145.32 140.15,150.32 140.29,150.46 141.74,150.46 142.06,150.77 142.06,153.41 141.74,153.72 138.73,153.72 138.53,153.92 138.53,154.33 138.73,154.53 140.65,154.53 141.06,154.94 141.06,157.09 141.2,157.22 142.95,157.22 143.42,157.69 143.42,162.4 143.57,162.55 144.3,162.55 144.55,162.29 144.55,162.15 144.46,162.05 v1(143.92,162.05)
FMC_HPC1_LA26_P: length 159.9
  TOP w0.104: U1.AK15 v2(125.24,56.84) ; J2.D26 v1(145.19,162.05)
  20_SIG7 w0.076: v2(125.24,56.84) 125.64,57.25 125.64,69.1 125.98,69.44 128.4,69.44 128.64,69.68 128.64,73.14 128.94,73.44 141.58,73.44 141.62,73.48
  20_SIG7 w0.089: 141.62,73.48 141.74,73.48 141.86,73.61 141.86,90.48 143.47,92.09 143.47,97.02 145.79,99.35 145.79,101.69 145.06,102.42 145.06,105.17 148.03,108.14 148.03,115.43 150.02,117.42 150.02,119.72 149.79,119.94 149.79,127.83 150.49,128.53 150.49,130.23 145.25,135.47 145.25,136.29 141.76,139.78 141.76,140.79 142.06,141.09 143.72,141.09 144.02,140.79 144.02,139.63 144.18,139.47 144.72,139.47 144.83,139.58 144.83,140.79 145.13,141.09 145.54,141.09 145.67,141.23 145.67,141.76 145.54,141.9 142.06,141.9 141.76,142.2 141.76,143.2 142.06,143.5 144.75,143.5 144.88,143.63 144.88,144.17 144.75,144.3 140.77,144.3 139.87,145.2 139.87,150.44 140.17,150.73 141.63,150.73 141.78,150.89 141.78,153.29 141.63,153.44 138.62,153.44 138.25,153.81 138.25,154.45 138.61,154.81 140.53,154.81 140.78,155.06 140.78,157.2 141.08,157.5 142.83,157.5 143.14,157.81 143.14,162.51 143.45,162.83 144.41,162.83 v1(145.19,162.05)
FMC_HPC1_LA27_N: length 157.7
  TOP w0.104: J2.C27 v1(143.92,160.78) ; U1.AM14 v2(127.24,55.84)
  20_SIG7 w0.076: 141.63,72.2 141.63,72.2 141.58,72.25 129.98,72.25 129.83,72.1 129.83,68.6 129.48,68.25 126.99,68.25 126.83,68.09 126.83,56.25 v2(127.24,55.84)
  20_SIG7 w0.089: v1(143.92,160.78) 144.69,161.56 145.61,161.56 145.96,161.21 145.96,157.76 145.6,157.4 144.81,157.4 144.56,157.15 144.56,156.29 144.26,155.99 142.11,155.99 141.99,155.87 141.99,155.28 142.07,155.19 145.23,155.19 145.53,154.89 145.53,154.12 145.23,153.82 143.42,153.82 143.33,153.73 143.33,153.1 143.42,153.01 144.88,153.01 145.34,152.56 145.34,151.88 144.95,151.49 143.17,151.49 143.04,151.35 143.04,150.82 143.17,150.68 145.23,150.68 145.53,150.38 145.53,149.61 145.23,149.31 143.17,149.31 143.04,149.18 143.04,148.64 143.17,148.51 145.23,148.51 145.53,148.21 145.53,147.44 145.23,147.14 143.17,147.14 142.98,146.95 142.98,146.52 143.17,146.33 145.23,146.33 145.53,146.03 145.53,145.3 146.93,143.91 146.93,136.17 151.64,131.45 151.64,127.39 151.39,127.14 151.06,127.14 150.97,127.05 150.97,126.78 151.06,126.69 151.39,126.69 151.64,126.44 151.64,125.94 151.39,125.69 151.06,125.69 150.97,125.6 150.97,123.94 151.09,123.82 151.79,123.82 152.16,123.45 152.16,122.32 151.61,121.77 151.61,120.49 151.18,120.06 151.18,116.9 150.69,116.41 150.69,115.47 149.21,113.99 149.21,107.01 147.67,105.47 147.67,104.87 148.12,104.42 148.12,102.7 147.61,102.19 147.61,100.51 147.82,100.31 147.82,99.13 144.65,95.97 144.65,91.54 143.09,89.98 143.09,73.25 142.05,72.2 141.63,72.2
FMC_HPC1_LA27_P: length 157.7
  TOP w0.104: U1.AL14 v2(126.24,55.84) ; J2.C26 v1(145.19,160.78)
  20_SIG7 w0.076: v2(126.24,55.84) 126.36,55.72 126.54,55.72 126.64,55.82 126.64,68.18 126.9,68.44 129.4,68.44 129.64,68.68 129.64,72.18 129.9,72.44 141.6,72.44 141.63,72.48
  20_SIG7 w0.089: 141.63,72.48 141.93,72.48 142.81,73.36 142.81,90.09 144.38,91.66 144.38,96.08 147.54,99.24 147.54,100.19 147.33,100.39 147.33,102.3 147.84,102.81 147.84,104.3 147.39,104.75 147.39,105.59 148.93,107.12 148.93,114.1 150.41,115.59 150.41,116.52 150.9,117.02 150.9,120.17 151.33,120.6 151.33,121.89 151.89,122.44 151.89,123.33 151.68,123.54 150.97,123.54 150.69,123.82 150.69,125.72 150.94,125.97 151.28,125.97 151.36,126.06 151.36,126.32 151.28,126.41 150.94,126.41 150.69,126.67 150.69,127.16 150.94,127.42 151.28,127.42 151.36,127.5 151.36,131.33 146.65,136.05 146.65,143.79 145.25,145.18 145.25,145.92 145.12,146.05 143.06,146.05 142.7,146.41 142.7,147.07 143.06,147.42 145.12,147.42 145.25,147.55 145.25,148.09 145.12,148.23 143.06,148.23 142.76,148.53 142.76,149.3 143.06,149.59 145.12,149.59 145.25,149.73 145.25,150.27 145.12,150.4 143.06,150.4 142.76,150.7 142.76,151.47 143.06,151.77 144.83,151.77 145.06,151.99 145.06,152.44 144.77,152.73 143.31,152.73 143.05,152.99 143.05,153.85 143.31,154.1 145.12,154.1 145.25,154.23 145.25,154.77 145.12,154.91 141.96,154.91 141.71,155.16 141.71,155.98 142,156.27 144.14,156.27 144.28,156.41 144.28,157.26 144.69,157.68 145.49,157.68 145.68,157.88 145.68,161.09 145.5,161.28 144.81,161.28 144.6,161.07 144.6,160.68 144.74,160.54 144.95,160.54 v1(145.19,160.78)
FMC_HPC1_LA28_N: length 150.2
  TOP w0.104: J2.H32 v1(137.57,167.13) ; U1.AW10 v2(134.24,51.84)
  18_SIG6 w0.076: v2(134.24,51.84) 133.92,51.84 133.81,51.73 133.81,51.5 133.56,51.25 131.95,51.25 131.64,51.56 131.64,53.07 131.46,53.24 127.93,53.24 127.64,53.53 127.64,65.21 127.99,65.56 132.01,65.56 132.64,66.19 132.64,78.13 132.95,78.44 136.47,78.44 136.64,78.61 136.64,84.27 136.62,84.29 136.62,87.47 136.66,87.51 136.66,89.8 136.62,89.83 136.62,89.85
  18_SIG6 w0.089: 136.62,89.85 136.62,91.55 135,93.18 135,94.88 135.89,95.77 135.89,101.04 137.01,102.16 137.01,109.77 136.47,110.32 136.47,113.05 137.32,113.9 137.32,117.3 138.34,118.32 139.37,118.32 140.05,119 140.05,125.87 139.41,126.51 139.41,129.82 138.77,130.46 138.77,133.69 137.67,134.79 137.67,144.16 137.16,144.68 136.48,144.68 130.74,150.42 128.91,150.42 128.45,150.89 128.45,151.5 128.87,151.92 134.44,151.92 136.58,154.07 136.58,156.82 137.12,157.35 137.84,157.35 138.06,157.57 138.06,166.64 v1(137.57,167.13)
FMC_HPC1_LA28_P: length 150
  TOP w0.104: J2.H31 v1(138.84,167.13) ; U1.AV10 v2(133.24,51.84)
  18_SIG6 w0.076: v2(133.24,51.84) 133.51,51.84 133.61,51.75 133.61,51.58 133.47,51.44 132.03,51.44 131.83,51.64 131.83,53.15 131.55,53.44 128.01,53.44 127.83,53.62 127.83,65.13 128.07,65.36 132.09,65.36 132.84,66.11 132.84,78.05 133.03,78.24 136.56,78.24 136.84,78.53 136.84,84.35 136.82,84.37 136.82,87.39 136.85,87.43 136.85,89.78 136.9,89.83 136.9,89.85
  18_SIG6 w0.089: 136.9,89.85 136.9,91.67 135.28,93.29 135.28,94.77 136.17,95.66 136.17,100.93 137.29,102.05 137.29,109.89 136.75,110.43 136.75,112.93 137.6,113.78 137.6,117.18 138.46,118.04 139.48,118.04 140.33,118.89 140.33,125.98 139.69,126.62 139.69,129.93 139.05,130.58 139.05,133.81 137.95,134.91 137.95,144.28 137.27,144.96 136.6,144.96 130.85,150.7 129.03,150.7 128.73,151 128.73,151.38 128.99,151.65 134.55,151.65 136.86,153.96 136.86,156.71 137.23,157.07 137.96,157.07 138.34,157.46 138.34,167.19 138.49,167.34 138.63,167.34 v1(138.84,167.13)
FMC_HPC1_LA29_N: length 157.9
  TOP w0.104: U1.AP15 v2(129.24,56.84) ; J2.G31 v1(138.84,165.86)
  18_SIG6 w0.076: 137.58,89.76 137.58,89.75 137.62,89.71 137.62,87.24 137.66,87.2 137.66,84.57 137.64,84.55 137.64,77.64 137.44,77.44 133.97,77.44 133.64,77.11 133.64,64.67 133.42,64.44 129.94,64.44 129.64,64.14 129.64,56.6 129.48,56.44 129.01,56.44 128.87,56.58 128.87,56.75 128.96,56.84 v2(129.24,56.84)
  18_SIG6 w0.089: v1(138.84,165.86) 139.2,165.86 139.33,165.73 139.33,157.63 139.5,157.46 139.5,155.14 139.97,154.66 141.98,154.66 142.21,154.43 142.21,152.48 142.09,152.35 141.58,152.35 141.46,152.47 141.46,153.6 141.16,153.89 140.39,153.89 140.09,153.6 140.09,152.78 139.95,152.65 138.43,152.65 138.18,152.4 138.18,150.93 137.54,150.29 136.35,150.29 135.68,150.96 133.55,150.96 133.16,150.57 133.16,149.53 134.53,148.16 136.28,148.16 136.41,148.03 136.41,146.14 136.71,145.84 137.48,145.84 137.78,146.14 137.78,148.03 137.91,148.16 138.51,148.16 138.81,147.87 138.81,142.71 139.1,142.42 139.53,142.42 139.67,142.28 139.67,141.74 139.53,141.61 139.1,141.61 138.81,141.31 138.81,140.54 139.1,140.24 139.53,140.24 139.67,140.11 139.67,139.57 139.53,139.43 139.1,139.43 138.81,139.14 138.81,138.37 139.1,138.07 139.53,138.07 139.67,137.93 139.67,137.39 139.53,137.26 139.1,137.26 138.81,136.96 138.81,135.06 139.77,134.1 139.77,133.51 140.07,133.21 142.29,133.21 142.43,133.08 142.43,132.54 142.29,132.4 140.07,132.4 139.65,131.98 139.65,130.9 140.03,130.51 142.02,130.51 142.16,130.37 142.16,128 142.76,127.4 142.76,125.71 141.16,124.11 141.16,124.1 141.04,123.97 141.04,118.68 140.28,117.91 140.28,114.12 138.51,112.35 138.51,110.91 137.96,110.36 137.96,101.84 136.78,100.66 136.78,95.37 136.1,94.69 136.1,93.67 137.58,92.19 137.58,89.76
FMC_HPC1_LA29_P: length 158.4
  TOP w0.104: U1.AN15 v2(128.24,56.84) ; J2.G30 v1(140.11,165.86)
  18_SIG6 w0.076: v2(128.24,56.84) 128.6,56.84 128.67,56.77 128.67,56.49 128.93,56.24 129.56,56.24 129.84,56.51 129.84,64.05 130.03,64.24 133.5,64.24 133.84,64.58 133.84,77.03 134.05,77.24 137.52,77.24 137.84,77.55 137.84,84.47 137.85,84.48 137.85,87.28 137.82,87.32 137.82,89.7 137.86,89.74 137.86,89.76
  18_SIG6 w0.089: 137.86,89.76 137.86,92.31 136.38,93.78 136.38,94.57 137.06,95.25 137.06,100.54 138.24,101.72 138.24,110.24 138.79,110.79 138.79,112.24 140.56,114.01 140.56,117.8 141.32,118.56 141.32,123.86 141.44,123.98 141.44,124 142.79,125.34 142.81,125.34 143.04,125.58 143.04,127.51 142.44,128.12 142.44,130.49 142.13,130.79 140.15,130.79 139.93,131.01 139.93,131.87 140.18,132.12 142.41,132.12 142.71,132.42 142.71,133.19 142.41,133.49 140.18,133.49 140.05,133.62 140.05,134.21 139.09,135.18 139.09,136.85 139.22,136.98 139.65,136.98 139.95,137.28 139.95,138.05 139.65,138.35 139.22,138.35 139.09,138.48 139.09,139.02 139.22,139.15 139.65,139.15 139.95,139.45 139.95,140.22 139.65,140.52 139.22,140.52 139.09,140.66 139.09,141.19 139.22,141.33 139.65,141.33 139.95,141.63 139.95,142.4 139.65,142.7 139.22,142.7 139.09,142.83 139.09,147.99 138.63,148.44 137.8,148.44 137.5,148.15 137.5,146.26 137.36,146.12 136.82,146.12 136.69,146.26 136.69,148.15 136.39,148.44 134.64,148.44 133.44,149.65 133.44,150.45 133.67,150.68 135.57,150.68 136.24,150.01 137.66,150.01 138.46,150.81 138.46,152.28 138.54,152.37 140.07,152.37 140.37,152.67 140.37,153.48 140.5,153.61 141.04,153.61 141.18,153.48 141.18,152.36 141.46,152.07 142.2,152.07 142.49,152.36 142.49,154.54 142.09,154.94 140.09,154.94 139.78,155.25 139.78,157.57 139.61,157.74 139.61,165.37 v1(140.11,165.86)
FMC_HPC1_LA30_N: length 159.1
  TOP w0.104: J2.H35 v1(133.76,167.13) ; v2(126.24,53.84) U1.AL12
  18_SIG6 w0.076: v2(126.24,53.84) 125.92,53.84 125.84,53.93 125.84,67.02 126.06,67.24 130.5,67.24 130.84,67.57 130.84,80.02 131.06,80.24 133.52,80.24 133.84,80.56 133.84,84.36 133.85,84.37 133.85,87.35 133.82,87.38 133.82,89.6 133.86,89.65 133.86,89.67
  18_SIG6 w0.089: 133.86,89.67 133.86,89.91 132.76,91.02 132.76,101.85 133.68,102.77 133.68,114.15 135.56,116.03 135.56,117.91 136.71,119.06 136.71,126.68 137.58,127.55 137.58,128.49 136.45,129.61 136.45,132.54 136.02,132.98 136.02,136.19 134.43,137.78 134.43,142.86 128.66,148.63 124.81,148.63 123.06,150.38 122.12,150.38 120.52,151.98 120.52,157.28 120.95,157.71 121.8,157.71 122.1,157.42 122.1,156.83 121.42,156.16 121.42,154.77 121.86,154.33 123.74,154.33 124.02,154.05 133.85,154.05 134.53,154.73 134.53,158.56 134.08,159.02 133.43,159.02 133.26,159.18 133.26,167.49 133.4,167.63 134.09,167.63 134.23,167.49 134.23,167.27 134.09,167.13 v1(133.76,167.13)
FMC_HPC1_LA30_P: length 159.9
  TOP w0.104: J2.H34 v1(135.03,167.13) ; v2(125.24,53.84) U1.AK12
  18_SIG6 w0.076: v2(125.24,53.84) 125.55,53.84 125.64,53.93 125.64,67.1 125.97,67.44 130.42,67.44 130.64,67.66 130.64,80.11 130.98,80.44 133.44,80.44 133.64,80.64 133.64,84.44 133.66,84.46 133.66,87.27 133.62,87.3 133.62,89.63 133.58,89.66 133.58,89.67
  18_SIG6 w0.089: 133.58,89.67 133.58,89.8 132.48,90.9 132.48,101.96 133.4,102.88 133.4,114.26 135.28,116.14 135.28,118.02 136.43,119.17 136.43,126.8 137.3,127.66 137.3,128.37 136.18,129.49 136.18,132.42 135.74,132.86 135.74,136.08 134.15,137.67 134.15,142.75 128.55,148.35 124.7,148.35 122.95,150.1 122.01,150.1 120.24,151.87 120.24,157.39 120.84,157.99 121.92,157.99 122.38,157.53 122.38,156.72 121.7,156.04 121.7,154.88 121.97,154.61 123.86,154.61 124.14,154.33 133.74,154.33 134.25,154.84 134.25,158.45 133.96,158.74 133.31,158.74 132.98,159.07 132.98,167.6 133.29,167.91 134.25,167.91 v1(135.03,167.13)
FMC_HPC1_LA31_N: length 157.8
  TOP w0.104: J2.G34 v1(135.03,165.86) ; v2(127.24,53.84) U1.AM12
  18_SIG6 w0.076: 135.2,89.52 135.22,89.5 135.27,89.5 135.62,89.14 135.62,87.21 135.66,87.18 135.66,84.44 135.64,84.43 135.64,79.65 135.43,79.45 131.94,79.45 131.64,79.15 131.64,66.65 131.32,66.33 127.43,66.33 126.64,65.54 126.64,54.45 126.85,54.23 127.19,54.23 127.24,54.19 v2(127.24,53.84)
  18_SIG6 w0.089: v1(135.03,165.86) 135.2,165.86 135.52,165.54 135.52,154.34 134.08,152.9 122.12,152.9 121.75,152.53 121.75,151.68 122.3,151.12 124.13,151.12 124.52,150.73 124.52,149.86 124.9,149.48 125.47,149.48 125.76,149.78 125.76,151.26 125.91,151.41 126.4,151.41 126.57,151.24 126.57,149.78 126.87,149.48 129.34,149.48 136.7,142.12 136.7,141.62 136.56,141.49 135.42,141.49 135.12,141.19 135.12,140.42 135.42,140.12 136.62,140.12 136.76,139.99 136.76,139.45 136.62,139.31 135.32,139.31 135.03,139.02 135.03,138.25 135.33,137.95 136.56,137.95 136.7,137.81 136.7,134.28 137.78,133.2 137.78,130.1 138.26,129.63 138.26,127.11 137.38,126.23 137.38,118.8 136.37,117.79 136.37,114.28 134.7,112.6 134.7,100.9 134.95,100.65 134.95,96.81 133.41,95.27 133.41,91.31 135.2,89.52
FMC_HPC1_LA31_P: length 157.3
  TOP w0.104: J2.G33 v1(136.3,165.86) ; U1.AM13 v2(127.24,54.84)
  18_SIG6 w0.076: 135.4,89.71 135.42,89.7 135.42,89.63 135.82,89.23 135.82,87.29 135.85,87.26 135.85,84.36 135.84,84.35 135.84,79.57 135.52,79.25 132.02,79.25 131.84,79.06 131.84,66.56 131.4,66.13 127.51,66.13 126.83,65.46 126.83,54.53 126.93,54.43 127.14,54.43 127.24,54.53 v2(127.24,54.84)
  18_SIG6 w0.089: 135.4,89.71 133.69,91.43 133.69,95.15 135.23,96.7 135.23,100.76 134.98,101.02 134.98,112.48 136.65,114.16 136.65,117.68 137.66,118.68 137.66,126.12 138.54,127 138.54,129.74 138.06,130.22 138.06,133.32 136.98,134.4 136.98,137.93 136.68,138.23 135.45,138.23 135.31,138.36 135.31,138.9 135.44,139.03 136.74,139.03 137.04,139.33 137.04,140.1 136.74,140.4 135.53,140.4 135.4,140.53 135.4,141.07 135.53,141.21 136.68,141.21 136.98,141.51 136.98,142.24 129.45,149.76 126.99,149.76 126.85,149.9 126.85,151.36 126.52,151.69 125.79,151.69 125.48,151.38 125.48,149.9 125.35,149.76 125.02,149.76 124.8,149.98 124.8,150.85 124.24,151.4 122.42,151.4 122.03,151.79 122.03,152.41 122.24,152.62 134.2,152.62 135.8,154.22 135.8,165.37 v1(136.3,165.86)
FMC_HPC1_LA32_N: length 160.3
  TOP w0.104: U1.AJ12 v2(124.24,53.84) ; J2.H38 v1(129.95,167.13)
  18_SIG6 w0.076: 130.57,90.32 130.57,90.31 130.62,90.25 130.62,89.52 130.66,89.49 130.66,87.11 130.62,87.07 130.62,84.38 130.64,84.36 130.64,83.62 130.47,83.44 128.94,83.44 128.63,83.14 128.63,69.61 128.47,69.44 123.96,69.44 123.64,69.11 123.64,54.46 123.86,54.23 124.16,54.23 124.24,54.16 v2(124.24,53.84)
  18_SIG6 w0.089: v1(129.95,167.13) 130.44,166.64 130.44,156.67 130.16,156.39 125.86,156.39 125.73,156.51 125.73,161.99 123.2,164.52 119.1,164.52 118.29,163.7 118.29,149.97 120.56,147.7 120.98,147.7 121.26,147.98 121.45,147.98 121.74,147.69 121.74,147.5 121.46,147.22 121.46,146.8 121.92,146.34 123.51,146.34 124.12,145.73 126.93,145.73 129.68,142.98 129.68,135.13 130.2,134.62 130.87,134.62 133.29,132.2 133.29,124.67 132.37,123.76 132.37,116.94 130.63,115.2 130.63,113.46 131.06,113.03 131.06,107.06 130.25,106.25 130.25,101.84 130.57,101.52 130.57,90.32
FMC_HPC1_LA32_P: length 160.2
  TOP w0.104: v2(124.24,54.84) 123.74,55.34 U1.AJ13 ; J2.H37 v1(131.22,167.13)
  18_SIG6 w0.076: 130.85,90.32 130.85,90.29 130.82,90.27 130.82,89.61 130.85,89.57 130.85,87.02 130.82,86.99 130.82,84.46 130.84,84.44 130.84,83.54 130.55,83.24 129.02,83.24 128.83,83.05 128.83,69.53 128.55,69.24 124.04,69.24 123.83,69.03 123.83,54.54 123.94,54.43 124.14,54.43 124.24,54.53 v2(124.24,54.84)
  18_SIG6 w0.089: v1(131.22,167.13) 130.86,167.13 130.72,167 130.72,156.55 130.28,156.11 125.74,156.11 125.45,156.4 125.45,161.87 123.09,164.24 119.22,164.24 118.57,163.59 118.57,150.09 120.68,147.98 120.87,147.98 121.15,148.26 121.57,148.26 122.02,147.81 122.02,147.39 121.74,147.11 121.74,146.92 122.04,146.62 123.63,146.62 124.24,146.01 127.04,146.01 129.96,143.09 129.96,135.25 130.31,134.9 130.98,134.9 133.57,132.31 133.57,124.55 132.65,123.64 132.65,116.83 130.91,115.09 130.91,113.58 131.34,113.15 131.34,106.95 130.53,106.13 130.53,101.96 130.85,101.64 130.85,90.32
FMC_HPC1_LA33_N: length 160.9
  TOP w0.104: J2.G37 v1(131.22,165.86) ; U1.AK13 v2(125.24,54.84)
  18_SIG6 w0.076: v2(125.24,54.84) 125.24,55.16 125.16,55.23 124.91,55.23 124.64,55.5 124.64,68.14 124.94,68.44 129.42,68.44 129.64,68.66 129.64,82.16 129.93,82.44 131.48,82.44 131.63,82.6 131.63,84.53 131.66,84.55 131.66,87.2 131.62,87.24 131.62,89.36 131.71,89.45 131.71,90.22 131.66,90.27 131.66,90.28
  18_SIG6 w0.089: v1(131.22,165.86) 131.71,165.37 131.71,157.91 132.48,157.15 132.48,155.67 132.17,155.36 125.01,155.36 124.08,156.3 124.08,157.15 124.84,157.91 124.84,160.45 123.06,162.23 121.59,162.23 120.34,160.98 119.64,160.98 119.27,160.61 119.27,150.97 121.29,148.96 122.77,148.96 125.05,146.68 128.45,146.68 131.13,143.99 131.13,136.75 131.74,136.14 132.16,136.14 132.77,136.74 132.96,136.74 133.34,136.36 133.34,136.17 132.67,135.5 132.67,134.3 135.14,131.83 135.14,128.3 134.73,127.89 134.73,126.72 135.47,125.99 135.47,125.73 135.38,125.64 134.64,125.64 134.39,125.39 134.39,124.89 134.64,124.64 135.38,124.64 135.47,124.55 135.47,119.54 133.73,117.8 133.73,116.68 131.95,114.9 131.95,102.93 131.49,102.47 131.49,90.7 131.66,90.53 131.66,90.28
