# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Nets (continued)
VCC12_SW: C146.1(CAP2) C257.1(CAP2) C288.1(CAP2) C499.1 C1011.1(CAP2) C1314.1(CAP2) C1412.1(CAP2) C1413.1(CAP2) C1415.1(CAP2) C1632.1(CAP2) C1633.1(CAP2) C1634.1(CAP2) C1635.1(CAP2) C1636.1(CAP2) C1648.1(CAP2) C1656.1(CAP2) DS4.2 DS26.2 DS27.2 DS28.2 DS46.2 J2.C35(12P0V_1) J2.C37(12P0V_2) J22.C35(12P0V_1) J22.C37(12P0V_2) J22.L36(12P0V_3) J22.L37(12P0V_4) J22.L40(12P0V_5) J36.2(P2) J54.1(P1) J73.2(P2) L6.1 L22.1 L65.1 L76.1 L77.1 L79.1 L90.1 L91.1 L92.1 R14.1 R95.1 R157.1 R333.1 R463.1 R1020.1 R1021.1 R1075.1 R1111.1 R1113.1 R1116.1 R1158.1 R1160.1 R1164.1 R1216.1 R1217.1 R1218.1 R1327.1 U16.8(CB)
VCC12_UTIL_1V35: C1315.1(CAP2) C1316.1(CAP2) L65.2 Q39.8(VP1) Q39.9(VP2)
VCC12_UTIL_3V3: C1437.1(CAP2) C1438.1(CAP2) C1439.1(CAP2) C1440.1(CAP2) L79.2 Q47.5(D_5) Q47.6(D_6) Q47.7(D_7) Q47.8(D_8)
VCC12_VADJ_1V8: C215.1(CAP2) C216.1(CAP2) L22.2 Q9.8(VP1) Q9.9(VP2)
VCC12_VCC1V2: C1431.1(CAP2) C1432.1(CAP2) L77.2 Q43.8(VP1) Q43.9(VP2)
VCC12_VCC1V8: C1429.1(CAP2) C1430.1(CAP2) L76.2 Q42.8(VP1) Q42.9(VP2)
VCC12_VCCINT: C121.1(CAP2) C149.1(CAP2) C151.1(CAP2) C193.1(CAP2) C195.1(CAP2) C226.1(CAP2) C227.1(CAP2) C1584.1(CAP2) C1585.1(CAP2) C1589.1(CAP2) C1590.1(CAP2) C1592.1(CAP2) C1593.1(CAP2) C1605.1(CAP2) C1606.1(CAP2) C1607.1(CAP2) C1609.1(CAP2) C1610.1(CAP2) C1611.1(CAP2) C1612.1(CAP2) C1613.1(CAP2) C1614.1(CAP2) C1657.1(CAP2) C1658.1(CAP2) C1661.1(CAP2) C1662.1(CAP2) C1663.1(CAP2) C1664.1(CAP2) L92.2 U11.1(VDDH) U159.1(VDDH) U160.1(VDDH) U161.1(VDDH)
VCC12_VCCINTIO_BRAM: C147.1(CAP2) C148.1(CAP2) L6.2 Q19.8(VP1) Q19.9(VP2)
VCCINT: C1757.1(CAP2) C1758.1(CAP2) L95.1 L95.3 L95.5 L95.7 R168.1(R1) R1228.1 Z6.1(NET1)
VCCINT_A3_IN: C1637.2(CAP1) C1691.1(CAP2) R169.1 R1223.1 R1224.1 R1225.1 R1244.1 R1272.2 U164.30(A3_IN)
VCCINT_FPGA: C153.1(CAP2) C159.1(CAP2) C163.1(CAP2) C164.1(CAP2) C165.1(CAP2) C196.1(CAP2) C197.1(CAP2) C206.1 C230.1 C330.1 C331.1(CAP2) C334.1(CAP2) C460.1 C461.1 C462.1 C657.1(CAP2) C658.1(CAP2) C659.1(CAP2) C906.1(CAP2) C907.1(CAP2) C908.1(CAP2) C909.1(CAP2) C911.1 C914.1(CAP2) C915.1 C916.1(CAP2) C917.1(CAP2) C918.1(CAP2) C919.1(CAP2) C920.1(CAP2) C921.1(CAP2) C922.1(CAP2) C923.1(CAP2) C1455.1(CAP2) C1486.1(CAP2) C1487.1(CAP2) C1488.1(CAP2) C1557.1(CAP2) C1558.1(CAP2) C1559.1(CAP2) C1755.1(CAP2) C1756.1(CAP2) D36.1(CATHODE) J5.1(P1) J107.1(P1) R168.2(R2) U1.AA15(VCCINT_AA15) U1.AA17(VCCINT_AA17) U1.AA19(VCCINT_AA19) U1.AA21(VCCINT_AA21) U1.AA23(VCCINT_AA23) U1.AA25(VCCINT_AA25) U1.AB14(VCCINT_AB14) U1.AB16(VCCINT_AB16) U1.AB20(VCCINT_AB20) U1.AB22(VCCINT_AB22) U1.AB24(VCCINT_AB24) U1.AB26(VCCINT_AB26) U1.AC15(VCCINT_AC15) U1.AC19(VCCINT_AC19) U1.AC21(VCCINT_AC21) U1.AC23(VCCINT_AC23) U1.AC25(VCCINT_AC25) U1.AD16(VCCINT_AD16) U1.AD20(VCCINT_AD20) U1.AD22(VCCINT_AD22) U1.AD24(VCCINT_AD24) U1.AD26(VCCINT_AD26) U1.AE15(VCCINT_AE15) U1.AE19(VCCINT_AE19) U1.AE21(VCCINT_AE21) U1.AE23(VCCINT_AE23) U1.AE25(VCCINT_AE25) U1.AF16(VCCINT_AF16) U1.AF18(VCCINT_AF18) U1.AF20(VCCINT_AF20) U1.AF22(VCCINT_AF22) U1.AF24(VCCINT_AF24) U1.AF26(VCCINT_AF26) U1.AG15(VCCINT_AG15) U1.AG17(VCCINT_AG17) U1.AG19(VCCINT_AG19) U1.AG21(VCCINT_AG21) U1.AG23(VCCINT_AG23) U1.AG25(VCCINT_AG25) U1.AH16(VCCINT_AH16) U1.AH18(VCCINT_AH18) U1.AH20(VCCINT_AH20) U1.AH22(VCCINT_AH22) U1.AH24(VCCINT_AH24) U1.AH26(VCCINT_AH26) U1.AJ15(VCCINT_AJ15) U1.AJ17(VCCINT_AJ17) U1.AJ19(VCCINT_AJ19) U1.AJ21(VCCINT_AJ21) U1.AJ23(VCCINT_AJ23) U1.AJ25(VCCINT_AJ25) U1.AK16(VCCINT_AK16) U1.AK18(VCCINT_AK18) U1.AK20(VCCINT_AK20) U1.AK22(VCCINT_AK22) U1.AK24(VCCINT_AK24) U1.AK26(VCCINT_AK26) U1.U17(VCCINT_U17) U1.U19(VCCINT_U19) U1.U21(VCCINT_U21) U1.U23(VCCINT_U23) U1.U25(VCCINT_U25) U1.V18(VCCINT_V18) U1.V20(VCCINT_V20) U1.V22(VCCINT_V22) U1.V24(VCCINT_V24) U1.V26(VCCINT_V26) U1.W17(VCCINT_W17) U1.W19(VCCINT_W19) U1.W21(VCCINT_W21) U1.W23(VCCINT_W23) U1.W25(VCCINT_W25) U1.Y16(VCCINT_Y16) U1.Y18(VCCINT_Y18) U1.Y20(VCCINT_Y20) U1.Y22(VCCINT_Y22) U1.Y24(VCCINT_Y24) U1.Y26(VCCINT_Y26) Z7.1(NET1) Z128.2(NET2)
VCCINT_ISENSE1: R1225.2 R1269.2 U159.15(ISENSE)
VCCINT_ISENSE2: R1224.2 R1268.2 U160.15(ISENSE)
VCCINT_ISENSE3: R1223.2 R1267.2 U161.15(ISENSE)
VCCINT_ISENSE4: R169.2 R171.2 U11.15(ISENSE)
VCCINT_PGOOD: D10.1(CATHODE) RP2.8 U51.3(A1) U164.24(PWRGD)
VCCINT_PWM1: U159.13(PWM) U164.18(PWM1)
VCCINT_PWM2: U160.13(PWM) U164.17(PWM2)
VCCINT_PWM3: U161.13(PWM) U164.16(PWM3)
VCCINT_PWM4: U11.13(PWM) U164.15(PWM4)
VCCINT_SLAVE_1V8: C228.1(CAP2) C1608.1(CAP2) C1677.1(CAP2) C1678.1(CAP2) C1679.1(CAP2) L96.1 R167.1 R1208.1 R1209.1 R1210.1 R1230.1 U11.11(VCC) U159.11(VCC) U160.11(VCC) U161.11(VCC)
VCCINT_SNS_N: C1688.2(CAP1) U164.35(SENSE_N) Z129.1(NET1)
VCCINT_SNS_P: C1688.1(CAP2) U35.8(VBUS) U164.36(SENSE_P) Z128.1(NET1)
VCCINT_TS_FAULTB: C1714.1(CAP2) R196.1 R1275.1 R1276.1 R1277.1 U164.19(TS_FAULTB)
VCCINT_VDD_MASTER: C1587.1(CAP2) C1660.1(CAP2) R1230.2 R1235.1 U164.8(VDD)
VCCINT_VIN_N: C152.1(CAP2) R109.1 U35.9(VIN_N)
VCCINT_VIN_P: C152.2(CAP1) R110.1 U35.10(VIN_P)
VCCINT_VIN_R_N: R109.2 Z7.2(NET2)
VCCINT_VIN_R_P: R110.2 Z6.2(NET2)
VCCINT_VIN_UV: C1712.1(CAP2) R1216.2 R1219.1 U164.14(VIN_UV)
VCCINT_VX1: C1700.1(CAP2) C1778.1(CAP2) L95.2 U159.6(VX) U159.7(VX_1) U159.8(VX_2) U159.9(VX_3)
VCCINT_VX2: C1701.1(CAP2) C1779.1(CAP2) L95.4 U160.6(VX) U160.7(VX_1) U160.8(VX_2) U160.9(VX_3)
VCCINT_VX3: C1702.1(CAP2) C1780.1(CAP2) L95.6 U161.6(VX) U161.7(VX_1) U161.8(VX_2) U161.9(VX_3)
VCCINT_VX4: C231.1(CAP2) C233.1(CAP2) L95.8 U11.6(VX) U11.7(VX_1) U11.8(VX_2) U11.9(VX_3)
VCCINTIO_BRAM: C131.1(CAP2) L7.2 R79.2 R156.1 R161.1 Z2.2(NET2)
VCCINTIO_BRAM_DH_R: Q19.1(HSG) R154.2
VCCINTIO_BRAM_DL: Q19.7(LSG) U6.19(DL)
VCCINTIO_BRAM_FET_SWITCH: C184.2(CAP1) L7.1 Q19.2(SW1) Q19.3(SW2) Q19.4(SW3) R80.2 R139.1 R158.2 U6.16(LX)
VCCINTIO_BRAM_FPGA: C160.1(CAP2) C205.1(CAP2) C1462.1(CAP2) C1463.1(CAP2) D16.1(CATHODE) J21.1(P1) R78.2 R161.2 U1.AA27(VCCINT_IO_AA27) U1.AC13(VCCBRAM_AC13) U1.AC27(VCCINT_IO_AC27) U1.AD14(VCCBRAM_AD14) U1.AE27(VCCINT_IO_AE27) U1.AF14(VCCBRAM_AF14) U1.AG13(VCCBRAM_AG13) U1.AG27(VCCINT_IO_AG27) U1.AH14(VCCBRAM_AH14) U1.AJ27(VCCINT_IO_AJ27) U1.AK28(VCCINT_IO_AK28) U1.U27(VCCINT_IO_U27) U1.V28(VCCINT_IO_V28) U1.W27(VCCINT_IO_W27) Z4.2(NET2)
VCCINTIO_BRAM_FPGA_SNS_N: C175.1(CAP2) C187.2(CAP1) U6.26(OUTN) Z5.1(NET1)
VCCINTIO_BRAM_FPGA_SNS_P: C187.1(CAP2) U6.27(OUTP) U8.8(VBUS) Z4.1(NET1)
VCCINTIO_BRAM_FPGA_VIN: C127.1(CAP2) R78.1 U8.9(VIN_N)
VCCINTIO_BRAM_PGOOD: D17.1(CATHODE) Q26.1(GATE) R106.2 U6.32(PG)
VCCINTIO_BRAM_TEMPX: C188.1(CAP2) Q20.1(BASE) Q20.2(COLLECTOR) U6.7(TEMPX)
VCCINTIO_BRAM_VIN: C127.2(CAP1) R79.1 U8.10(VIN_P)
VCCPLL: C794.1(CAP2) C835.1(CAP2) L62.1 U111.F5(VCCPLL_F5)
1N1524: J2.B1(CLK_DIR)
1N1551: J2.D34(TRST_L)
1N1554: J2.B40(RES0)
1N4342: J2.A2(DP1_M2C_P)
1N4343: J2.A18(DP5_M2C_P)
1N4344: J2.A3(DP1_M2C_N)
1N4345: J2.A27(DP2_C2M_N)
1N4346: J2.A26(DP2_C2M_P)
1N4347: J2.A7(DP2_M2C_N)
1N4348: J2.A23(DP1_C2M_N)
1N4349: J2.A6(DP2_M2C_P)
1N4350: J2.A11(DP3_M2C_N)
1N4351: J2.A19(DP5_M2C_N)
1N4352: J2.A14(DP4_M2C_P)
1N4353: J2.A15(DP4_M2C_N)
1N4354: J2.A10(DP3_M2C_P)
1N4355: J2.A22(DP1_C2M_P)
1N4377: J2.A30(DP3_C2M_P)
1N4378: J2.A31(DP3_C2M_N)
1N4379: J2.A35(DP4_C2M_N)
1N4380: J2.A34(DP4_C2M_P)
1N4381: J2.A39(DP5_C2M_N)
1N4383: J2.A38(DP5_C2M_P)
1N4399: J2.B4(DP9_M2C_P)
1N4400: J2.B5(DP9_M2C_N)
1N4401: J2.B9(DP8_M2C_N)
1N4402: J2.B8(DP8_M2C_P)
1N4403: J2.B13(DP7_M2C_N)
1N4404: J2.B16(DP6_M2C_P)
1N4405: J2.B17(DP6_M2C_N)
1N4406: J2.B12(DP7_M2C_P)
1N4423: J2.B24(DP9_C2M_P)
1N4424: J2.B25(DP9_C2M_N)
1N4425: J2.B29(DP8_C2M_N)
1N4426: J2.B28(DP8_C2M_P)
1N4427: J2.B33(DP7_C2M_N)
1N4428: J2.B36(DP6_C2M_P)
1N4429: J2.B37(DP6_C2M_N)
1N4430: J2.B32(DP7_C2M_P)
1N4447: J2.C2(DP0_C2M_P)
1N4448: J2.C3(DP0_C2M_N)
1N4449: J2.C7(DP0_M2C_N)
1N4450: J2.C6(DP0_M2C_P)
1N4611: J2.D4(GBTCLK0_M2C_P)
1N4612: J2.D5(GBTCLK0_M2C_N)
1N4617: J2.B20(GBTCLK1_M2C_P)
1N4618: J2.B21(GBTCLK1_M2C_N)
4N2355: D15.2 R115.1
4N2356: DS2.4(RED_CATHODE) R473.2
4N2357: DS2.1(GRN_ANODE) R472.2
4N2358: R472.1 R473.1 U53.3(A)
4N4374: J78.1(P1) R554.1
4N4376: J78.2(P2) R553.1
4N4692: D15.1
4N6788: DS34.1 R598.1
4N6800: Q2.3(DRAIN) R598.2
5N11680: U1.AN29(VREF_40_AN29)
5N11683: U1.AU36(VREF_42_AU36)
6N5608: U1.AL26(VREF_41_AL26)
7N8237: U1.J15(VREF_71_J15)
8N9313: R193.1 R218.2 U31.1(TH1)
8N9315: R217.2 R319.1 U31.15(TH2)
8N9317: R213.2 R318.1 U31.3(TL1)
8N9319: R208.2 R229.1 U31.2(TL2)
8N9384: R221.2 R223.1 U31.13(OT2)
8N9386: R220.2 R222.1 U31.14(OT1)
8N9847: U1.AL17(VREF_65_AL17)
8N9851: U1.BF20(IO_L1N_T0L_N1_DBC_RS1_65_BF20)
8N9854: U1.BE20(IO_L1P_T0L_N0_DBC_RS0_65_BE20)
8N9858: U1.BE19(IO_L3P_T0L_N4_AD15P_A26_65_BE19)
8N9859: U1.BF19(IO_L3N_T0L_N5_AD15N_A27_65_BF19)
8N9863: U1.AR17(IO_L19N_T3L_N1_DBC_AD9N_D11_65_AR17)
8N9864: U1.AN18(IO_L20N_T3L_N3_AD1N_D09_65_AN18)
8N9865: U1.AN19(IO_L20P_T3L_N2_AD1P_D08_65_AN19)
8N9869: U1.AT19(IO_L18N_T2U_N11_AD2N_D13_65_AT19)
8N9870: U1.AR18(IO_L19P_T3L_N0_DBC_AD9P_D10_65_AR18)
8N9871: U1.AW17(IO_T2U_N12_CSI_ADV_B_65_AW17)
8N9873: U1.BF17(IO_L2P_T0L_N2_FOE_B_65_BF17)
8N9880: U1.BD20(IO_L5N_T0U_N9_AD14N_A23_65_BD20)
8N9881: U1.BD17(IO_L6N_T0U_N11_AD6N_A21_65_BD17)
8N9882: U1.BD18(IO_L6P_T0U_N10_AD6P_A20_65_BD18)
8N9883: U1.BE18(IO_L4P_T0U_N6_DBC_AD7P_A24_65_BE18)
8N9884: U1.BC20(IO_L5P_T0U_N8_AD14P_A22_65_BC20)
8N9885: U1.BE17(IO_L4N_T0U_N7_DBC_AD7N_A25_65_BE17)
8N9892: U1.AT17(IO_L17P_T2U_N8_AD10P_D14_65_AT17)
8N9893: U1.AT20(IO_L18P_T2U_N10_AD2P_D12_65_AT20)
8N9894: U1.AU17(IO_L17N_T2U_N9_AD10N_D15_65_AU17)
8N9895: U1.AW20(IO_L15N_T2L_N5_AD11N_A03_D19_65_AW20)
8N9896: U1.AR19(IO_L16N_T2U_N7_QBC_AD3N_A01_D17_65_AR19)
8N9897: U1.AR20(IO_L16P_T2U_N6_QBC_AD3P_A00_D16_65_AR20)
8N9910: U1.AU19(IO_L14P_T2L_N2_GC_A04_D20_65_AU19)
8N9911: U1.AV20(IO_L15P_T2L_N4_AD11P_A02_D18_65_AV20)
8N9912: U1.AU18(IO_L14N_T2L_N3_GC_A05_D21_65_AU18)
8N9913: U1.AY17(IO_T1U_N12_SMBALERT_65_AY17)
8N9914: U1.AV18(IO_L13N_T2L_N1_GC_QBC_A07_D23_65_AV18)
8N9915: U1.AV19(IO_L13P_T2L_N0_GC_QBC_A06_D22_65_AV19)
8N9916: U1.BA19(IO_L11N_T1U_N9_GC_A11_D27_65_BA19)
8N9917: U1.AY18(IO_L12N_T1U_N11_GC_A09_D25_65_AY18)
8N9918: U1.AW18(IO_L12P_T1U_N10_GC_A08_D24_65_AW18)
8N9919: U1.BA17(IO_L10P_T1U_N6_QBC_AD4P_A12_D28_65_BA17)
8N9920: U1.AY19(IO_L11P_T1U_N8_GC_A10_D26_65_AY19)
8N9921: U1.BB17(IO_L10N_T1U_N7_QBC_AD4N_A13_D29_65_BB17)
8N9928: U1.BC18(IO_L8N_T1L_N3_AD5N_A17_65_BC18)
8N9929: U1.BC19(IO_L9N_T1L_N5_AD12N_A15_D31_65_BC19)
8N9930: U1.BB19(IO_L9P_T1L_N4_AD12P_A14_D30_65_BB19)
8N9931: U1.AY20(IO_L7P_T1L_N0_QBC_AD13P_A18_65_AY20)
8N9932: U1.BB18(IO_L8P_T1L_N2_AD5P_A16_65_BB18)
8N9933: U1.BA20(IO_L7N_T1L_N1_QBC_AD13N_A19_65_BA20)
8N9935: U1.AL19(IO_L24N_T3U_N11_DOUT_CSO_B_65_AL19)
9N9684: U1.K36(IO_T3U_N12_45_K36)
9N9688: U1.R36(IO_T2U_N12_45_R36)
9N9690: U1.V30(IO_T1U_N12_45_V30)
9N9738: U1.AH30(IO_T3U_N12_43_AH30)
9N9739: U1.AM31(IO_T2U_N12_43_AM31)
9N10300: U1.W31(IO_L9N_T1L_N5_AD12N_45_W31)
9N10301: U1.U32(IO_L8N_T1L_N3_AD5N_45_U32)
9N10302: U1.U31(IO_L8P_T1L_N2_AD5P_45_U31)
9N10303: U1.T31(IO_L7N_T1L_N1_QBC_AD13N_45_T31)
9N10304: U1.Y31(IO_L9P_T1L_N4_AD12P_45_Y31)
9N10308: U1.T30(IO_L7P_T1L_N0_QBC_AD13P_45_T30)
9N10384: U1.L38(IO_L15N_T2L_N5_AD11N_45_L38)
9N10385: U1.M37(IO_L15P_T2L_N4_AD11P_45_M37)
9N10740: U1.R33(IO_L12N_T1U_N11_GC_45_R33)
9N10741: U1.T33(IO_L12P_T1U_N10_GC_45_T33)
10N8170: U1.AM16(IO_T3U_N12_67_AM16)
10N8224: U1.BB11(IO_T3U_N12_66_BB11)
10N8836: U1.AR15(IO_T2U_N12_67_AR15)
10N8842: U1.AW16(IO_T1U_N12_67_AW16)
10N8984: U1.BD10(IO_L11N_T1U_N9_GC_66_BD10)
10N8985: U1.BC10(IO_L11P_T1U_N8_GC_66_BC10)
10N8987: U1.BE10(IO_L9P_T1L_N4_AD12P_66_BE10)
10N8988: U1.BE7(IO_L8N_T1L_N3_AD5N_66_BE7)
10N8989: U1.BE8(IO_L8P_T1L_N2_AD5P_66_BE8)
10N8990: U1.BD7(IO_L7N_T1L_N1_QBC_AD13N_66_BD7)
10N8992: U1.BE9(IO_L9N_T1L_N5_AD12N_66_BE9)
10N8994: U1.BD8(IO_L7P_T1L_N0_QBC_AD13P_66_BD8)
10N9224: U1.AU14(IO_L11P_T1U_N8_GC_67_AU14)
10N9225: U1.AN13(IO_L15N_T2L_N5_AD11N_67_AN13)
10N9226: U1.AN14(IO_L15P_T2L_N4_AD11P_67_AN14)
10N9228: U1.AU13(IO_L11N_T1U_N9_GC_67_AU13)
10N9606: U1.BB8(IO_L14N_T2L_N3_GC_66_BB8)
10N9607: U1.BB9(IO_L14P_T2L_N2_GC_66_BB9)
10N9644: U1.BA10(IO_T2U_N12_66_BA10)
10N9645: U1.BF7(IO_T1U_N12_66_BF7)
11N5838: U1.AE8(MGTREFCLK1N_226_AE8)
11N5839: U1.AE9(MGTREFCLK1P_226_AE9)
11N8666: U1.AN9(MGTREFCLK1P_224_AN9)
11N8667: U1.AN8(MGTREFCLK1N_224_AN8)
11N8774: U1.AA9(MGTREFCLK1P_227_AA9)
11N8775: U1.AA8(MGTREFCLK1N_227_AA8)
11N9044: U1.AR9(MGTREFCLK0P_224_AR9)
11N9045: U1.AR8(MGTREFCLK0N_224_AR8)
12N5415: U1.AW21(NC_AW21)
17N1467: U19.18(B4)
17N1470: U19.15(B7)
17N1473: U19.14(B8)
17N1476: U19.10(A8)
17N1479: U19.9(A7)
17N1482: U19.6(A4)
17N1575: R575.2 U115.4(TMS)
17N1576: R574.2 U115.3(TDI)
17N1577: R573.2 U115.2(TCK)
17N1924: R861.2 U19.2(DIR)
17N2056: U13.4(B2)
17N2058: U13.9(A2)
17N2120: J106.4(ID) X7.3(ID)
17N2123: J106.6(SHLD1) J106.7(SHLD2) J106.8(SHLD3) J106.9(SHLD4) J106.10(SHLD5) J106.11(SHLD6) R1324.1
17N2128: X7.5(NC)
17N2513: J3.14(P14)
17N2516: J3.12(P12)
17N2634: J17.1(P1) U115.7(GPIO2_SRST)
17N2635: J18.1(P1) U115.6(GPIO1)
17N2674: J19.1(P1) R140.2 U115.5(GPIO0)
18N3158: U60.T7(NC)
18N4182: U61.T7(NC)
20N153: U62.T7(NC)
20N1721: U63.T7(NC)
21N4739: C639.2(CAP1) R565.2 R566.2
21N5660: U64.T7(NC)
22N1524: J22.B1(CLK_DIR)
22N1551: J22.D34(TRST_L)
22N1554: J22.B40(RES0)
23N1212: J22.E21(HB03_P)
23N1215: J22.E22(HB03_N)
23N1218: J22.E24(HB05_P)
23N1220: J22.E25(HB05_N)
23N1224: J22.E27(HB09_P)
23N1226: J22.E28(HB09_N)
23N1230: J22.E30(HB13_P)
23N1232: J22.E31(HB13_N)
23N1236: J22.E33(HB19_P)
23N1238: J22.E34(HB19_N)
23N1242: J22.E36(HB21_P)
23N1244: J22.E37(HB21_N)
23N1248: J22.F22(HB02_P)
23N1251: J22.F23(HB02_N)
23N1254: J22.F25(HB04_P)
23N1256: J22.F26(HB04_N)
23N1260: J22.F28(HB08_P)
23N1262: J22.F29(HB08_N)
23N1266: J22.F31(HB12_P)
23N1268: J22.F32(HB12_N)
23N1272: J22.F34(HB16_P)
23N1274: J22.F35(HB16_N)
23N1278: J22.F37(HB20_P)
23N1280: J22.F38(HB20_N)
24N1169: J22.J24(HB01_P)
24N1172: J22.J25(HB01_N)
24N1175: J22.J27(HB07_P)
24N1178: J22.J28(HB07_N)
24N1181: J22.J30(HB11_P)
24N1184: J22.J31(HB11_N)
24N1187: J22.J33(HB15_P)
24N1189: J22.J34(HB15_N)
24N1193: J22.J36(HB18_P)
24N1195: J22.J37(HB18_N)
24N1199: J22.J39(VIO_B_M2C_1)
24N1202: J22.K25(HB00_P_CC)
24N1205: J22.K26(HB00_N_CC)
24N1208: J22.K28(HB06_P_CC)
24N1211: J22.K29(HB06_N_CC)
24N1214: J22.K31(HB10_P)
24N1217: J22.K32(HB10_N)
24N1220: J22.K34(HB14_P)
24N1223: J22.K35(HB14_N)
24N1226: J22.K37(HB17_P_CC)
24N1229: J22.K38(HB17_N_CC)
24N1232: J22.K40(VIO_B_M2C_2)
24N1235: J22.K1(VREF_B_M2C)
24N1238: J22.K4(CLK2_BIDIR_P)
24N1241: J22.K5(CLK2_BIDIR_N)
24N1244: J22.J2(CLK3_BIDIR_P)
24N1247: J22.J3(CLK3_BIDIR_N)
25N293: C466.1(CAP2) J22.ST2(GND_ST2) R346.1
25N294: C467.1(CAP2) J22.ST1(GND_ST1) R345.1
26N1212: J2.E21(HB03_P)
26N1215: J2.E22(HB03_N)
26N1218: J2.E24(HB05_P)
26N1220: J2.E25(HB05_N)
26N1224: J2.E27(HB09_P)
26N1226: J2.E28(HB09_N)
26N1230: J2.E30(HB13_P)
26N1232: J2.E31(HB13_N)
26N1236: J2.E33(HB19_P)
26N1238: J2.E34(HB19_N)
26N1242: J2.E36(HB21_P)
26N1244: J2.E37(HB21_N)
26N1248: J2.F22(HB02_P)
26N1251: J2.F23(HB02_N)
26N1254: J2.F25(HB04_P)
26N1256: J2.F26(HB04_N)
26N1260: J2.F28(HB08_P)
26N1262: J2.F29(HB08_N)
26N1266: J2.F31(HB12_P)
26N1268: J2.F32(HB12_N)
26N1272: J2.F34(HB16_P)
26N1274: J2.F35(HB16_N)
26N1278: J2.F37(HB20_P)
26N1280: J2.F38(HB20_N)
26N1653: J2.F4(HA00_P_CC)
26N1655: J2.F5(HA00_N_CC)
26N1657: J2.F7(HA04_P)
26N1659: J2.F8(HA04_N)
26N1665: J2.F10(HA08_P)
26N1667: J2.F11(HA08_N)
26N1669: J2.F13(HA12_P)
26N1671: J2.F14(HA12_N)
26N1677: J2.F16(HA15_P)
26N1679: J2.F17(HA15_N)
26N1681: J2.F19(HA19_P)
26N1683: J2.F20(HA19_N)
26N1689: J2.E15(HA16_P)
26N1691: J2.E16(HA16_N)
26N1693: J2.E18(HA20_P)
26N1695: J2.E19(HA20_N)
26N1701: J2.E9(HA09_P)
26N1703: J2.E10(HA09_N)
26N1705: J2.E12(HA13_P)
26N1707: J2.E13(HA13_N)
26N1713: J2.E2(HA01_P_CC)
26N1715: J2.E3(HA01_N_CC)
26N1717: J2.E6(HA05_P)
26N1719: J2.E7(HA05_N)
27N2133: U2.A8(JTAG5/TMS)
27N2135: U2.A7(JTAG4/TDO)
27N2137: U2.A6(JTAG3/TDI)
27N2139: U2.A5(JTAG2/TCK)
27N2141: U2.B9(JTAG1/TRSTN)
27N2176: U2.A33(RSVD5)
27N2177: U2.A32(RSVD4)
27N2179: U2.A19(RSVD3)
27N2181: U2.B12(RSVD)
27N2183: U2.A50(RSVD6)
27N2225: U2.A10(+3.3V_3)
27N2226: U2.A9(+3.3V_2)
27N2228: U2.B10(3.3VAUX)
27N2231: U2.B6(SMDAT)
27N2232: U2.B5(SMCLK)
27N2234: U2.B82(RSVD2)
27N2236: U2.B8(+3.3V_1)
27N2238: U2.B30(RSVD1)
29N3158: U135.T7(NC)
29N4153: U136.T7(NC)
30N3617: U1.N12(IO_T2U_N12_70_N12)
30N3618: U1.J14(IO_T3U_N12_70_J14)
30N3619: U1.R16(IO_T1U_N12_70_R16)
30N4994: U1.AL22(VREF_64_AL22)
31N2260: R1241.1 R1261.1 U164.34(A1_OUT)
31N2264: C1689.2(CAP1) C1713.1(CAP2) R1215.1 R1261.2 U164.33(A2_IN)
31N2266: C1713.2(CAP1) C1719.2(CAP1) U164.32(A2_OUT)
31N2267: C1690.2(CAP1) R1272.1 U164.31(A2B_OUT)
31N2291: R1253.1 U164.28(A3_OUT_PS)
31N2351: C1719.1(CAP2) R1215.2
31N2375: C1689.1(CAP2) R1241.2
31N3241: R1206.1 U164.6(R_SEL3)
31N3243: R1201.1 U164.5(R_SEL2)
31N3245: R1205.1 U164.4(R_SEL1)
31N3247: R1254.1 U164.3(R_SEL0)
31N3249: R1265.1 U164.2(MRAMP)
31N3251: R1238.1 U164.1(R_REF)
31N3398: L96.2 U164.26(PVX)
31N3508: C1683.1(CAP2) R1267.1 U164.22(ISENSE3)
31N3515: C1684.1(CAP2) R1268.1 U164.21(ISENSE2)
31N3619: C1685.1(CAP2) R1269.1 U164.20(ISENSE1)
31N5850: C1691.2(CAP1) R1222.1 R1253.2 U164.29(A3_OUT_NORM)
31N5852: C1637.1(CAP2) R1222.2
31N6030: C1690.1(CAP2) R1244.2
31N6929: U164.10(NC)
31N8456: C229.1(CAP2) R171.1 U164.23(ISENSE4)
32N2260: R1236.1 R1263.1 U165.34(A1_OUT)
32N2264: C1724.2(CAP1) R1248.1 R1259.1 R1263.2 U165.33(A2_IN)
32N2266: C1638.2(CAP1) C1695.2(CAP1) U165.32(A2_OUT)
32N2267: R1273.1 U165.31(A2B_OUT)
32N2291: R1255.1 U165.28(A3_OUT_PS)
32N2351: C1638.1(CAP2) R1259.2
32N2375: C1724.1(CAP2) R1236.2
32N3241: R1280.1 U165.6(R_SEL3)
32N3243: R1213.1 U165.5(R_SEL2)
32N3245: R1281.1 U165.4(R_SEL1)
32N3247: R1256.1 U165.3(R_SEL0)
32N3249: R1229.1 U165.2(MRAMP)
32N3251: R1239.1 U165.1(R_REF)
32N3398: L97.2 U165.26(PVX)
32N3515: C1720.1(CAP2) R1270.1 U165.21(ISENSE2)
32N3990: C1599.1(CAP2) R1211.2 R1247.1 U162.12(VDD)
32N4051: C1708.1(CAP2) R1278.2 U162.16(TS_FAULTB)
32N5850: C1694.2(CAP1) R1233.1 R1255.2 U165.29(A3_OUT_NORM)
32N5852: C1722.1(CAP2) R1233.2
32N6304: C1703.2(CAP1) U162.10(BST)
32N7064: U165.10(NC)
32N8319: C1695.1(CAP2) R1248.2
32N9731: R129.2 U36.1(A1)
32N9732: R128.2 U36.2(A0)
34N153: U137.T7(NC)
34N2121: U138.T7(NC)
35N3590: U122.2(XB) X6.3(X2)
35N3592: U122.1(XA) X6.1(X1)
35N3667: R801.1 R803.2 U122.12(FS0)
35N3680: R802.2 R804.1 U122.19(FS1)
35N3787: U122.13(CLK2B)
35N3790: U122.9(CLK3B)
35N3861: U122.8(LOS)
35N3959: U157.8(VREF)
35N4086: U157.16(Q3_N)
35N4087: U157.15(Q3_P)
35N4466: R28.2 U18.2(OE)
35N4470: U18.1(NC)
35N4621: J8.2(P2) R9.1 U157.2(CLK_SEL)
36N328: R77.2 U32.2(OE)
36N711: U32.1(NC)
36N1001: U104.8(VREF)
36N1657: J9.2(P2) R194.1 U104.2(CLK_SEL)
36N1876: R86.2 U38.2(OE)
36N1879: U38.1(NC)
36N2434: R126.2 U14.1(OE)
36N2543: U14.2(NC)
38N7680: R44.1 U7.12(RBIAS)
38N7682: R30.2 U7.22(JTAG_TMS)
38N7683: R29.2 U7.23(JTAG_TDI)
38N7684: R31.2 U7.20(JTAG_CLK)
38N7720: X2.2(GND1)
38N7721: X2.4(GND2)
38N7725: R73.2 U7.25(TX_D3)
38N7726: R35.2 U7.26(TX_D2)
38N10481: U7.40(GPIO_1)
38N10484: U7.21(JTAG_TDO)
38N10562: U7.32(RX_CLK)
38N10573: U7.29(GTX_CLK)
38N10574: U7.48(VDDA1P8_1_17)
38N10575: U7.13(VDDA1P8_2_64)
38N10576: U7.37(TX_CTRL)
38N10790: R32.1 U7.18(CLK_OUT)
38N10890: DS1.2 R33.2
38N12235: C238.1(CAP2) J10.7(CT3)
38N12237: C237.1(CAP2) J10.1(CT2)
38N12239: C129.1(CAP2) J10.6(CT1)
38N12241: C1781.1(CAP2) J10.12(CT0)
39N5820: U133.13(NC6)
39N5821: U133.12(NC5)
39N5822: U133.11(NC4)
39N5824: R1017.2 U133.14(NC7)
39N5826: U133.5(NC2)
39N5827: U133.6(NC3)
39N5828: U133.4(NC1)
39N5864: U43.13(NC6)
39N5865: U43.12(NC5)
39N5866: U43.11(NC4)
39N5868: R215.2 U43.14(NC7)
39N5871: U43.5(NC2)
39N5872: U43.6(NC3)
39N5873: U43.4(NC1)
40N107: R352.1 R399.2 U12.3(A2)
40N4216: R498.1 U34.9(RST_B)
40N4217: C54.1(CAP2) C470.1(CAP2) U34.6(VDD)
40N4218: J4.4(ID) X1.3(ID)
40N4221: J4.6(SHLD1) J4.7(SHLD2) J4.8(SHLD3) J4.9(SHLD4) J4.10(SHLD5) J4.11(SHLD6) R1325.1
40N4233: U34.16(NC)
40N4235: U34.10(CTS_ECI_I)
40N4237: U34.11(RTS_ECI_O)
40N4239: U34.22(GPIO2_SCI_IO)
40N4241: U34.17(SUSPEND2_B_O)
40N4243: U34.1(SUSPEND1_B_O)
40N4245: X1.5(NC)
40N4295: R858.1 R859.1 U131.4(FB)
40N4316: Q55.3(DRAIN) U34.19(RTS_SCI_O)
40N4317: Q54.3(DRAIN) U34.18(CTS_SCI_I)
40N4318: Q53.3(DRAIN) U34.21(TXD_SCI_O)
40N4319: Q52.3(DRAIN) U34.20(RXD_SCI_I)
40N5161: U34.23(VDD18_30)
40N5164: U34.24(VDD18_28)
40N5167: U34.15(GPIO0_ECI_IO)
40N5170: U34.14(GPIO1_ECI_IO)
40N5326: Q56.3(DRAIN) U34.13(TXD_ECI_O)
40N5328: Q57.3(DRAIN) U34.12(RXD_ECI_I)
41N94: R840.2 SW6.1(P1) SW6.2(P2)
41N96: R841.2 SW9.1(P1) SW9.2(P2)
41N97: R839.2 SW10.1(P1) SW10.2(P2)
41N2776: R837.2 SW17.1(P1) SW17.2(P2)
41N2778: R838.2 SW7.1(P1) SW7.2(P2)
41N3761: DS7.2 R151.2
41N3762: DS6.2 R149.2
41N3763: DS8.2 R148.2
41N3764: DS9.2 R147.2
41N3765: DS10.2 R146.2
41N3766: DS12.2 R145.2
41N3767: DS13.2 R144.2
41N3768: DS18.2 R143.2
41N3809: DS10.1 Q12.3(DRAIN)
41N3810: DS8.1 Q14.3(DRAIN)
41N3811: DS6.1 Q15.3(DRAIN)
41N3812: DS9.1 Q13.3(DRAIN)
41N3813: DS7.1 Q16.3(DRAIN)
41N3814: DS12.1 Q11.3(DRAIN)
41N3815: DS13.1 Q10.3(DRAIN)
41N3816: DS18.1 Q8.3(DRAIN)
42N2449: U17.11(B8)
42N2458: U17.10(A8)
42N2553: U44.11(B8)
42N2555: U44.10(A8)
42N3296: R85.2 U44.19(VREFB) U44.20(EN)
42N3414: R89.2 U3.19(VREFB) U3.20(EN)
42N3417: R90.2 U17.19(VREFB) U17.20(EN)
42N3794: U17.13(B6)
42N3796: U17.8(A6)
43N2999: U1.T28(VREF_47_T28)
48N1291: R131.2 U41.19(VREFB) U41.20(EN)
48N1428: R132.2 U42.19(VREFB) U42.20(EN)
49N610: R75.2 R356.1 U28.21(A2)
49N611: R58.1 R355.2 U28.2(A1)
49N612: R59.1 R354.2 U28.1(A0)
49N3747: R581.1 R601.2 U80.21(A2)
49N3748: R580.2 R600.1 U80.2(A1)
49N3749: R582.1 R602.2 U80.1(A0)
49N6854: U80.19(SD7)
49N6856: U80.20(SC7)
49N7483: U80.17(SD6)
49N7484: U80.18(SC6)
49N7548: U28.6(SD1)
49N7549: U28.7(SC1)
51N1061: C242.2(CAP1) C910.2(CAP1) Q1.4(GATE) R273.1 R316.2
51N1068: Q4.3(DRAIN) R273.2
51N1070: R421.2 SW1.1(P1)
51N1071: DS26.1 R460.1
51N2166: C358.1(CAP2) U15.6(CDELAY)
51N2353: J12.2(P2) R639.2 U15.1(EN)
51N3244: C871.1(CAP2) R637.1 R638.2 U15.3(IN) U128.22(SHDN_B)
51N4062: R808.1 R816.2 U128.11(SET2)
51N4063: R815.1 R819.2 U128.8(SET3)
51N4064: R817.2 R827.1 U128.18(SET1)
51N4066: R809.1 R818.2 U128.4(EN)
51N4068: C873.1(CAP2) U128.3(ABP) U128.5(SET4) U128.14(EN_HOLD_B)
51N4071: C870.1(CAP2) U128.24(TIMEOUT)
51N4072: C869.1(CAP2) U128.23(DELAY)
51N4078: U128.6(OUT4)
51N4079: U128.28(CP_OUT)
51N4080: U128.15(REM)
51N4081: U128.19(OV_OUT_B)
51N4082: U128.21(FAULT_B)
51N4083: U128.27(SEQ3)
51N4084: U128.26(SEQ2)
51N4085: U128.25(SEQ1)
51N4086: U128.7(DISC4)
51N4580: DS20.1 R134.1
51N4656: J39.15(P15)
51N4658: J39.13(P13)
51N4660: J39.11(P11)
51N4662: J39.9(P9)
51N4664: J39.5(P5)
52N2260: R1237.1 R1264.1 U166.34(A1_OUT)
52N2264: C1725.2(CAP1) R1252.1 R1260.1 R1264.2 U166.33(A2_IN)
52N2266: C1639.2(CAP1) C1699.2(CAP1) U166.32(A2_OUT)
52N2267: R1274.1 U166.31(A2B_OUT)
52N2291: R1257.1 U166.28(A3_OUT_PS)
52N2351: C1639.1(CAP2) R1260.2
52N2375: C1725.1(CAP2) R1237.2
52N3241: R1207.1 U166.6(R_SEL3)
52N3243: R1262.1 U166.5(R_SEL2)
52N3245: R1214.1 U166.4(R_SEL1)
52N3247: R1258.1 U166.3(R_SEL0)
52N3249: R1266.1 U166.2(MRAMP)
52N3251: R1240.1 U166.1(R_REF)
52N3398: L98.2 U166.26(PVX)
52N3515: C1721.1(CAP2) R1271.1 U166.21(ISENSE2)
52N3990: C1604.1(CAP2) R1212.2 R1251.1 U163.12(VDD)
52N4051: C1709.1(CAP2) R1279.2 U163.16(TS_FAULTB)
52N5850: C1698.2(CAP1) R1234.1 R1257.2 U166.29(A3_OUT_NORM)
52N5852: C1723.1(CAP2) R1234.2
52N6304: C1704.2(CAP1) U163.10(BST)
52N7064: U166.10(NC)
52N8319: C1699.1(CAP2) R1252.2
52N9498: R130.2 U37.1(A1)
55N3098: R1158.2 U9.13(INSNS)
55N3099: C1442.1(CAP2) R1111.2 U9.22(PWR)
55N3100: R1166.1 U9.4(ADDR1)
55N3101: C1527.1(CAP2) R1136.2
55N3102: R1131.1 R1143.2 U9.1(SYNC)
55N3103: R1132.1 U9.2(ADDR0)
55N3104: R1125.1 U9.3(SET)
55N3109: C1401.1(CAP2) U9.18(GDRV)
55N3110: R1159.1 U9.14(LXSNS)
55N3111: C1523.1(CAP2) U9.17(BST)
55N3112: R1112.1 U9.15(DH)
55N3113: L82.2 U9.21(LBI)
55N3114: L82.1 U9.23(LBO)
55N3115: C1408.1(CAP2) U9.6(1P8)
55N3116: C1543.1(CAP2) U9.24(3P3_1) U9.25(3P3_2)
55N3155: C1531.2(CAP1) U9.30(DCRP) Z98.1(NET1)
55N3156: C1531.1(CAP2) U9.31(DCRN) Z97.1(NET1)
55N4690: R125.2 U23.2(A0)
55N4756: R1127.1 Z98.2(NET2)
56N1406: R463.2 U30.13(INSNS)
56N1407: C124.1(CAP2) R95.2 U30.22(PWR)
56N1411: C729.2(CAP1) U30.30(DCRP) Z66.1(NET1)
56N1412: R515.1 U30.4(ADDR1)
56N1413: C454.1(CAP2) R231.2
56N1414: R214.1 R362.2 U30.1(SYNC)
56N1415: R155.1 U30.2(ADDR0)
56N1416: R199.1 U30.3(SET)
56N1425: C258.1(CAP2) U30.18(GDRV)
56N1426: R464.1 U30.14(LXSNS)
56N1427: C406.1(CAP2) U30.17(BST)
56N1428: R98.1 U30.15(DH)
56N1429: L48.2 U30.21(LBI)
56N1430: L48.1 U30.23(LBO)
56N1431: C423.1(CAP2) U30.6(1P8)
56N1432: C480.1(CAP2) U30.24(3P3_1) U30.25(3P3_2)
56N1434: C729.1(CAP2) U30.31(DCRN) Z65.1(NET1)
56N2929: J14.1(P1) R435.2
56N5656: R712.1 Z66.2(NET2)
57N3698: R1160.2 U4.13(INSNS)
57N3699: C1443.1(CAP2) R1113.2 U4.22(PWR)
57N3700: R1167.1 U4.4(ADDR1)
57N3701: C1528.1(CAP2) R1137.2
57N3702: R1133.1 R1144.2 U4.1(SYNC)
57N3703: R1126.1 U4.2(ADDR0)
57N3704: R1108.1 U4.3(SET)
57N3709: C1402.1(CAP2) U4.18(GDRV)
57N3710: R1161.1 U4.14(LXSNS)
57N3711: C1524.1(CAP2) U4.17(BST)
57N3712: R1114.1 U4.15(DH)
57N3713: L83.2 U4.21(LBI)
57N3714: L83.1 U4.23(LBO)
57N3715: C1409.1(CAP2) U4.6(1P8)
57N3716: C1544.1(CAP2) U4.24(3P3_1) U4.25(3P3_2)
57N3731: C1533.2(CAP1) U4.30(DCRP) Z104.1(NET1)
57N3732: C1533.1(CAP2) U4.31(DCRN) Z103.1(NET1)
57N5412: R1107.1 Z104.2(NET2)
60N3562: C1731.1(CAP2) J63.1(P1) R172.1 U167.12(OUT1) U167.13(OUT2) U167.14(OUT3) U167.15(OUT4)
60N3589: U167.1(NC1)
60N3590: U167.16(NC3)
60N3594: U167.9(NC2)
60N3616: C1754.1(CAP2) U167.8(SS)
60N3732: R1289.1 R1290.2 U167.11(SET)
60N3794: U5.1(NC1)
60N3795: U5.16(NC3)
60N3797: U5.9(NC2)
60N3801: C183.1(CAP2) U5.8(SS)
60N3813: R138.1 R160.2 U5.11(SET)
60N4071: C132.1(CAP2) J20.1(P1) R173.1 U5.12(OUT1) U5.13(OUT2) U5.14(OUT3) U5.15(OUT4)
61N5741: R1165.1 U156.14(LXSNS)
61N5742: R1164.2 U156.13(INSNS)
61N5743: C1537.2(CAP1) U156.30(DCRP) Z118.1(NET1)
61N5744: R1169.1 U156.4(ADDR1)
61N5745: C1530.1(CAP2) R1139.2
61N5746: R1109.1 U156.2(ADDR0)
61N5747: R1170.1 U156.3(SET)
61N5752: C1404.1(CAP2) U156.18(GDRV)
61N5753: C1526.1(CAP2) U156.17(BST)
61N5754: R1147.1 U156.15(DH)
61N5755: L85.2 U156.21(LBI)
61N5756: L85.1 U156.23(LBO)
61N5757: C1411.1(CAP2) U156.6(1P8)
61N5758: C1546.1(CAP2) U156.24(3P3_1) U156.25(3P3_2)
61N5761: R1130.1 U156.1(SYNC)
61N5762: C1445.1(CAP2) R1116.2 U156.22(PWR)
61N5776: C1537.1(CAP2) U156.31(DCRN) Z117.1(NET1)
61N7077: C194.1(CAP2) L75.2 R153.2 R1157.1 Z117.2(NET2)
61N7290: R1135.1 Z118.2(NET2)
62N1445: R162.1 R166.2 U10.7(FB)
62N1446: C190.1(CAP2) U10.6(SS)
62N1458: Q24.3(DRAIN) R165.1
62N1459: DS4.1 R165.2
62N1460: Q24.1(GATE) R164.2
63N1124: Q6.3(DRAIN) R468.1
63N1127: DS27.1 R468.2
63N3433: C872.1(CAP2) U124.C2(SS_REFIN)
63N3436: C878.1(CAP2) R813.2
63N3439: R813.1 U124.B1(COMP)
63N3442: C879.2(CAP1) R805.1 R814.2 U124.C1(FB)
63N4281: Q36.3(DRAIN) R830.1
63N4282: DS46.1 R830.2
63N4453: U124.B2(SKIP)
63N4705: C1356.1(CAP2) U151.C2(SS_REFIN)
63N4706: C1358.1(CAP2) R1097.2
63N4708: R1097.1 U151.B1(COMP)
63N4710: C1359.2(CAP1) R1090.1 R1096.2 U151.C1(FB)
63N4720: U151.B2(SKIP)
63N5111: Q5.3(DRAIN) R467.1
63N5112: DS28.1 R467.2
63N5113: Q5.1(GATE) R334.2
63N5131: R821.1 R832.2 U125.7(FB)
63N5132: C862.1(CAP2) U125.6(SS)
64N648: DS36.2 R492.2
64N649: DS36.1 Q17.3(DRAIN)
64N651: U24.5(VOSNS) Z43.2(NET2)
64N2771: DS47.2 R945.2
64N2772: DS47.1 Q37.3(DRAIN)
64N2774: U134.5(VOSNS) Z86.2(NET2)
65N130: R479.1 R480.1 U71.4(Y)
65N131: DS3.1(GRN_ANODE) R479.2
65N132: DS3.4(RED_CATHODE) R480.2
65N137: DS25.1 R484.1
65N138: DS17.1 R483.1
65N139: DS15.1 R482.1
65N140: DS16.1 R481.1
65N144: DS25.2 U51.15(B7)
65N145: DS16.2 U51.18(B4)
65N146: DS15.2 U51.17(B5)
65N147: DS17.2 U51.16(B6)
65N152: DS19.1 R486.1
65N154: DS24.1 R487.1
65N158: DS21.1 R488.1
65N160: R323.2 U51.2(DIR)
65N163: DS21.2 U51.21(B1)
65N166: DS24.2 U51.20(B2)
65N167: DS19.2 U51.19(B3)
65N1694: DS14.1 R478.1
65N1695: DS14.2 U51.14(B8)
65N4344: R424.1 U51.22(OE_B)
65N4702: DS49.2 R1183.2
65N4703: DS49.1 Q58.3(DRAIN)
65N4960: DS5.2 R127.2
65N4961: DS5.1 Q26.3(DRAIN)
67N1169: J2.J24(HB01_P)
67N1172: J2.J25(HB01_N)
67N1175: J2.J27(HB07_P)
67N1178: J2.J28(HB07_N)
67N1181: J2.J30(HB11_P)
67N1184: J2.J31(HB11_N)
67N1187: J2.J33(HB15_P)
67N1189: J2.J34(HB15_N)
67N1193: J2.J36(HB18_P)
67N1195: J2.J37(HB18_N)
67N1199: J2.J39(VIO_B_M2C_1)
67N1202: J2.K25(HB00_P_CC)
67N1205: J2.K26(HB00_N_CC)
67N1208: J2.K28(HB06_P_CC)
67N1211: J2.K29(HB06_N_CC)
67N1214: J2.K31(HB10_P)
67N1217: J2.K32(HB10_N)
67N1220: J2.K34(HB14_P)
67N1223: J2.K35(HB14_N)
67N1226: J2.K37(HB17_P_CC)
67N1229: J2.K38(HB17_N_CC)
67N1232: J2.K40(VIO_B_M2C_2)
67N1235: J2.K1(VREF_B_M2C)
67N1238: J2.K4(CLK2_BIDIR_P)
67N1241: J2.K5(CLK2_BIDIR_N)
67N1244: J2.J2(CLK3_BIDIR_P)
67N1247: J2.J3(CLK3_BIDIR_N)
67N1644: J2.K19(HA21_P)
67N1646: J2.K20(HA21_N)
67N1648: J2.K22(HA23_P)
67N1650: J2.K23(HA23_N)
67N1656: J2.K13(HA10_P)
67N1658: J2.K14(HA10_N)
67N1660: J2.K16(HA17_P_CC)
67N1662: J2.K17(HA17_N_CC)
67N1668: J2.K7(HA02_P)
67N1670: J2.K8(HA02_N)
67N1672: J2.K10(HA06_P)
67N1674: J2.K11(HA06_N)
67N1680: J2.J18(HA18_P)
67N1682: J2.J19(HA18_N)
67N1684: J2.J21(HA22_P)
67N1686: J2.J22(HA22_N)
67N1692: J2.J12(HA11_P)
67N1694: J2.J13(HA11_N)
67N1696: J2.J15(HA14_P)
67N1698: J2.J16(HA14_N)
67N1704: J2.J6(HA03_P)
67N1706: J2.J7(HA03_N)
67N1708: J2.J9(HA07_P)
67N1710: J2.J10(HA07_N)
68N293: C1108.1(CAP2) J2.ST2(GND_ST2) R892.1
68N294: C1109.1(CAP2) J2.ST1(GND_ST1) R891.1
70N4739: C1163.2(CAP1) R897.2 R898.2
70N5660: U139.T7(NC)
71N1040: R1148.1 U141.E7(MF)
72N3763: C1759.2(CAP1) R951.2 R1292.2
72N4110: R216.1 U142.E7(MF)
74N668: DS48.2 R1013.2
74N670: DS48.1 Q41.3(DRAIN)
77N2783: R1075.2 U150.13(INSNS)
77N2784: C1317.1(CAP2) R1021.2 U150.22(PWR)
77N2785: C1328.2(CAP1) U150.30(DCRP) Z90.1(NET1)
77N2786: R1077.1 U150.4(ADDR1)
77N2787: C1327.1(CAP2) R1029.2
77N2788: R1028.1 R1070.2 U150.1(SYNC)
77N2789: R1174.1 U150.2(ADDR0)
77N2790: R1078.1 U150.3(SET)
77N2796: C1311.1(CAP2) U150.18(GDRV)
77N2797: R1076.1 U150.14(LXSNS)
77N2798: C1325.1(CAP2) U150.17(BST)
77N2799: R1022.1 U150.15(DH)
77N2800: L67.2 U150.21(LBI)
77N2801: L67.1 U150.23(LBO)
77N2802: C1313.1(CAP2) U150.6(1P8)
77N2803: C1336.1(CAP2) U150.24(3P3_1) U150.25(3P3_2)
77N2808: R1020.2 R1052.1 U150.12(EN)
77N4651: C1428.1(CAP2) L66.2 R152.1 R1074.1 Z89.2(NET2)
77N4678: C1328.1(CAP2) U150.31(DCRN) Z89.1(NET1)
77N6252: R1079.1 Z90.2(NET2)
78N6513: R724.2 U111.K6(PROGRAM_B_0_K6)
78N6517: U111.F11(VCCO_35_F11) U111.H15(VCCO_35_H15)
78N6524: U111.F12(IO_L1P_T0_AD0P_35_F12)
78N6525: U111.E11(IO_L2P_T0_AD8P_35_E11)
78N6526: U111.E13(IO_L1N_T0_AD0N_35_E13)
78N6527: U111.E12(IO_L2N_T0_AD8N_35_E12)
78N6528: U111.F14(IO_L3N_T0_DQS_AD1N_35_F14)
78N6529: U111.F13(IO_L3P_T0_DQS_AD1P_35_F13)
78N6530: U111.G15(IO_L5P_T0_AD9P_35_G15)
78N6531: U111.F15(IO_L5N_T0_AD9N_35_F15)
78N7461: U111.P10(IO_L24P_T3_34_P10)
78N7462: U111.R7(IO_L20P_T3_34_R7)
78N7464: U111.L12(IO_L12P_T1_MRCC_34_L12)
78N7465: U111.M12(IO_L12N_T1_MRCC_34_M12)
78N7467: U111.H14(IO_L3N_T0_DQS_34_H14)
78N7468: U111.K11(IO_L11P_T1_SRCC_34_K11)
78N7469: U111.G11(IO_L1P_T0_34_G11)
78N7471: U111.J15(IO_L4P_T0_34_J15)
78N7472: U111.K15(IO_L4N_T0_34_K15)
78N7473: U111.J13(IO_L5P_T0_34_J13)
78N7475: U111.H13(IO_L2N_T0_34_H13)
78N7477: U111.L14(IO_L9P_T1_DQS_34_L14)
78N7478: U111.M14(IO_L9N_T1_DQS_34_M14)
78N7479: U111.L13(IO_L10N_T1_34_L13)
78N7480: U111.P14(IO_L18N_T2_34_P14)
78N7481: U111.N9(IO_L19N_T3_VREF_34_N9)
78N7482: U111.M15(IO_L8N_T1_34_M15)
78N7483: U111.P15(IO_L15P_T2_DQS_34_P15)
78N7501: U111.M9(IO_L19P_T3_34_M9)
78N7502: U111.N12(IO_L13N_T2_MRCC_34_N12)
78N7503: U111.N11(IO_L13P_T2_MRCC_34_N11)
78N7504: U111.R15(IO_L15N_T2_DQS_34_R15)
78N7505: U111.P13(IO_L18P_T2_34_P13)
78N7506: U111.K13(IO_L10P_T1_34_K13)
78N7507: U111.N13(IO_L7P_T1_34_N13)
78N7944: U111.L15(IO_L8P_T1_34_L15)
78N8053: U109.14(B5)
78N8055: U109.13(B6)
78N8057: U109.12(B7)
78N8059: U109.11(B8)
78N8061: U109.7(A5)
78N8063: U109.8(A6)
78N8065: U109.9(A7)
78N8067: U109.10(A8)
78N8088: R142.2 U109.19(VREFB) U109.20(EN)
78N8264: U111.J14(IO_L5N_T0_34_J14)
78N8265: U111.H11(IO_L6P_T0_34_H11)
78N8266: U111.J11(IO_L6N_T0_VREF_34_J11)
79N2940: R826.2 U111.B11(PS_SRST_B_501_B11)
79N2956: R1124.1 U111.B5(PS_MIO9_500_B5)
79N2958: R1197.2 U111.B6(PS_MIO8_500_B6)
79N2959: R1196.2 U111.D9(PS_MIO7_500_D9)
79N3567: U111.F4(PS_DDR_VREF0_502_F4)
79N3568: U111.J3(PS_DDR_VRN_502_J3)
79N3569: U111.H3(PS_DDR_VRP_502_H3)
79N3570: U111.R5(PS_DDR_CAS_B_502_R5)
79N3571: U111.R6(PS_DDR_RAS_B_502_R6)
79N3572: U111.L3(PS_DDR_CKE_502_L3)
79N3573: U111.R3(PS_DDR_WE_B_502_R3)
79N3574: U111.K3(PS_DDR_ODT_502_K3)
79N3575: U111.R2(PS_DDR_CS_B_502_R2)
79N3576: U111.M6(PS_DDR_BA0_502_M6)
79N3577: U111.N6(PS_DDR_BA2_502_N6)
79N3578: U111.R1(PS_DDR_BA1_502_R1)
79N3579: U111.N1(PS_DDR_A1_502_N1)
79N3580: U111.P1(PS_DDR_A0_502_P1)
79N3581: U111.N2(PS_DDR_CKN_502_N2)
79N3582: U111.M1(PS_DDR_A2_502_M1)
79N3583: U111.P3(PS_DDR_A4_502_P3)
79N3584: U111.P5(PS_DDR_A6_502_P5)
79N3585: U111.P4(PS_DDR_A5_502_P4)
79N3586: U111.P6(PS_DDR_A8_502_P6)
79N3587: U111.M5(PS_DDR_A7_502_M5)
79N3588: U111.J1(PS_DDR_A10_502_J1)
79N3589: U111.N4(PS_DDR_A9_502_N4)
79N3590: U111.L2(PS_DDR_A11_502_L2)
79N3591: U111.K2(PS_DDR_A13_502_K2)
79N3592: U111.M2(PS_DDR_A12_502_M2)
79N3593: U111.H2(PS_DDR_DQ15_502_H2)
79N3594: U111.K1(PS_DDR_A14_502_K1)
79N3595: U111.G1(PS_DDR_DQ13_502_G1)
79N3596: U111.H1(PS_DDR_DQ14_502_H1)
79N3597: U111.F3(PS_DDR_DQ12_502_F3)
79N3598: U111.G2(PS_DDR_DQS_P1_502_G2)
79N3599: U111.F2(PS_DDR_DQS_N1_502_F2)
79N3600: U111.E3(PS_DDR_DQ11_502_E3)
79N3601: U111.D3(PS_DDR_DM1_502_D3)
79N3602: U111.D1(PS_DDR_DQ9_502_D1)
79N3603: U111.E2(PS_DDR_DQ10_502_E2)
79N3604: U111.E1(PS_DDR_DQ8_502_E1)
79N3605: U111.C3(PS_DDR_DQ6_502_C3)
79N3606: U111.A3(PS_DDR_DQ7_502_A3)
79N3607: U111.B4(PS_DDR_DQ4_502_B4)
79N3608: U111.A4(PS_DDR_DQ5_502_A4)
79N3609: U111.C2(PS_DDR_DQS_P0_502_C2)
79N3610: U111.B2(PS_DDR_DQS_N0_502_B2)
79N3611: U111.B1(PS_DDR_DM0_502_B1)
79N3612: U111.C4(PS_DDR_DQ2_502_C4)
79N3613: U111.C1(PS_DDR_DQ3_502_C1)
79N3614: U111.D4(PS_DDR_DQ0_502_D4)
79N3615: U111.A2(PS_DDR_DQ1_502_A2)
79N3616: U111.L4(PS_DDR_DRST_B_502_L4)
79N3617: U111.M4(PS_DDR_A3_502_M4)
79N3618: U111.N3(PS_DDR_CKP_502_N3)
81N1560: U114.3(NC0)
81N1561: U114.4(NC1)
81N1562: U114.5(NC2)
81N1563: U114.6(NC3)
81N1572: U114.14(NC7)
81N1573: U114.13(NC6)
81N1574: U114.12(NC5)
81N1575: U114.11(NC4)
81N1821: DS43.2 R785.2
81N1822: DS43.1 Q34.3(DRAIN)
81N1903: DS45.2 R786.2
81N1904: DS45.1 Q35.3(DRAIN)
81N3811: DS44.2 R787.2
81N3812: DS44.1 Q3.3(DRAIN)
81N3985: DS42.1(GRN_ANODE) DS42.3(RED_ANODE) R784.2
81N3988: DS42.2(GRN_CATHODE) Q7.3(DRAIN)
81N4212: U154.11(CLK_RET)
250MHZ_CLK1_N: R24.2 R42.1 R692.1 U1.D12(IO_L13N_T2L_N1_GC_QBC_71_D12) U21.2(NQ0)
250MHZ_CLK1_P: R23.2 R25.1 R692.2 U1.E12(IO_L13P_T2L_N0_GC_QBC_71_E12) U21.1(Q0)
250MHZ_CLK2_N: R15.1 R18.2 R22.1 U1.AW27(IO_L13N_T2L_N1_GC_QBC_41_AW27) U21.4(NQ1)
250MHZ_CLK2_P: R15.2 R17.2 R20.1 U1.AW26(IO_L13P_T2L_N0_GC_QBC_41_AW26) U21.3(Q1)
5328N47: R21.1 U57.21(CS_CA)
5328N733: U57.4(C2B)
5328N736: U57.11(RATE0)
5328N739: U57.15(RATE1)
5328N742: U57.18(LOL)
5328N745: U57.2(NC1)
5328N748: U57.9(NC2)
5328N751: U57.14(NC3)
5328N754: U57.30(NC4)
5328N757: U57.33(NC5)
5328N766: U57.27(SDI)
5328N1017: U57.19(NC6)
5328N1020: U57.20(NC7)
5329N4244: U1.D24(IO_L19N_T3L_N1_DBC_AD9N_72_D24)
5329N4246: U1.G21(IO_L13N_T2L_N1_GC_QBC_72_G21)
5329N4248: U1.K23(IO_L7N_T1L_N1_QBC_AD13N_72_K23)
5329N4257: U1.J20(IO_T1U_N12_72_J20)
5329N4282: U1.T19(VREF_73_T19)
5329N4285: U1.G17(IO_L13N_T2L_N1_GC_QBC_73_G17)
5329N4288: U1.T20(VREF_72_T20)
5330N3435: U1.T25(VREF_48_T25)
5330N3438: U1.J34(VREF_46_J34)
5330N3483: U1.D36(IO_T3U_N12_46_D36)
5330N3484: U1.C38(IO_T2U_N12_46_C38)
5330N3486: U1.E36(IO_T1U_N12_46_E36)
5330N3493: U1.A25(IO_T3U_N12_48_A25)
5330N3494: U1.H25(IO_T2U_N12_48_H25)
5330N3495: U1.J25(IO_T1U_N12_48_J25)
5336N2051: J6.B8(RSVD_6)
5336N2052: J6.B9(RSVD_7)
5336N2053: J6.B10(RSVD_8)
5336N2054: J6.B11(RSVD_9)
5336N2059: J6.A8(RSVD_1)
5336N2060: J6.A9(RSVD_2)
5336N2061: J6.A10(RSVD_3)
5336N2062: J6.A11(RSVD_4)
5336N2064: J6.A12(RSVD_5)
5336N2066: J6.B12(RSVD_10)
5336N2098: C6.2(CAP1) C11.2(CAP1) J6.10(VCC_RX) L5.1
5336N2099: C5.1(CAP2) C8.1(CAP2) J6.1(VCC_TX) L4.1
5336N2585: J36.3(P3)
5337N768: R157.2 U6.13(INSNS)
5337N769: C173.1(CAP2) R14.2 U6.22(PWR)
5337N770: R159.1 U6.4(ADDR1)
5337N771: C185.1(CAP2) R139.2
5337N772: R136.1 R141.2 U6.1(SYNC)
5337N773: R137.1 U6.2(ADDR0)
5337N774: R74.1 U6.3(SET)
5337N779: C130.1(CAP2) U6.18(GDRV)
5337N780: R158.1 U6.14(LXSNS)
5337N781: C184.1(CAP2) U6.17(BST)
5337N782: R154.1 U6.15(DH)
5337N783: L8.2 U6.21(LBI)
5337N784: L8.1 U6.23(LBO)
5337N785: C145.1(CAP2) U6.6(1P8)
5337N786: C189.1(CAP2) U6.24(3P3_1) U6.25(3P3_2)
5337N797: C186.2(CAP1) U6.30(DCRP) Z3.1(NET1)
5337N798: C186.1(CAP2) U6.31(DCRN) Z2.1(NET1)
5337N2109: R80.1 Z3.2(NET2)
5339N66: J22.L33(RES3)
5339N68: J22.L32(RES2)
5339N70: J22.L1(RES1)
5340N31: C1588.1(CAP2) R1208.2 U159.12(VDD)
5340N35: C1705.1(CAP2) R1275.2 U159.16(TS_FAULTB)
5340N44: C1700.2(CAP1) U159.10(BST)
5340N432: C1591.1(CAP2) R1209.2 U160.12(VDD)
5340N433: C1706.1(CAP2) R1276.2 U160.16(TS_FAULTB)
5340N442: C1701.2(CAP1) U160.10(BST)
5340N809: C1594.1(CAP2) R1210.2 U161.12(VDD)
5340N810: C1707.1(CAP2) R1277.2 U161.16(TS_FAULTB)
5340N819: C1702.2(CAP1) U161.10(BST)
5340N1196: C1780.2(CAP1) R1317.1
5340N1198: C1779.2(CAP1) R1318.1
5340N1200: C1778.2(CAP1) R1319.1
5340N1586: C150.1(CAP2) R167.2 U11.12(VDD)
5340N1587: C232.1(CAP2) R196.2 U11.16(TS_FAULTB)
5340N1593: C231.2(CAP1) U11.10(BST)
5340N2428: C233.2(CAP1) R170.1
CLK_125MHZ_N: R150.1 R186.2 R188.1 U1.AY23(IO_L11N_T1U_N9_GC_64_AY23) U122.17(CLK1B)
CLK_125MHZ_P: R150.2 R185.2 R187.1 U1.AY24(IO_L11P_T1U_N8_GC_64_AY24) U122.18(CLK1A)
COMBINED_PGOOD: D4.2(ANODE) D5.2(ANODE) D7.1(CATHODE) D10.2(ANODE) D11.2(ANODE) D12.2(ANODE) D13.2(ANODE) D14.2(ANODE) D17.2(ANODE) D35.2(ANODE) R321.2 U71.2(A) U109.15(B4)
COMBINED_PGOOD_LS: D7.2(ANODE) J78.3(P3) R16.2 U109.6(A4) U111.R10(IO_L24N_T3_34_R10)
CPU_RESET: R52.1 SW5.3(P3) SW5.4(P4) U1.L19(IO_T1U_N12_73_L19)
DDR4_C1_A0: R238.2 U1.D14(IO_T3U_N12_71_D14) U60.P3(A0) U61.P3(A0) U62.P3(A0) U63.P3(A0) U64.P3(A0)
DDR4_C1_A1: R239.2 U1.B15(IO_L24N_T3U_N11_71_B15) U60.P7(A1) U61.P7(A1) U62.P7(A1) U63.P7(A1) U64.P7(A1)
DDR4_C1_A2: R255.2 U1.B16(IO_L24P_T3U_N10_71_B16) U60.R3(A2) U61.R3(A2) U62.R3(A2) U63.R3(A2) U64.R3(A2)
DDR4_C1_A3: R254.2 U1.C14(IO_L23N_T3U_N9_71_C14) U60.N7(A3) U61.N7(A3) U62.N7(A3) U63.N7(A3) U64.N7(A3)
DDR4_C1_A4: R252.2 U1.C15(IO_L23P_T3U_N8_71_C15) U60.N3(A4) U61.N3(A4) U62.N3(A4) U63.N3(A4) U64.N3(A4)
DDR4_C1_A5: R253.2 U1.A13(IO_L22N_T3U_N7_DBC_AD0N_71_A13) U60.P8(A5) U61.P8(A5) U62.P8(A5) U63.P8(A5) U64.P8(A5)
DDR4_C1_A6: R241.2 U1.A14(IO_L22P_T3U_N6_DBC_AD0P_71_A14) U60.P2(A6) U61.P2(A6) U62.P2(A6) U63.P2(A6) U64.P2(A6)
DDR4_C1_A7: R240.2 U1.A15(IO_L21N_T3L_N5_AD8N_71_A15) U60.R8(A7) U61.R8(A7) U62.R8(A7) U63.R8(A7) U64.R8(A7)
DDR4_C1_A8: R245.2 U1.A16(IO_L21P_T3L_N4_AD8P_71_A16) U60.R2(A8) U61.R2(A8) U62.R2(A8) U63.R2(A8) U64.R2(A8)
DDR4_C1_A9: R244.2 U1.B12(IO_L20N_T3L_N3_AD1N_71_B12) U60.R7(A9) U61.R7(A9) U62.R7(A9) U63.R7(A9) U64.R7(A9)
DDR4_C1_A10: R243.2 U1.C12(IO_L20P_T3L_N2_AD1P_71_C12) U60.M3(A10/AP) U61.M3(A10/AP) U62.M3(A10/AP) U63.M3(A10/AP) U64.M3(A10/AP)
DDR4_C1_A11: R242.2 U1.B13(IO_L19N_T3L_N1_DBC_AD9N_71_B13) U60.T2(A11) U61.T2(A11) U62.T2(A11) U63.T2(A11) U64.T2(A11)
DDR4_C1_A12: R247.2 U1.C13(IO_L19P_T3L_N0_DBC_AD9P_71_C13) U60.M7(A12/BC_B) U61.M7(A12/BC_B) U62.M7(A12/BC_B) U63.M7(A12/BC_B) U64.M7(A12/BC_B)
DDR4_C1_A13: R256.2 U1.D15(IO_T2U_N12_71_D15) U60.T8(A13) U61.T8(A13) U62.T8(A13) U63.T8(A13) U64.T8(A13)
DDR4_C1_A14_WE_B: R249.2 U1.H14(IO_L18N_T2U_N11_AD2N_71_H14) U60.L2(WE_B/A14) U61.L2(WE_B/A14) U62.L2(WE_B/A14) U63.L2(WE_B/A14) U64.L2(WE_B/A14)
DDR4_C1_A15_CAS_B: R250.2 U1.H15(IO_L18P_T2U_N10_AD2P_71_H15) U60.M8(CAS_B/A15) U61.M8(CAS_B/A15) U62.M8(CAS_B/A15) U63.M8(CAS_B/A15) U64.M8(CAS_B/A15)
DDR4_C1_A16_RAS_B: R564.2 U1.F15(IO_L17N_T2U_N9_AD10N_71_F15) U60.L8(RAS_B/A16) U61.L8(RAS_B/A16) U62.L8(RAS_B/A16) U63.L8(RAS_B/A16) U64.L8(RAS_B/A16)
DDR4_C1_ACT_B: R567.2 U1.E13(IO_L14N_T2L_N3_GC_71_E13) U60.L3(ACT_B) U61.L3(ACT_B) U62.L3(ACT_B) U63.L3(ACT_B) U64.L3(ACT_B)
DDR4_C1_ALERT_B: R258.2 U1.R17(IO_L1N_T0L_N1_DBC_73_R17) U60.P9(ALERT_B) U61.P9(ALERT_B) U62.P9(ALERT_B) U63.P9(ALERT_B) U64.P9(ALERT_B)
DDR4_C1_BA0: R237.2 U1.G15(IO_L17P_T2U_N8_AD10P_71_G15) U60.N2(BA0) U61.N2(BA0) U62.N2(BA0) U63.N2(BA0) U64.N2(BA0)
DDR4_C1_BA1: R257.2 U1.G13(IO_L15N_T2L_N5_AD11N_71_G13) U60.N8(BA1) U61.N8(BA1) U62.N8(BA1) U63.N8(BA1) U64.N8(BA1)
DDR4_C1_BG0: R246.2 U1.H13(IO_L15P_T2L_N4_AD11P_71_H13) U60.M2(BG0) U61.M2(BG0) U62.M2(BG0) U63.M2(BG0) U64.M2(BG0)
DDR4_C1_CK_C: R566.1 U1.E14(IO_L16N_T2U_N7_QBC_AD3N_71_E14) U60.K8(CK_C) U61.K8(CK_C) U62.K8(CK_C) U63.K8(CK_C) U64.K8(CK_C)
DDR4_C1_CK_T: R565.1 U1.F14(IO_L16P_T2U_N6_QBC_AD3P_71_F14) U60.K7(CK_T) U61.K7(CK_T) U62.K7(CK_T) U63.K7(CK_T) U64.K7(CK_T)
DDR4_C1_CKE: R251.2 U1.A10(IO_T1U_N12_71_A10) U60.K2(CKE) U61.K2(CKE) U62.K2(CKE) U63.K2(CKE) U64.K2(CKE)
DDR4_C1_CS_B: R1105.2 U1.F13(IO_L14P_T2L_N2_GC_71_F13) U60.L7(CS_B) U61.L7(CS_B) U62.L7(CS_B) U63.L7(CS_B) U64.L7(CS_B)
DDR4_C1_DM0: U1.G11(IO_L1P_T0L_N0_DBC_71_G11) U60.E7(DML_B/DBIL_B)
DDR4_C1_DM1: U1.R18(IO_L1P_T0L_N0_DBC_73_R18) U60.E2(DMU_B/DBIU_B)
DDR4_C1_DM2: U1.K17(IO_L7P_T1L_N0_QBC_AD13P_73_K17) U61.E7(DML_B/DBIL_B)
DDR4_C1_DM3: U1.G18(IO_L13P_T2L_N0_GC_QBC_73_G18) U61.E2(DMU_B/DBIU_B)
DDR4_C1_DM4: U1.B18(IO_L19P_T3L_N0_DBC_AD9P_73_B18) U62.E7(DML_B/DBIL_B)
DDR4_C1_DM5: U1.P20(IO_L1P_T0L_N0_DBC_72_P20) U62.E2(DMU_B/DBIU_B)
DDR4_C1_DM6: U1.L23(IO_L7P_T1L_N0_QBC_AD13P_72_L23) U63.E7(DML_B/DBIL_B)
DDR4_C1_DM7: U1.G22(IO_L13P_T2L_N0_GC_QBC_72_G22) U63.E2(DMU_B/DBIU_B)
DDR4_C1_DM8: U1.E24(IO_L19P_T3L_N0_DBC_AD9P_72_E24) U64.E7(DML_B/DBIL_B)
DDR4_C1_DM9: U1.C9(IO_L7P_T1L_N0_QBC_AD13P_71_C9) U64.E2(DMU_B/DBIU_B)
DDR4_C1_DQ0: U1.F11(IO_L2P_T0L_N2_71_F11) U60.G2(DQL0)
DDR4_C1_DQ1: U1.E11(IO_L2N_T0L_N3_71_E11) U60.F7(DQL1)
DDR4_C1_DQ2: U1.F10(IO_L3P_T0L_N4_AD15P_71_F10) U60.H3(DQL2)
DDR4_C1_DQ3: U1.F9(IO_L3N_T0L_N5_AD15N_71_F9) U60.H7(DQL3)
DDR4_C1_DQ4: U1.H12(IO_L5P_T0U_N8_AD14P_71_H12) U60.H2(DQL4)
DDR4_C1_DQ5: U1.G12(IO_L5N_T0U_N9_AD14N_71_G12) U60.H8(DQL5)
DDR4_C1_DQ6: U1.E9(IO_L6P_T0U_N10_AD6P_71_E9) U60.J3(DQL6)
DDR4_C1_DQ7: U1.D9(IO_L6N_T0U_N11_AD6N_71_D9) U60.J7(DQL7)
DDR4_C1_DQ8: U1.R19(IO_L2P_T0L_N2_73_R19) U60.A3(DQU0)
DDR4_C1_DQ9: U1.P19(IO_L2N_T0L_N3_73_P19) U60.B8(DQU1)
DDR4_C1_DQ10: U1.M18(IO_L3P_T0L_N4_AD15P_73_M18) U60.C3(DQU2)
DDR4_C1_DQ11: U1.M17(IO_L3N_T0L_N5_AD15N_73_M17) U60.C7(DQU3)
DDR4_C1_DQ12: U1.N19(IO_L5P_T0U_N8_AD14P_73_N19) U60.C2(DQU4)
DDR4_C1_DQ13: U1.N18(IO_L5N_T0U_N9_AD14N_73_N18) U60.C8(DQU5)
DDR4_C1_DQ14: U1.N17(IO_L6P_T0U_N10_AD6P_73_N17) U60.D3(DQU6)
DDR4_C1_DQ15: U1.M16(IO_L6N_T0U_N11_AD6N_73_M16) U60.D7(DQU7)
DDR4_C1_DQ16: U1.L16(IO_L8P_T1L_N2_AD5P_73_L16) U61.G2(DQL0)
DDR4_C1_DQ17: U1.K16(IO_L8N_T1L_N3_AD5N_73_K16) U61.F7(DQL1)
DDR4_C1_DQ18: U1.L18(IO_L9P_T1L_N4_AD12P_73_L18) U61.H3(DQL2)
DDR4_C1_DQ19: U1.K18(IO_L9N_T1L_N5_AD12N_73_K18) U61.H7(DQL3)
DDR4_C1_DQ20: U1.J17(IO_L11P_T1U_N8_GC_73_J17) U61.H2(DQL4)
DDR4_C1_DQ21: U1.H17(IO_L11N_T1U_N9_GC_73_H17) U61.H8(DQL5)
DDR4_C1_DQ22: U1.H19(IO_L12P_T1U_N10_GC_73_H19) U61.J3(DQL6)
DDR4_C1_DQ23: U1.H18(IO_L12N_T1U_N11_GC_73_H18) U61.J7(DQL7)
DDR4_C1_DQ24: U1.F19(IO_L14P_T2L_N2_GC_73_F19) U61.A3(DQU0)
DDR4_C1_DQ25: U1.F18(IO_L14N_T2L_N3_GC_73_F18) U61.B8(DQU1)
DDR4_C1_DQ26: U1.E19(IO_L15P_T2L_N4_AD11P_73_E19) U61.C3(DQU2)
DDR4_C1_DQ27: U1.E18(IO_L15N_T2L_N5_AD11N_73_E18) U61.C7(DQU3)
DDR4_C1_DQ28: U1.G20(IO_L17P_T2U_N8_AD10P_73_G20) U61.C2(DQU4)
DDR4_C1_DQ29: U1.F20(IO_L17N_T2U_N9_AD10N_73_F20) U61.C8(DQU5)
DDR4_C1_DQ30: U1.E17(IO_L18P_T2U_N10_AD2P_73_E17) U61.D3(DQU6)
DDR4_C1_DQ31: U1.D16(IO_L18N_T2U_N11_AD2N_73_D16) U61.D7(DQU7)
DDR4_C1_DQ32: U1.D17(IO_L20P_T3L_N2_AD1P_73_D17) U62.G2(DQL0)
DDR4_C1_DQ33: U1.C17(IO_L20N_T3L_N3_AD1N_73_C17) U62.F7(DQL1)
DDR4_C1_DQ34: U1.C19(IO_L21P_T3L_N4_AD8P_73_C19) U62.H3(DQL2)
DDR4_C1_DQ35: U1.C18(IO_L21N_T3L_N5_AD8N_73_C18) U62.H7(DQL3)
DDR4_C1_DQ36: U1.D20(IO_L23P_T3U_N8_73_D20) U62.H2(DQL4)
DDR4_C1_DQ37: U1.D19(IO_L23N_T3U_N9_73_D19) U62.H8(DQL5)
DDR4_C1_DQ38: U1.C20(IO_L24P_T3U_N10_73_C20) U62.J3(DQL6)
DDR4_C1_DQ39: U1.B20(IO_L24N_T3U_N11_73_B20) U62.J7(DQL7)
DDR4_C1_DQ40: U1.N23(IO_L2P_T0L_N2_72_N23) U62.A3(DQU0)
DDR4_C1_DQ41: U1.M23(IO_L2N_T0L_N3_72_M23) U62.B8(DQU1)
DDR4_C1_DQ42: U1.R21(IO_L3P_T0L_N4_AD15P_72_R21) U62.C3(DQU2)
DDR4_C1_DQ43: U1.P21(IO_L3N_T0L_N5_AD15N_72_P21) U62.C7(DQU3)
DDR4_C1_DQ44: U1.R22(IO_L5P_T0U_N8_AD14P_72_R22) U62.C2(DQU4)
DDR4_C1_DQ45: U1.P22(IO_L5N_T0U_N9_AD14N_72_P22) U62.C8(DQU5)
DDR4_C1_DQ46: U1.T23(IO_L6P_T0U_N10_AD6P_72_T23) U62.D3(DQU6)
DDR4_C1_DQ47: U1.R23(IO_L6N_T0U_N11_AD6N_72_R23) U62.D7(DQU7)
DDR4_C1_DQ48: U1.K24(IO_L8P_T1L_N2_AD5P_72_K24) U63.G2(DQL0)
DDR4_C1_DQ49: U1.J24(IO_L8N_T1L_N3_AD5N_72_J24) U63.F7(DQL1)
DDR4_C1_DQ50: U1.M21(IO_L9P_T1L_N4_AD12P_72_M21) U63.H3(DQL2)
DDR4_C1_DQ51: U1.L21(IO_L9N_T1L_N5_AD12N_72_L21) U63.H7(DQL3)
DDR4_C1_DQ52: U1.K21(IO_L11P_T1U_N8_GC_72_K21) U63.H2(DQL4)
DDR4_C1_DQ53: U1.J21(IO_L11N_T1U_N9_GC_72_J21) U63.H8(DQL5)
DDR4_C1_DQ54: U1.K22(IO_L12P_T1U_N10_GC_72_K22) U63.J3(DQL6)
DDR4_C1_DQ55: U1.J22(IO_L12N_T1U_N11_GC_72_J22) U63.J7(DQL7)
DDR4_C1_DQ56: U1.H23(IO_L14P_T2L_N2_GC_72_H23) U63.A3(DQU0)
DDR4_C1_DQ57: U1.H22(IO_L14N_T2L_N3_GC_72_H22) U63.B8(DQU1)
DDR4_C1_DQ58: U1.E23(IO_L15P_T2L_N4_AD11P_72_E23) U63.C3(DQU2)
DDR4_C1_DQ59: U1.E22(IO_L15N_T2L_N5_AD11N_72_E22) U63.C7(DQU3)
DDR4_C1_DQ60: U1.F21(IO_L17P_T2U_N8_AD10P_72_F21) U63.C2(DQU4)
DDR4_C1_DQ61: U1.E21(IO_L17N_T2U_N9_AD10N_72_E21) U63.C8(DQU5)
DDR4_C1_DQ62: U1.F24(IO_L18P_T2U_N10_AD2P_72_F24) U63.D3(DQU6)
DDR4_C1_DQ63: U1.F23(IO_L18N_T2U_N11_AD2N_72_F23) U63.D7(DQU7)
DDR4_C1_DQ64: U1.A24(IO_L20P_T3L_N2_AD1P_72_A24) U64.G2(DQL0)
DDR4_C1_DQ65: U1.A23(IO_L20N_T3L_N3_AD1N_72_A23) U64.F7(DQL1)
DDR4_C1_DQ66: U1.C24(IO_L21P_T3L_N4_AD8P_72_C24) U64.H3(DQL2)
DDR4_C1_DQ67: U1.C23(IO_L21N_T3L_N5_AD8N_72_C23) U64.H7(DQL3)
DDR4_C1_DQ68: U1.B23(IO_L23P_T3U_N8_72_B23) U64.H2(DQL4)
DDR4_C1_DQ69: U1.B22(IO_L23N_T3U_N9_72_B22) U64.H8(DQL5)
DDR4_C1_DQ70: U1.B21(IO_L24P_T3U_N10_72_B21) U64.J3(DQL6)
DDR4_C1_DQ71: U1.A21(IO_L24N_T3U_N11_72_A21) U64.J7(DQL7)
DDR4_C1_DQ72: U1.D7(IO_L8P_T1L_N2_AD5P_71_D7) U64.A3(DQU0)
DDR4_C1_DQ73: U1.C7(IO_L8N_T1L_N3_AD5N_71_C7) U64.B8(DQU1)
DDR4_C1_DQ74: U1.B8(IO_L9P_T1L_N4_AD12P_71_B8) U64.C3(DQU2)
DDR4_C1_DQ75: U1.B7(IO_L9N_T1L_N5_AD12N_71_B7) U64.C7(DQU3)
DDR4_C1_DQ76: U1.C10(IO_L11P_T1U_N8_GC_71_C10) U64.C2(DQU4)
DDR4_C1_DQ77: U1.B10(IO_L11N_T1U_N9_GC_71_B10) U64.C8(DQU5)
DDR4_C1_DQ78: U1.B11(IO_L12P_T1U_N10_GC_71_B11) U64.D3(DQU6)
DDR4_C1_DQ79: U1.A11(IO_L12N_T1U_N11_GC_71_A11) U64.D7(DQU7)
DDR4_C1_DQS0_C: U1.D10(IO_L4N_T0U_N7_DBC_AD7N_71_D10) U60.F3(DQSL_C)
DDR4_C1_DQS0_T: U1.D11(IO_L4P_T0U_N6_DBC_AD7P_71_D11) U60.G3(DQSL_T)
DDR4_C1_DQS1_C: U1.P16(IO_L4N_T0U_N7_DBC_AD7N_73_P16) U60.A7(DQSU_C)
DDR4_C1_DQS1_T: U1.P17(IO_L4P_T0U_N6_DBC_AD7P_73_P17) U60.B7(DQSU_T)
DDR4_C1_DQS2_C: U1.J19(IO_L10N_T1U_N7_QBC_AD4N_73_J19) U61.F3(DQSL_C)
DDR4_C1_DQS2_T: U1.K19(IO_L10P_T1U_N6_QBC_AD4P_73_K19) U61.G3(DQSL_T)
DDR4_C1_DQS3_C: U1.E16(IO_L16N_T2U_N7_QBC_AD3N_73_E16) U61.A7(DQSU_C)
DDR4_C1_DQS3_T: U1.F16(IO_L16P_T2U_N6_QBC_AD3P_73_F16) U61.B7(DQSU_T)
DDR4_C1_DQS4_C: U1.A18(IO_L22N_T3U_N7_DBC_AD0N_73_A18) U62.F3(DQSL_C)
DDR4_C1_DQS4_T: U1.A19(IO_L22P_T3U_N6_DBC_AD0P_73_A19) U62.G3(DQSL_T)
DDR4_C1_DQS5_C: U1.M22(IO_L4N_T0U_N7_DBC_AD7N_72_M22) U62.A7(DQSU_C)
DDR4_C1_DQS5_T: U1.N22(IO_L4P_T0U_N6_DBC_AD7P_72_N22) U62.B7(DQSU_T)
DDR4_C1_DQS6_C: U1.L20(IO_L10N_T1U_N7_QBC_AD4N_72_L20) U63.F3(DQSL_C)
DDR4_C1_DQS6_T: U1.M20(IO_L10P_T1U_N6_QBC_AD4P_72_M20) U63.G3(DQSL_T)
DDR4_C1_DQS7_C: U1.G23(IO_L16N_T2U_N7_QBC_AD3N_72_G23) U63.A7(DQSU_C)
DDR4_C1_DQS7_T: U1.H24(IO_L16P_T2U_N6_QBC_AD3P_72_H24) U63.B7(DQSU_T)
DDR4_C1_DQS8_C: U1.C22(IO_L22N_T3U_N7_DBC_AD0N_72_C22) U64.F3(DQSL_C)
DDR4_C1_DQS8_T: U1.D22(IO_L22P_T3U_N6_DBC_AD0P_72_D22) U64.G3(DQSL_T)
DDR4_C1_DQS9_C: U1.A8(IO_L10N_T1U_N7_QBC_AD4N_71_A8) U64.A7(DQSU_C)
DDR4_C1_DQS9_T: U1.A9(IO_L10P_T1U_N6_QBC_AD4P_71_A9) U64.B7(DQSU_T)
DDR4_C1_ODT: R569.2 U1.C8(IO_L7N_T1L_N1_QBC_AD13N_71_C8) U60.K3(ODT) U61.K3(ODT) U62.K3(ODT) U63.K3(ODT) U64.K3(ODT)
DDR4_C1_PAR: R568.2 U1.G10(IO_L1N_T0L_N1_DBC_71_G10) U60.T3(PAR) U61.T3(PAR) U62.T3(PAR) U63.T3(PAR) U64.T3(PAR)
DDR4_C1_REFIN: C451.1(CAP2) R299.2 R300.1 U24.1(REFIN)
DDR4_C1_RESET_B: R76.1 U1.N20(IO_L1N_T0L_N1_DBC_72_N20) U60.P1(RESET_B) U61.P1(RESET_B) U62.P1(RESET_B) U63.P1(RESET_B) U64.P1(RESET_B)
DDR4_C1_TEN: R259.1 U1.A20(IO_T3U_N12_73_A20) U60.N9(TEN) U61.N9(TEN) U62.N9(TEN) U63.N9(TEN) U64.N9(TEN)
DDR4_C1_VREFA: C559.1(CAP2) R558.2 R559.1 U60.M1(VREFCA)
DDR4_C1_VREFB: C696.1(CAP2) R706.2 R707.1 U61.M1(VREFCA)
DDR4_C1_VREFC: C699.1(CAP2) R708.2 R709.1 U62.M1(VREFCA)
DDR4_C1_VREFD: C954.1(CAP2) R894.2 R895.1 U63.M1(VREFCA)
DDR4_C1_VREFE: C557.1(CAP2) R556.2 R557.1 U64.M1(VREFCA)
DDR4_C1_VTERM_0V60_PGOOD: Q17.1(GATE) R389.2 U24.9(PGOOD)
DDR4_C1_VTERM_EN: R388.2 U24.7(EN)
DDR4_C1_VTERM_REFOUT: C138.1(CAP2) U24.6(REFOUT)
DDR4_C1_VTT: C104.1(CAP2) C105.1(CAP2) C106.1(CAP2) C107.1(CAP2) C108.1(CAP2) C350.1(CAP2) C351.1(CAP2) C352.1(CAP2) C516.1(CAP2) C517.1(CAP2) C518.1(CAP2) J65.1(P1) R237.1 R238.1 R239.1 R240.1 R241.1 R242.1 R243.1 R244.1 R245.1 R246.1 R247.1 R249.1 R250.1 R251.1 R252.1 R253.1 R254.1 R255.1 R256.1 R257.1 R258.1 R564.1 R567.1 R568.1 R569.1 R1105.1 U24.3(VO) Z43.1(NET1)
DDR4_C1_ZQA: R386.1 U60.F9(ZQ)
DDR4_C1_ZQB: R704.1 U61.F9(ZQ)
DDR4_C1_ZQC: R705.1 U62.F9(ZQ)
DDR4_C1_ZQD: R893.1 U63.F9(ZQ)
DDR4_C1_ZQE: R385.1 U64.F9(ZQ)
DDR4_C2_A0: R903.2 U1.AM27(IO_L24N_T3U_N11_41_AM27) U135.P3(A0) U136.P3(A0) U137.P3(A0) U138.P3(A0) U139.P3(A0)
DDR4_C2_A1: R904.2 U1.AL27(IO_L24P_T3U_N10_41_AL27) U135.P7(A1) U136.P7(A1) U137.P7(A1) U138.P7(A1) U139.P7(A1)
DDR4_C2_A2: R919.2 U1.AP26(IO_L23N_T3U_N9_41_AP26) U135.R3(A2) U136.R3(A2) U137.R3(A2) U138.R3(A2) U139.R3(A2)
DDR4_C2_A3: R918.2 U1.AP25(IO_L23P_T3U_N8_41_AP25) U135.N7(A3) U136.N7(A3) U137.N7(A3) U138.N7(A3) U139.N7(A3)
DDR4_C2_A4: R916.2 U1.AN28(IO_L22N_T3U_N7_DBC_AD0N_41_AN28) U135.N3(A4) U136.N3(A4) U137.N3(A4) U138.N3(A4) U139.N3(A4)
