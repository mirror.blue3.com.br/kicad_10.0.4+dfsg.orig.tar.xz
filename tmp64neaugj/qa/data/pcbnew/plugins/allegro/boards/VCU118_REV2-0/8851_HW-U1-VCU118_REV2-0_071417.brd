# Allegro board 8851_HW-U1-VCU118_REV2-0_071417.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_C1_CK_T: length 153.4
  TOP w0.145: v4(73.96,96.23) 73.82,96.09 73.82,95.12 74.12,94.82 74.37,94.82 74.39,94.84 ; U1.F14 100.74,56.34 v2(100.24,55.84)
  TOP w0.188: 74.39,94.84 75.1,94.84 75.28,95.03 75.28,95.4 75.47,95.58 75.85,95.58 76.03,95.4 76.03,95.03 76.22,94.84 76.6,94.84 76.79,95.03 76.79,95.4 76.97,95.58 77.35,95.58 77.54,95.4 77.54,95.03 77.72,94.84 81.63,94.84 81.95,94.52 82.26,94.52 R565.1
  20_SIG7 w0.102: 73.94,48.69 73.89,48.63 73.89,47.45 73.62,47.18 72.37,47.18 72.23,47.04 72.23,46.79 72.43,46.59 73.62,46.59 73.89,46.32 73.89,45.86 73.62,45.59 73.52,45.59 73.35,45.43 73.35,45.16 73.51,45.01 73.62,45.01 73.89,44.74 73.89,42.98 ; 74.06,62.79 74.06,62.76 74.05,62.75 74.05,60.58 74.17,60.45 75.41,60.45 75.7,60.17 75.7,59.65 75.34,59.29 74.14,59.29 74.02,59.16 74.02,57.11 74.03,57.1 74.03,57.07 ; 74.11,85.27 74.11,85.29 74.1,85.3 74.1,87.87 74.24,88 74.56,88 74.83,88.27 74.83,88.73 74.56,89 74.24,89 74.1,89.14 74.1,89.99 73.92,90.17 73.92,90.94 73.96,90.98 73.96,90.98 ; 73.92,71.17 73.92,75.17 74.02,75.28 74.24,75.28 74.48,75.51 74.48,76.01 74.24,76.24 74.02,76.24 73.94,76.32 73.94,76.81 73.97,76.85 73.97,76.89
  20_SIG7 w0.107: 94.39,58.49 94.41,58.49 94.46,58.44 99.49,58.44 99.84,58.1 99.84,55.95 99.95,55.84 v2(100.24,55.84) ; 74,48.79 74,48.75 73.94,48.69
  20_SIG7 w0.108: 74,48.79 74,53.64 73.96,53.68 v4(73.96,53.94) 74.09,53.94 74.34,54.18 74.34,56.59 74.03,56.9 74.03,57.07 ; 73.92,71.17 73.92,71.11 74.34,70.69 74.34,68.32 74.05,68.04 v4(73.96,68.04) 73.96,67.68 74.04,67.6 74.04,66.53 74.33,66.24 74.33,65.91 74.06,65.63 74.06,62.79 ; 73.89,42.98 73.89,42.91 74.34,42.46 74.34,40.09 74.09,39.84 v4(73.96,39.84) 73.81,39.7 73.81,39.21 73.91,39.1 81.27,39.1 81.96,39.8 81.96,39.84 81.98,39.86 ; 73.97,76.89 73.97,76.92 v4(73.96,82.13) 74.23,82.13 74.34,82.24 74.34,84.84 74.11,85.07 74.11,85.27 ; 73.96,90.98 v4(73.96,96.23)
  20_SIG7 w0.14: 81.98,39.86 82.86,40.73 82.86,43.9 82.32,44.44 74.96,44.44 74.64,44.75 74.64,46.83 74.99,47.18 82.95,47.18 83.47,47.69 83.47,62.27 84,62.81 85.76,62.81 86.45,62.12 93.32,62.12 93.7,61.74 93.7,58.9 94.11,58.49 94.39,58.49
  BOTTOM w0.145: v4(73.96,53.94) U64.K7 ; v4(73.96,39.84) U60.K7 ; U62.K7 v4(73.96,96.23) ; v4(73.96,68.04) U61.K7 ; v4(73.96,82.13) U63.K7
DDR4_C1_CKE: length 143.5
  TOP w0.152: U1.A10 v2(95.24,51.84)
  TOP w0.279: v1(66.29,98.5) 66.14,98.65 66.14,101.29 R251.2
  14_SIG4 w0.089: 67.56,91.01 67.94,90.63 72.11,90.63 72.76,91.28 72.76,91.83 v4(73.16,92.23)
  14_SIG4 w0.157: v1(66.29,98.5) 67.23,97.56 67.23,91.34 67.56,91.01
  18_SIG6 w0.089: v2(95.24,51.84) 94.39,50.99 ; v4(73.16,92.23) 73.78,91.61 73.78,86.67 72.76,85.64 72.76,79.57 72.99,79.33 73.32,79.33 73.56,79.1 73.56,78.53 v4(73.16,78.13) 73.56,77.73 73.56,76.37 73.13,75.95 73.13,71 72.76,70.62 72.76,65.47 72.99,65.23 73.32,65.23 73.56,65 73.56,64.43 v4(73.16,64.04) 73.36,64.04 73.87,63.53 73.87,62.69 75.1,61.46 75.1,57.93 74.56,57.39 73.31,57.39 72.76,56.84 72.76,51.37 72.99,51.14 73.32,51.14 73.56,50.9 73.56,50.34 v4(73.16,49.94) 73.56,49.54 73.56,48.4 73.84,48.11 74.49,48.11 75.74,46.87 75.74,44.86 74.5,43.62 73.83,43.62 72.76,42.55 72.76,36.24 v4(73.16,35.84) 73.56,35.44 73.56,35.04 74,34.59
  18_SIG6 w0.157: 94.39,50.99 91.47,48.07 91.47,47.66 92.63,46.5 92.63,46.09 92.22,45.67 91.8,45.67 89.39,48.09 88.77,48.09 88.46,47.78 88.46,47.36 92.15,43.68 92.15,43.26 91.74,42.85 91.32,42.85 88.99,45.18 88.58,45.18 88.16,44.77 88.16,44.36 91.18,41.35 91.18,41.01 90.76,40.6 90.27,40.6 87.34,43.53 86.92,43.53 84.84,41.45 84.84,36.41 82.55,34.12 74.48,34.12 74,34.59
  BOTTOM w0.152: v4(73.16,78.13) U63.K2 ; v4(73.16,49.94) U64.K2 ; v4(73.16,64.04) U61.K2 ; U60.K2 v4(73.16,35.84) ; v4(73.16,92.23) U62.K2
DDR4_C1_CS_B: length 138
  TOP w0.152: U1.F13 100.74,55.34 v2(100.24,54.84)
  TOP w0.279: R1105.2 70.23,100.43 v1(70.16,100.36)
  07_SIG3 w0.173: v4(73.16,39.84) U60.L7 72.76,43.65 72.94,43.84 72.94,45.66 72.84,45.76 72.52,45.76 72.42,45.86 72.42,46.13 72.52,46.23 72.84,46.23 72.94,46.33 72.94,46.72 72.76,46.9 72.76,53.54 v4(73.16,53.94) 73.56,54.34 73.56,56.81 74.07,57.33 75.59,57.33 76.27,58.01 76.27,61.37 75.16,62.48 74.77,62.48 74.35,62.9 74.35,66.84 v4(73.16,68.04) U61.L7 72.76,70.7 71.81,71.65 71.81,76.05 72.76,77 72.76,81.73 v4(73.16,82.13) U63.L7 72.76,85.62 73.39,86.25 73.39,87.33 72.25,88.47 72.25,89.82 72.76,90.33 72.76,95.83 v4(73.16,96.23)
  14_SIG4 w0.089: v4(73.16,96.23) 72.76,96.63 70.6,96.63 70.35,96.87 70.35,98.93 69.92,99.36
  14_SIG4 w0.157: v1(70.16,100.36) 69.92,100.12 69.92,99.36
  16_SIG5 w0.089: 81.67,39.53 81.58,39.44 81.32,39.44 81.32,39.44 80.19,39.44 79.96,39.68 79.96,42.54 79.81,42.69 75.87,42.69 75.7,42.87 75.7,48.26 75.53,48.43 75.18,48.43 75.01,48.26 75.01,48.04 74.84,47.87 74.14,47.87 73.97,47.7 73.97,47.35 74.15,47.18 74.84,47.18 75.01,47 75.01,46.66 74.84,46.48 74.14,46.48 73.97,46.31 73.97,45.97 74.15,45.79 74.84,45.79 75.01,45.62 75.01,45.28 74.84,45.1 74.14,45.1 73.97,44.93 73.97,44.59 74.15,44.41 74.84,44.41 75.01,44.24 75.01,42.87 74.84,42.69 73.7,42.69 73.56,42.55 73.56,40.24 v4(73.16,39.84) ; 94.39,56.6 94.74,56.95 94.74,57.05 95.03,57.34 97.47,57.34 97.74,57.07 97.74,56.64 98.03,56.34 98.47,56.34 98.74,56.07 98.74,55.64 99.03,55.34 99.47,55.34 99.97,54.84 v2(100.24,54.84)
  16_SIG5 w0.157: 81.67,39.53 82.44,40.3 82.44,41.25 83.05,41.85 87.34,41.85 87.45,41.96 93.74,48.25 93.74,55.95 94.39,56.6
  BOTTOM w0.152: U61.L7 v4(73.16,68.04) ; U62.L7 v4(73.16,96.23) ; U60.L7 v4(73.16,39.84) ; U64.L7 v4(73.16,53.94) ; U63.L7 v4(73.16,82.13)
DDR4_C1_DM0: length 44.8
  TOP w0.152: v2(101.24,52.84) U1.G11
  14_SIG4 w0.089: v4(77.96,39.84) 78.36,40.24 78.36,42.98 ; v2(101.24,52.84) 100.74,53.34 99.03,53.34 98.74,53.64 98.74,54.05 98.44,54.34 97.03,54.34 96.74,54.05 96.74,53.64 96.76,53.61 96.5,53.34 94.39,53.34
  14_SIG4 w0.14: 78.36,42.98 78.36,44.16 79.4,45.2 82.75,45.2 83.78,46.23 84.05,46.23 84.94,45.35 85.21,45.35 85.48,45.62 85.48,45.88 84.59,46.77 84.59,47.04 84.82,47.27 86.24,47.27 86.81,47.84 87.01,47.84 87.3,47.55 87.5,47.55 87.7,47.75 87.7,47.95 87.4,48.24 87.4,48.44 87.6,48.63 87.8,48.63 88.09,48.34 88.29,48.34 88.49,48.54 88.49,48.74 88.19,49.03 88.19,49.23 88.39,49.42 88.59,49.42 88.88,49.13 89.08,49.13 89.28,49.33 89.28,49.53 88.98,49.82 88.98,50.02 89.18,50.22 89.38,50.22 89.67,49.92 89.87,49.92 90.07,50.12 90.07,50.32 89.77,50.61 89.77,50.81 89.97,51.01 90.17,51.01 90.46,50.71 90.66,50.71 90.86,50.91 90.86,51.11 90.56,51.4 90.56,51.6 90.76,51.8 90.96,51.8 91.25,51.5 91.45,51.5 91.65,51.7 91.65,51.9 91.35,52.19 91.35,52.39 91.55,52.59 91.75,52.59 92.04,52.29 92.24,52.29 92.44,52.49 92.44,52.69 92.14,52.98 92.14,53.18 92.31,53.34 93,53.34 93.2,53.53 93.2,53.65 93.39,53.84 93.77,53.84 93.96,53.65 93.96,53.53 94.15,53.34 94.39,53.34
  BOTTOM w0.152: U60.E7 v4(77.96,39.84)
DDR4_C1_DM1: length 54.3
  TOP w0.152: U1.R18 v2(109.24,59.84)
  07_SIG3 w0.173: 82.2,38.38 82.13,38.31 82.13,38.06 82.01,37.94 81.6,37.94 81.53,38.01 81.53,38.33 81.41,38.46 81.15,38.46 81.02,38.33 81.02,38.07 80.9,37.94 80.61,37.94 80.48,38.07 80.48,38.69 80.35,38.82 79.76,38.82 79.6,38.66 79.6,38.17 79.96,37.82 79.96,37.28 79.72,37.04 78.59,37.04 78.36,36.81 78.36,36.24 v4(77.96,35.84) ; 97.27,42.17 97.42,42.32 98.5,42.32 98.74,42.56 98.74,44.05 99.03,44.34 99.44,44.34 99.74,44.64 99.74,45.05 100.03,45.34 100.44,45.34 100.74,45.64 100.74,46.05 101.03,46.34 101.44,46.34 101.74,46.64 101.74,47.05 102.03,47.34 102.44,47.34 102.74,47.64 102.74,48.05 103.03,48.34 103.44,48.34 103.74,48.64 103.74,49.05 104.03,49.34 104.44,49.34 104.74,49.64 104.74,50.05 105.03,50.34 105.44,50.34 105.74,50.64 105.74,51.05 106.03,51.34 106.44,51.34 106.74,51.64 106.74,52.05 107.03,52.34 107.44,52.34 107.74,52.64 107.74,53.05 108.03,53.34 108.44,53.34 108.74,53.64 108.74,54.05 109.03,54.34 109.44,54.34 109.74,54.64 109.74,58.98 109.24,59.48 v2(109.24,59.84)
  07_SIG3 w0.262: 82.2,38.38 82.28,38.46 82.71,38.46 82.85,38.32 82.85,38.16 82.99,38.02 83.27,38.02 83.41,38.16 83.41,38.32 83.55,38.46 83.82,38.46 83.96,38.32 83.96,38.16 84.1,38.02 84.38,38.02 84.52,38.16 84.52,38.32 84.66,38.46 85.5,38.46 85.85,38.8 93.91,38.8 97.27,42.17
  BOTTOM w0.152: U60.E2 v4(77.96,35.84)
DDR4_C1_DM2: length 51.9
  TOP w0.152: U1.K17 104.74,59.34 v2(104.24,58.84)
  03_SIG1 w0.173: v4(77.96,68.04) 77.96,67.67 78.1,67.53 78.87,67.53 79.02,67.38 79.02,67.25 79.17,67.1 79.38,67.1 79.54,67.25 79.54,67.44 79.68,67.59 79.9,67.59 80.05,67.44 80.05,67.25 80.21,67.1 80.42,67.1 80.57,67.25 80.57,67.38 80.72,67.53 81.39,67.53 81.61,67.31 ; 94.39,57.34 102.44,57.34 102.74,57.64 102.74,58.16 102.92,58.34 103.44,58.34 103.74,58.64 103.74,58.95 103.53,59.17 103.53,59.39 103.68,59.54 103.9,59.54 104.03,59.41 104.26,59.41 104.35,59.32 104.35,58.96 v2(104.24,58.84)
  03_SIG1 w0.262: 81.61,67.31 82,67.31 82.11,67.2 82.11,66.8 82.44,66.46 82.87,66.46 82.94,66.53 83.28,66.53 83.5,66.31 83.5,65.81 83.63,65.68 83.92,65.68 84.05,65.55 84.05,65.27 83.9,65.12 83.62,65.12 83.48,64.98 83.48,63.83 83.72,63.6 84.19,63.6 84.3,63.7 84.3,64.26 84.48,64.44 85.2,64.44 89.6,60.04 89.87,60.04 90.98,61.16 91.25,61.16 91.43,60.97 91.43,60.7 90.32,59.59 90.32,59.32 90.51,59.13 90.77,59.13 91.89,60.25 92.15,60.25 92.34,60.06 92.34,59.79 91.23,58.68 91.23,58.41 91.42,58.22 91.68,58.22 92.8,59.34 93.06,59.34 93.25,59.15 93.25,58.88 92.14,57.77 92.14,57.5 92.39,57.25 93.44,57.25 93.56,57.36 93.56,58.23 93.74,58.42 94.01,58.42 94.2,58.23 94.2,57.53 94.39,57.34
  BOTTOM w0.152: U61.E7 v4(77.96,68.04)
DDR4_C1_DM3: length 40.4
  TOP w0.152: v2(101.24,59.84) U1.G18
  07_SIG3 w0.173: 94.39,63.78 94.82,63.34 99.47,63.34 99.74,63.08 99.74,62.61 100,62.34 100.44,62.34 100.74,62.05 100.74,60.64 101.24,60.14 v2(101.24,59.84) ; v4(77.96,64.04) U61.E2 77.56,70.61 77.81,70.87 79.62,70.87 79.92,71.17
  07_SIG3 w0.262: 79.92,71.17 80.9,72.15 82.33,72.15 82.67,71.81 83.02,71.81 83.36,71.47 84.5,71.47 85.19,70.78 86.2,70.78 87.37,69.62 87.37,68.32 87.54,68.15 89.36,68.15 90.93,66.57 90.93,64.92 91.49,64.36 93.8,64.36 94.39,63.78
  BOTTOM w0.152: U61.E2 v4(77.96,64.04)
DDR4_C1_DM4: length 58.7
  TOP w0.152: U1.B18 v2(96.24,59.84)
  05_SIG2 w0.173: v2(96.24,59.84) 95.91,59.84 95.74,60.02 95.74,61.05 95.49,61.3 94.71,61.3 94.54,61.47 94.54,62.07 94.39,62.22 ; 81.61,95.38 81.38,95.61 78.13,95.61 77.96,95.78 v4(77.96,96.23)
  05_SIG2 w0.262: 94.39,62.22 94.35,62.26 94.1,62.26 93.92,62.09 93.73,62.09 93.52,62.3 93.52,62.6 94.33,63.41 94.33,63.63 94.09,63.87 93.89,63.87 93.03,63 92.83,63 92.63,63.2 92.63,63.4 93.5,64.26 93.5,64.46 93.3,64.66 93.1,64.66 92.24,63.79 92.04,63.79 91.85,63.99 91.85,64.2 92.7,65.04 92.7,65.24 92.5,65.43 92.31,65.43 91.72,64.85 91.5,64.85 91.34,65.02 91.34,65.25 91.91,65.83 91.91,66.13 89.4,68.64 86.24,68.64 85.95,68.93 85.95,87.79 85.69,88.05 85.18,88.05 84.25,88.98 83.86,88.98 83.52,89.32 83.52,90.92 82.75,91.7 82.75,94.24 81.61,95.38
  BOTTOM w0.152: U62.E7 v4(77.96,96.23)
DDR4_C1_DM5: length 77.2
  TOP w0.152: U1.P20 v2(108.24,61.84)
  03_SIG1 w0.173: 71.68,90.98 71.96,91.26 71.96,91.6 72.19,91.83 72.47,91.83 72.52,91.83 72.76,92.07 72.76,92.4 72.99,92.63 U62.E2 v4(77.96,92.23) ; 94.39,76.34 95.44,76.34 95.74,76.05 95.74,75.64 96.03,75.34 96.44,75.34 96.74,75.05 96.74,74.64 97.03,74.34 97.44,74.34 97.74,74.05 97.74,73.64 98.03,73.34 98.44,73.34 98.74,73.05 98.74,72.64 99.03,72.34 99.44,72.34 99.74,72.05 99.74,71.64 100.03,71.34 100.44,71.34 100.74,71.05 100.74,69.64 101.03,69.34 101.44,69.34 101.74,69.05 101.74,68.64 102.03,68.34 102.44,68.34 102.74,68.05 102.74,67.64 103.03,67.34 103.44,67.34 103.74,67.05 103.74,64.64 104.03,64.34 104.44,64.34 104.74,64.05 104.74,63.64 105.03,63.34 105.44,63.34 105.74,63.05 105.74,62.64 106.03,62.34 107.74,62.34 v2(108.24,61.84)
  03_SIG1 w0.262: 71.68,90.98 71.55,90.86 71.32,90.86 71.04,90.58 67.53,90.58 67.44,90.49 67.44,89.98 67.5,89.91 68.29,89.91 68.43,89.77 68.43,89.49 68.29,89.35 67.73,89.35 67.59,89.21 67.59,88.93 67.73,88.8 68.29,88.8 68.43,88.66 68.43,88.38 68.29,88.24 67.73,88.24 67.59,88.1 67.59,87.82 67.73,87.68 68.29,87.68 68.43,87.54 68.43,87.26 68.29,87.12 67.73,87.12 67.59,86.98 67.59,85.7 68.31,84.98 82.01,84.98 82.79,84.2 85.94,84.2 93.8,76.34 94.39,76.34
  BOTTOM w0.152: U62.E2 v4(77.96,92.23)
DDR4_C1_DM6: length 57.5
  TOP w0.152: U1.L23 v2(105.24,64.84)
  07_SIG3 w0.173: 81.61,81.66 81.44,81.49 81.44,80.97 81.33,80.86 81.09,80.86 81.01,80.94 81.01,81.55 80.9,81.66 80.72,81.66 80.62,81.56 80.62,80.95 80.5,80.83 80.33,80.83 80.23,80.93 80.23,81.54 80.12,81.65 79.95,81.65 79.85,81.55 79.85,80.94 79.75,80.83 79.59,80.83 79.48,80.95 79.48,81.56 79.37,81.66 79.2,81.66 79.1,81.56 79.1,80.95 79,80.85 78.82,80.85 78.72,80.95 78.72,81.56 78.62,81.66 78.31,81.66 77.9,81.25 77.36,81.25 77.21,81.4 77.21,81.59 77.34,81.72 77.83,81.72 77.96,81.84 v4(77.96,82.13) ; v2(105.24,64.84) 105.13,64.95 105.13,65.76 104.55,66.34 102.03,66.34 101.74,66.64 101.74,67.05 101.44,67.34 99.94,67.34 99.74,67.54 99.74,68.22 99.61,68.34 98.9,68.34 98.74,68.51 98.74,69.16 98.56,69.34 96.93,69.34 96.74,69.53 96.74,70.2 96.59,70.34 96.05,70.34 95.71,70 95.71,69.52 95.53,69.34 94.97,69.34 94.72,69.6 94.72,70.15 94.97,70.41 95.55,70.41 95.74,70.59 95.74,71.12 95.51,71.34 94.39,71.34
  07_SIG3 w0.262: 94.39,71.34 94.18,71.34 94.05,71.47 94.05,71.63 94.24,71.82 94.24,72.02 94.05,72.22 93.85,72.22 93.57,71.94 93.37,71.94 93.17,72.13 93.17,72.33 93.44,72.6 93.44,72.8 93.25,73 93.05,73 92.78,72.73 92.58,72.73 92.38,72.92 92.38,73.12 92.65,73.39 92.65,73.58 92.45,73.78 92.25,73.78 91.99,73.52 91.79,73.52 91.59,73.71 91.59,73.91 91.86,74.18 91.86,74.37 91.66,74.57 91.46,74.57 91.19,74.31 91.02,74.31 90.8,74.53 90.8,74.7 91.07,74.97 91.07,75.16 90.87,75.36 90.67,75.36 90.4,75.1 90.21,75.1 90.01,75.29 90.01,75.49 90.28,75.76 90.28,75.96 90.08,76.15 89.88,76.15 89.61,75.89 89.42,75.89 89.22,76.08 89.22,76.28 89.48,76.55 89.48,76.75 89.29,76.94 89.09,76.94 88.86,76.72 88.66,76.72 88.47,76.91 88.47,77.11 88.69,77.34 88.69,77.54 88.5,77.73 88.3,77.73 87.96,77.39 86.49,77.39 86.36,77.52 86.06,77.52 85.48,78.1 84.46,78.1 83.69,78.87 83.69,79.96 83.19,80.47 82.68,80.47 81.94,81.21 81.94,81.48 81.76,81.66 81.61,81.66
  BOTTOM w0.152: U63.E7 v4(77.96,82.13)
DDR4_C1_DM7: length 36.8
  TOP w0.152: v2(101.24,63.84) U1.G22
  03_SIG1 w0.173: v2(101.24,63.84) 101.69,63.39 101.69,62.63 101.4,62.34 98.03,62.34 97.74,62.64 97.74,63.05 97.44,63.34 97.03,63.34 96.74,63.64 96.74,64.05 96.44,64.34 95.44,64.34 95.44,64.34 95.03,64.34 94.7,64.67 94.7,64.89 94.61,64.97 94.39,65.2 ; 77.56,76.89 77.56,77.73 v4(77.96,78.13)
  03_SIG1 w0.262: 77.56,76.89 77.56,74.56 79.85,72.27 82.07,72.27 82.69,72.89 83.18,72.89 84.17,71.91 87.68,71.91 94.39,65.2
  BOTTOM w0.152: U63.E2 v4(77.96,78.13)
DDR4_C1_DM8: length 55.7
  TOP w0.152: v2(99.24,66.84) U1.E24
  16_SIG5 w0.089: 79.96,57.07 79.96,55.27 79.83,55.14 78.59,55.14 78.36,54.9 78.36,54.55 78.05,54.23 78.05,54.03 v4(77.96,53.94) ; v2(99.24,66.84) 97.74,65.34 97.74,64.64 97.44,64.34 97.03,64.34 96.74,64.05 96.74,63.64 96.44,63.34 94.85,63.34 94.39,62.87
  16_SIG5 w0.14: 79.96,57.07 79.96,57.52 80.21,57.78 81.51,57.78 81.67,57.62 81.67,55.27 81.81,55.13 82.08,55.13 82.27,55.32 82.27,57.49 82.55,57.78 83.21,57.78 83.54,57.45 83.54,56.09 83.76,55.88 84.45,55.88 84.69,55.64 84.69,55.11 84.4,54.83 83.76,54.83 83.54,54.61 83.54,54.21 83.86,53.89 84.65,53.89 84.92,53.63 84.92,48.1 85.17,47.85 86.03,47.85 86.22,48.04 86.22,52.06 86.37,52.21 89.18,52.21 89.41,52.43 89.41,57.89 94.39,62.87
  BOTTOM w0.152: U64.E7 v4(77.96,53.94)
DDR4_C1_DM9: length 37.6
  TOP w0.152: U1.C9 v2(97.24,50.84)
  05_SIG2 w0.173: v2(97.24,50.84) U1.C9 97.74,52.97 97.36,53.34 97.12,53.34 96.74,53.73 96.74,53.99 96.38,54.34 96.1,54.34 95.74,54.71 95.74,55.05 95.44,55.34 95.09,55.34 94.39,56.04 ; v4(77.96,49.94) 77.56,50.34 77.56,51.74 76.76,52.54 76.76,56.52 77.32,57.07
  05_SIG2 w0.262: 94.39,56.04 88.98,61.45 85.79,61.45 85.71,61.37 84.69,61.37 84.64,61.42 82.75,61.42 82.4,61.07 81.31,61.07 77.32,57.07
  BOTTOM w0.152: U64.E2 v4(77.96,49.94)
DDR4_C1_DQ0: length 42.5
  TOP w0.152: v2(100.24,52.84) U1.F11
  14_SIG4 w0.089: v2(100.24,52.84) 100.74,52.34 100.74,51.64 100.44,51.34 99.03,51.34 98.74,51.05 98.74,49.58 98.5,49.34 98.03,49.34 97.74,49.05 97.74,48.64 97.74,48.51 97.57,48.34 97.07,48.34 97.06,48.34 97.03,48.34 96.74,48.05 96.74,48.02 96.73,48.01 96.73,47.64 96.72,47.62 96.72,47.62 96.44,47.34 95.93,47.34 95.74,47.15 95.74,46.51 95.57,46.34 94.92,46.34 94.39,45.81 ; 81.61,35.35 81.52,35.44 76.75,35.44 v4(76.36,35.84)
  14_SIG4 w0.14: 81.61,35.35 82.05,34.92 82.29,34.92 82.87,35.5 82.87,35.69 82.67,35.89 82.67,36.09 82.97,36.38 83.17,36.38 83.36,36.19 83.56,36.19 86.54,39.17 88.68,39.17 88.85,39.34 88.85,39.61 88.07,40.39 88.07,40.66 88.34,40.93 88.61,40.93 89.39,40.15 89.66,40.15 89.93,40.42 89.93,40.69 89.15,41.47 89.15,41.74 89.42,42.01 89.69,42.01 90.47,41.23 90.74,41.23 94.13,44.61 94.13,45.54 94.39,45.81
  BOTTOM w0.152: U60.G2 v4(76.36,35.84)
DDR4_C1_DQ1: length 42.3
  TOP w0.152: v2(99.24,52.84) U1.E11
  14_SIG4 w0.089: 79.16,42.98 79.16,39.68 78.92,39.44 77.55,39.44 v4(77.16,39.84) ; 94.39,51.68 94.4,51.68 94.61,51.89 94.61,52.15 94.8,52.34 96.48,52.34 96.74,52.6 96.74,53.05 97.03,53.34 98.44,53.34 98.94,52.84 v2(99.24,52.84)
  14_SIG4 w0.14: 94.39,51.68 94.08,51.68 93.89,51.87 93.89,52.58 93.7,52.77 93.32,52.77 93.13,52.58 93.13,51.87 92.94,51.68 92.67,51.68 87.3,46.31 86.96,46.31 86.71,46.56 86.44,46.56 86.17,46.29 86.17,46.02 86.5,45.69 86.5,45.51 85.48,44.48 85.16,44.48 84.97,44.29 84.97,43.9 84.52,43.44 83.91,43.44 83.76,43.59 83.76,44.01 83.63,44.15 83.35,44.15 83.21,44 83.21,43.59 83.06,43.44 82.85,43.44 82.68,43.61 82.68,44.29 82.49,44.48 80.93,44.48 80.74,44.29 80.74,43.76 80.88,43.62 81.34,43.62 81.5,43.46 81.5,42.91 81.37,42.78 80.17,42.78 79.97,42.97 79.97,44.29 79.78,44.48 79.5,44.48 79.16,44.14 79.16,42.98
  BOTTOM w0.152: U60.F7 v4(77.16,39.84)
DDR4_C1_DQ2: length 42.9
  TOP w0.152: v2(100.24,51.84) U1.F10
  14_SIG4 w0.089: 94.39,49.34 96.44,49.34 96.74,49.64 96.74,49.66 96.74,50.05 97.03,50.34 97.44,50.34 97.74,50.64 97.74,51.05 98.03,51.34 98.44,51.34 98.74,51.64 98.74,52.05 99.03,52.34 99.74,52.34 v2(100.24,51.84) ; 81.61,38.12 81.46,37.97 78.58,37.97 78.36,37.75 78.36,37.23 78.17,37.04 76.14,37.04 75.75,37.44 v4(75.56,37.44)
  14_SIG4 w0.14: 94.39,49.34 94.36,49.34 94.22,49.2 94.22,48.82 94.08,48.68 93.66,48.68 93.52,48.82 93.52,49.2 93.38,49.34 92.8,49.34 92.36,48.91 92.36,48.64 93.05,47.95 93.05,47.68 92.78,47.41 92.52,47.41 91.82,48.1 91.56,48.1 91.29,47.83 91.29,47.56 91.98,46.87 91.98,46.6 91.71,46.33 91.44,46.33 90.75,47.03 90.48,47.03 90.21,46.76 90.21,46.49 90.9,45.8 90.9,45.53 90.63,45.26 90.36,45.26 89.67,45.95 89.45,45.95 89.11,45.61 89.11,45.22 89.5,44.82 89.5,44.21 84.33,39.04 82.53,39.04 81.61,38.12
  BOTTOM w0.152: U60.H3 v4(75.56,37.44)
DDR4_C1_DQ3: length 42.6
  TOP w0.152: v2(100.24,50.84) U1.F9
  14_SIG4 w0.089: 75.65,42.98 75.16,42.49 75.16,40.24 v4(75.56,39.84) ; 94.39,55.34 96.38,55.34 96.74,55.7 96.74,56.02 97.06,56.34 98.41,56.34 98.74,56.02 98.74,55.7 99.09,55.34 100.37,55.34 100.74,54.98 100.74,54.64 101.03,54.34 101.44,54.34 101.74,54.05 101.74,51.64 101.44,51.34 101.03,51.34 100.53,50.84 v2(100.24,50.84)
  14_SIG4 w0.14: 94.39,55.34 90.85,55.34 86.47,50.96 86.47,50.28 85.59,49.4 84.9,49.4 82.14,46.64 79.31,46.64 75.65,42.98
  BOTTOM w0.152: U60.H7 v4(75.56,39.84)
DDR4_C1_DQ4: length 43.5
  TOP w0.152: v2(102.24,53.84) U1.H12
  14_SIG4 w0.089: v4(75.56,35.84) 75.16,35.44 75.16,34.75 75.31,34.59 ; v2(102.24,53.84) 102.24,53.82 102.74,53.32 102.74,51.64 102.44,51.34 102.03,51.34 101.74,51.05 101.74,50.64 101.44,50.34 101.03,50.34 100.74,50.05 100.74,49.68 100.73,49.68 100.73,49.59 100.49,49.34 100.04,49.34 99.74,49.05 99.74,48.52 99.56,48.34 99.03,48.34 98.73,48.04 98.73,47.64 98.44,47.34 98.35,47.34 98.35,47.34 98.03,47.34 97.74,47.05 97.74,45.54 97.54,45.34 96.04,45.34 96.04,45.34 96.03,45.34 95.74,45.05 95.74,45.04 95.73,45.04 95.73,44.1 94.39,42.75
  14_SIG4 w0.14: 94.39,42.75 89.13,37.49 86.92,37.49 82.34,32.92 81.89,32.92 80.58,34.22 75.68,34.22 75.31,34.59
  BOTTOM w0.152: U60.H2 v4(75.56,35.84)
DDR4_C1_DQ5: length 44.2
  TOP w0.152: v2(101.24,53.84) U1.G12
  14_SIG4 w0.089: 76.49,42.98 76.49,42.94 75.96,42.41 75.96,41.57 75.83,41.44 v4(75.56,41.44) ; 94.39,54.56 94.62,54.56 94.84,54.34 96.46,54.34 96.74,54.62 96.74,54.63 96.74,54.64 96.74,55.05 97.03,55.34 98.44,55.34 98.74,55.05 98.74,54.64 99.03,54.34 100.71,54.34 101.21,53.84 v2(101.24,53.84)
  14_SIG4 w0.14: 76.49,42.98 76.61,43.09 76.87,43.09 77.14,42.82 77.41,42.82 77.68,43.09 77.68,43.36 77.41,43.63 77.41,43.9 79.45,45.93 82.45,45.93 84.5,47.99 85.87,47.99 86.51,48.62 86.51,48.87 87.2,49.57 87.55,49.57 87.97,49.98 87.97,50.16 87.47,50.66 87.47,50.93 87.63,51.09 87.83,51.09 88.38,50.54 88.58,50.54 88.78,50.73 88.78,50.93 88.22,51.48 88.22,51.68 88.42,51.88 88.62,51.88 89.17,51.33 89.37,51.33 89.57,51.53 89.57,51.72 89.01,52.27 89.01,52.47 89.21,52.67 89.41,52.67 89.96,52.12 90.16,52.12 90.36,52.32 90.36,52.51 89.8,53.06 89.8,53.26 90,53.46 90.2,53.46 90.75,52.91 90.95,52.91 91.15,53.11 91.15,53.3 90.59,53.86 90.59,54.05 91.1,54.56 94.39,54.56
  BOTTOM w0.152: U60.H8 v4(75.56,41.44)
DDR4_C1_DQ6: length 40.3
  TOP w0.152: v2(99.24,50.84) U1.E9
  14_SIG4 w0.089: 81.24,34.59 81.19,34.64 76.19,34.64 75.96,34.88 75.96,36 75.72,36.24 74.6,36.24 74.28,36.56 74.28,37.72 74.45,37.89 74.63,37.89 74.76,37.77 v4(74.76,37.44) ; 94.39,43.8 94.64,44.06 94.64,44.95 95.03,45.34 95.05,45.34 95.05,45.34 95.46,45.35 95.74,45.63 95.74,45.64 95.74,46.05 96.03,46.34 96.54,46.34 96.73,46.53 96.73,47.1 96.97,47.34 97.56,47.34 97.74,47.52 97.74,48.05 98.03,48.34 98.53,48.34 98.74,48.55 98.74,49.11 98.97,49.34 99.55,49.34 99.74,49.53 99.74,50.34 v2(99.24,50.84)
  14_SIG4 w0.14: 81.24,34.59 81.91,33.93 82.3,33.93 86.75,38.38 88.97,38.38 94.39,43.8
  BOTTOM w0.152: U60.J3 v4(74.76,37.44)
DDR4_C1_DQ7: length 40.6
  TOP w0.152: U1.D9 v2(98.24,50.84)
  14_SIG4 w0.089: v4(74.76,39.84) 75.16,39.44 75.16,37.28 75.4,37.04 75.72,37.04 75.96,36.8 75.96,36.48 76.19,36.24 78.12,36.24 78.35,36.48 78.35,36.8 78.59,37.04 82.3,37.04 ; v2(98.24,50.84) 98.24,50.82 97.74,50.32 97.74,49.95 97.74,49.5 97.58,49.34 97.03,49.34 96.74,49.05 96.74,49.04 96.73,49.03 96.73,48.64 96.73,48.63 96.73,48.47 96.6,48.34 94.72,48.34 94.39,48.01
  14_SIG4 w0.14: 82.3,37.04 83.41,37.04 83.77,37.4 83.77,37.59 83.5,37.86 83.5,38.06 83.8,38.35 84,38.35 84.26,38.09 84.46,38.09 90.28,43.91 90.55,43.91 91.3,43.17 91.57,43.17 91.84,43.44 91.84,43.71 91.09,44.45 91.09,44.72 91.36,44.99 91.63,44.99 92.37,44.25 92.64,44.25 92.91,44.51 92.91,44.78 92.17,45.53 92.17,45.8 94.39,48.01
  BOTTOM w0.152: U60.J7 v4(74.76,39.84)
DDR4_C1_DQ8: length 53.9
  TOP w0.152: U1.R19 v2(109.24,60.84)
  07_SIG3 w0.173: 82.3,37 82.26,37.04 81.56,37.04 v4(81.16,37.44) ; 99.45,42.27 99.74,42.55 99.74,44.05 100.03,44.34 100.44,44.34 100.74,44.64 100.74,45.05 101.03,45.34 101.44,45.34 101.74,45.64 101.74,46.05 102.03,46.34 102.44,46.34 102.74,46.64 102.74,47.05 103.03,47.34 103.44,47.34 103.74,47.64 103.74,48.05 104.03,48.34 104.44,48.34 104.74,48.64 104.74,49.05 105.03,49.34 105.44,49.34 105.74,49.64 105.74,50.05 106.03,50.34 106.44,50.34 106.74,50.64 106.74,51.05 107.03,51.34 107.44,51.34 107.74,51.64 107.74,52.05 108.03,52.34 108.44,52.34 108.74,52.64 108.74,53.05 109.03,53.34 109.44,53.34 109.74,53.64 109.74,54.05 110.03,54.34 110.44,54.34 110.74,54.64 110.74,59.02 110.37,59.39 109.97,59.39 109.75,59.61 109.75,60 109.24,60.52 v2(109.24,60.84)
  07_SIG3 w0.262: 99.45,42.27 98.77,41.58 97.68,41.58 94.24,38.14 86.43,38.14 85.19,36.9 85.19,36.58 85.05,36.44 84.77,36.44 84.63,36.58 84.63,37.2 84.47,37.35 84.2,37.35 84.07,37.23 84.07,36.25 83.93,36.11 83.65,36.11 83.51,36.25 83.51,37.2 83.36,37.35 83.08,37.35 82.95,37.23 82.95,36.25 82.81,36.11 82.53,36.11 82.41,36.23 82.41,36.89 82.3,37
  BOTTOM w0.152: U60.A3 v4(81.16,37.44)
DDR4_C1_DQ9: length 54.8
  TOP w0.152: U1.P19 v2(108.24,60.84)
  07_SIG3 w0.173: v4(80.36,41.44) 80.76,41.04 82.2,41.04 ; 94.27,41.91 94.99,42.63 95.21,42.63 95.27,42.57 95.52,42.57 95.67,42.72 95.67,42.9 95.57,42.99 95.57,43.83 96.01,44.27 96.37,44.27 96.8,44.7 96.8,45.12 96.96,45.29 97.49,45.29 97.76,45.57 97.76,48.04 98.05,48.32 99.37,48.32 99.69,48.64 99.69,49.13 99.96,49.4 100.54,49.4 100.73,49.59 100.73,50 101.04,50.32 101.42,50.32 101.79,50.68 101.79,51.12 102.05,51.38 103.45,51.38 103.73,51.66 103.73,52.07 103.99,52.32 104.44,52.32 104.72,52.6 104.72,53.06 104.98,53.31 105.33,53.31 105.71,53.7 105.71,54.03 106.02,54.33 106.55,54.33 106.78,54.56 106.78,55.12 107.01,55.35 107.48,55.35 107.74,55.6 107.74,59.05 108.03,59.34 108.44,59.34 108.74,59.64 108.74,60.34 v2(108.24,60.84)
  07_SIG3 w0.262: 94.27,41.91 94.03,41.91 93.89,42.05 93.89,42.4 93.75,42.54 93.47,42.54 93.33,42.4 93.33,41.85 93.18,41.7 92.9,41.7 92.77,41.83 92.77,42.4 92.63,42.54 92.35,42.54 92.21,42.4 92.21,41.95 92.07,41.81 91.79,41.81 91.65,41.95 91.65,42.4 91.51,42.54 91.24,42.54 91.1,42.4 91.1,42.05 90.96,41.91 90.68,41.91 90.54,42.05 90.54,42.4 90.4,42.54 90.07,42.54 89.77,42.24 89.4,42.24 89.11,42.54 88.33,42.54 88.11,42.32 87.64,42.32 86.9,43.06 86.9,43.23 86.69,43.44 86.14,43.44 85.91,43.21 85.91,42.99 86.7,42.2 86.7,42 86.55,41.84 86.32,41.84 85.54,42.62 85.32,42.62 85.12,42.42 85.12,41.63 85.31,41.44 85.31,40.81 85.06,40.55 84.69,40.55 84.21,41.04 82.2,41.04
  BOTTOM w0.152: U60.B8 v4(80.36,41.44)
DDR4_C1_DQ10: length 54.9
  TOP w0.152: U1.M18 v2(106.24,59.84)
  07_SIG3 w0.173: 94.39,48.82 94.9,49.33 95.55,49.33 95.74,49.52 95.74,50.1 95.97,50.33 96.36,50.33 96.66,50.63 96.66,51.03 96.94,51.31 97.52,51.31 97.73,51.53 97.73,52.03 98.06,52.35 99.54,52.35 99.74,52.56 99.74,53.03 100.04,53.33 100.43,53.33 100.75,53.65 100.75,54.09 101,54.34 101.46,54.34 101.71,54.6 101.71,55.08 102.01,55.37 102.52,55.37 102.74,55.59 102.74,56.11 102.99,56.36 103.51,56.36 103.74,56.58 103.74,57.05 104.03,57.34 104.44,57.34 104.74,57.64 104.74,58.05 105.03,58.34 105.44,58.34 105.74,58.64 105.74,59.1 106.24,59.6 v2(106.24,59.84) ; v4(79.56,37.44) 78.74,38.26 76.29,38.26 76.15,38.41 76.15,38.63 76.34,38.82 77.24,38.82 77.56,39.14 77.56,42.98
  07_SIG3 w0.262: 77.56,42.98 77.56,43.24 80.47,46.15 86.14,46.15 88.66,48.67 88.92,48.67 89.06,48.53 89.06,47.98 89.2,47.84 89.48,47.84 89.62,47.98 89.62,48.53 89.76,48.67 90.04,48.67 90.18,48.53 90.18,47.98 90.32,47.84 90.6,47.84 90.74,47.98 90.74,48.53 90.88,48.67 91.15,48.67 91.29,48.53 91.29,47.98 91.43,47.84 91.71,47.84 91.85,47.98 91.85,48.53 91.99,48.67 92.27,48.67 92.41,48.53 92.41,47.98 92.55,47.84 92.83,47.84 92.97,47.98 92.97,48.53 93.11,48.67 94.24,48.67 94.39,48.82
  BOTTOM w0.152: U60.C3 v4(79.56,37.44)
DDR4_C1_DQ11: length 54.7
  TOP w0.152: U1.M17 106.74,59.34 v2(106.24,58.84)
  07_SIG3 w0.173: 78.36,42.98 78.36,39.58 78.01,39.23 78.01,38.86 78.18,38.68 78.97,38.68 79.24,38.95 79.24,39.52 v4(79.56,39.84) ; 94.39,47.98 94.59,47.98 94.9,48.29 95.49,48.29 95.73,48.53 95.73,49.04 96.03,49.34 96.47,49.34 96.74,49.61 96.74,50.09 96.97,50.32 97.47,50.32 97.73,50.58 97.73,51.02 98.04,51.33 99.4,51.33 99.69,51.62 99.69,52.03 100,52.34 100.5,52.34 100.73,52.57 100.73,53.11 100.97,53.35 101.48,53.35 101.73,53.6 101.73,54.12 101.95,54.34 102.49,54.34 102.72,54.57 102.72,55.11 102.96,55.35 103.48,55.35 103.73,55.59 103.73,56.1 104,56.37 104.47,56.37 104.74,56.64 104.74,57.05 105.03,57.34 105.44,57.34 105.74,57.64 105.74,58.04 106.24,58.54 v2(106.24,58.84)
  07_SIG3 w0.262: 94.39,47.98 94.04,47.98 93.61,47.55 93.61,46.27 93.47,46.13 93.2,46.13 93.06,46.27 93.06,47.04 92.92,47.18 92.64,47.18 92.5,47.04 92.5,46.27 92.36,46.13 92.08,46.13 91.94,46.27 91.94,47.04 91.8,47.18 91.52,47.18 91.38,47.04 91.38,46.27 91.24,46.13 90.96,46.13 90.82,46.27 90.82,47.04 90.68,47.18 90.4,47.18 90.26,47.04 90.26,46.27 90.12,46.13 89.84,46.13 89.7,46.27 89.7,47.04 89.56,47.18 89.28,47.18 89.14,47.04 89.14,46.27 89,46.13 88.72,46.13 88.59,46.27 88.59,47.04 88.45,47.18 88.1,47.18 86.41,45.5 80.55,45.5 78.36,43.3 78.36,42.98
  BOTTOM w0.152: U60.C7 v4(79.56,39.84)
DDR4_C1_DQ12: length 55.1
  TOP w0.152: U1.N19 v2(107.24,60.84)
  07_SIG3 w0.173: v4(79.56,35.84) 79.96,35.44 81.61,35.44 ; v2(107.24,60.84) 107.74,61.34 109.43,61.34 109.78,61 109.78,60.63 110.05,60.36 110.42,60.36 110.78,60 110.78,59.56 111,59.33 111.47,59.33 111.74,59.07 111.74,54.69 111.39,54.34 111.09,54.34 110.74,53.99 110.74,53.64 110.44,53.34 110.03,53.34 109.74,53.05 109.74,52.64 109.44,52.34 109.03,52.34 108.74,52.05 108.74,51.64 108.44,51.34 108.03,51.34 107.74,51.05 107.74,50.64 107.44,50.34 107.03,50.34 106.74,50.05 106.74,49.64 106.44,49.34 106.03,49.34 105.74,49.05 105.74,48.64 105.44,48.34 105.06,48.34 104.74,48.02 104.74,47.66 104.42,47.34 104.11,47.34 103.74,46.97 103.74,46.66 103.42,46.34 103.05,46.34 102.74,46.03 102.74,45.72 102.36,45.34 102.13,45.34 101.74,44.95 101.74,44.75 101.33,44.34 101.12,44.34 100.78,44.01 100.78,42.46 100.49,42.17
  07_SIG3 w0.262: 100.49,42.17 98.97,40.65 97.75,40.65 94.59,37.49 87.12,37.49 85.07,35.44 81.61,35.44
  BOTTOM w0.152: U60.C2 v4(79.56,35.84)
DDR4_C1_DQ13: length 55
  TOP w0.152: U1.N18 v2(107.24,59.84)
  07_SIG3 w0.173: v4(79.56,41.44) 79.96,41.84 82.2,41.84 ; v2(107.24,59.84) 106.74,59.34 106.74,55.58 106.48,55.32 105.99,55.32 105.71,55.04 105.71,54.56 105.46,54.31 105,54.31 104.75,54.05 104.75,53.59 104.47,53.31 103.99,53.31 103.71,53.04 103.71,52.58 103.42,52.29 102.01,52.29 101.8,52.08 101.8,51.59 101.54,51.33 100.95,51.33 100.77,51.16 100.77,50.65 100.47,50.34 100.1,50.34 99.76,50 99.76,49.69 99.41,49.33 97.98,49.33 97.75,49.1 97.75,48.54 97.51,48.3 97,48.3 96.74,48.04 96.74,46.61 96.44,46.31 95.99,46.31 95.73,46.05 95.73,44.58 95.5,44.34 95.22,44.34 94.95,44.07 94.95,43.41 94.78,43.24
  07_SIG3 w0.262: 82.2,41.84 84.15,41.84 84.48,42.17 84.48,42.7 84.8,43.02 84.81,43.02 85.61,43.81 85.61,43.82 85.86,44.08 87.4,44.08 87.54,43.94 87.54,43.33 87.68,43.19 87.96,43.19 88.1,43.33 88.1,43.94 88.24,44.08 88.52,44.08 88.66,43.94 88.66,43.33 88.8,43.19 89.08,43.19 89.22,43.33 89.22,44.14 89.37,44.29 89.65,44.29 89.78,44.16 89.78,43.33 89.92,43.19 90.2,43.19 90.34,43.33 90.34,44.14 90.49,44.29 90.77,44.29 90.89,44.16 90.89,43.33 91.03,43.19 91.31,43.19 91.45,43.33 91.45,44.14 91.6,44.29 91.88,44.29 92.01,44.16 92.01,43.33 92.15,43.19 92.43,43.19 92.57,43.33 92.57,44.14 92.72,44.29 93,44.29 93.13,44.16 93.13,43.33 93.27,43.19 93.55,43.19 93.69,43.33 93.69,44.14 93.84,44.29 94.12,44.29 94.25,44.16 94.25,43.38 94.39,43.24 94.78,43.24
  BOTTOM w0.152: U60.C8 v4(79.56,41.44)
DDR4_C1_DQ14: length 55
  TOP w0.152: U1.N17 107.74,59.34 v2(107.24,58.84)
  07_SIG3 w0.173: v2(107.24,58.84) 107.24,59.13 107.74,59.63 107.74,60.05 107.44,60.34 106.03,60.34 105.74,60.05 105.74,59.64 105.44,59.34 105.03,59.34 104.74,59.05 104.74,58.64 104.44,58.34 104.03,58.34 103.74,58.05 103.74,57.64 103.44,57.34 103.03,57.34 102.74,57.05 102.74,56.57 102.51,56.34 102,56.34 101.75,56.09 101.75,55.67 101.44,55.36 101.05,55.36 100.77,55.08 100.77,54.58 100.51,54.32 99.94,54.32 99.74,54.12 99.74,53.63 99.47,53.37 98.02,53.37 97.74,53.1 97.74,52.59 97.52,52.37 97,52.37 96.75,52.11 96.75,51.57 96.49,51.32 96.03,51.32 95.75,51.03 95.75,50.55 95.53,50.34 94.98,50.34 94.39,49.75 ; v4(78.76,37.44) 78.33,37.87 74.82,37.87 74.71,37.98 74.71,39.11 74.82,39.22 76.6,39.22 76.76,39.37 76.76,42.98
  07_SIG3 w0.262: 94.39,49.75 93.98,49.34 88.36,49.34 85.87,46.85 80.41,46.85 76.76,43.2 76.76,42.98
  BOTTOM w0.152: U60.D3 v4(78.76,37.44)
DDR4_C1_DQ15: length 54.6
  TOP w0.152: U1.M16 106.74,58.34 v2(106.24,57.84)
  07_SIG3 w0.173: v2(106.24,57.84) 106.24,57.52 105.74,57.02 105.74,56.59 105.48,56.34 104.98,56.34 104.72,56.08 104.72,55.55 104.5,55.33 103.96,55.33 103.73,55.1 103.73,54.58 103.49,54.34 102.99,54.34 102.73,54.08 102.73,53.58 102.46,53.31 102.01,53.31 101.76,53.06 101.76,52.6 101.48,52.33 100.98,52.33 100.73,52.08 100.73,51.6 100.49,51.36 99.97,51.36 99.73,51.12 99.73,50.6 99.45,50.33 97.98,50.33 97.74,50.09 97.74,49.62 97.47,49.34 96.96,49.34 96.74,49.12 96.74,48.58 96.45,48.3 95.98,48.3 95.75,48.07 95.75,46.62 95.44,46.31 94.65,46.31 94.39,46.04 ; v4(78.76,39.84) 79.16,40.24 79.16,42.98
  07_SIG3 w0.262: 94.39,46.04 93.9,45.55 93.9,45.09 93.76,44.95 93.48,44.95 93.34,45.09 93.34,45.32 93.2,45.46 92.92,45.46 92.78,45.32 92.78,45.09 92.64,44.95 92.36,44.95 92.22,45.09 92.22,45.32 92.08,45.46 91.8,45.46 91.66,45.32 91.66,45.09 91.52,44.95 91.24,44.95 91.1,45.09 91.1,45.32 90.96,45.46 90.68,45.46 90.54,45.32 90.54,45.09 90.4,44.95 90.12,44.95 89.98,45.09 89.98,45.32 89.84,45.46 89.56,45.46 89.42,45.32 89.42,45.09 89.29,44.95 89.01,44.95 88.87,45.09 88.87,45.32 88.73,45.46 88.45,45.46 88.31,45.32 88.31,45.09 88.17,44.95 87.89,44.95 87.75,45.09 87.75,45.32 87.61,45.46 87.29,45.46 86.63,44.79 85.18,44.79 84.96,44.58 84.96,44.08 84.55,43.66 83.95,43.66 83.83,43.54 83.83,42.65 83.69,42.51 83.41,42.51 83.27,42.64 83.27,44.37 83.17,44.47 82.84,44.47 82.73,44.36 82.73,43.39 82.33,42.99 81.67,42.99 81.48,43.19 81.48,44.72 81.34,44.86 80.99,44.86 80.71,44.58 80.71,43.2 80.57,43.06 80.3,43.06 80.16,43.2 80.16,43.94 80.02,44.08 79.76,44.08 79.16,43.48 79.16,42.98
  BOTTOM w0.152: U60.D7 v4(78.76,39.84)
DDR4_C1_DQ16: length 49.2
  TOP w0.152: v2(105.24,57.84) 105.74,58.34 U1.L16
  03_SIG1 w0.173: v2(105.24,57.84) 104.74,57.34 104.74,56.64 104.44,56.34 104.03,56.34 103.74,56.05 103.74,55.64 103.44,55.34 103.03,55.34 102.74,55.05 102.74,54.64 102.44,54.34 94.39,54.34 ; 77.56,62.79 77.56,63.46 77.39,63.64 76.47,63.64 76.36,63.75 v4(76.36,64.04)
  03_SIG1 w0.262: 77.56,62.79 77.56,62.39 77.75,62.2 78.08,62.2 78.62,62.73 78.92,62.73 79.12,62.54 79.12,62.34 78.49,61.71 78.49,61.43 79.76,60.16 80.13,60.16 80.93,60.97 81.2,60.97 81.39,60.78 81.39,60.51 80.32,59.44 80.32,59.1 80.53,58.89 80.94,58.89 81.79,59.74 82.06,59.74 82.29,59.51 82.29,59.2 82.57,58.92 83.28,58.92 83.41,58.79 83.41,58.47 83.59,58.29 83.91,58.29 84.19,58.56 84.41,58.56 84.61,58.36 84.61,58.15 84.27,57.8 84.27,57.6 84.5,57.37 84.64,57.37 85.06,57.78 86.06,57.78 86.41,57.43 86.41,57.23 86.21,57.04 86.21,56.84 86.41,56.64 86.61,56.64 86.8,56.84 87,56.84 87.2,56.64 87.2,56.44 87,56.25 87,56.05 87.2,55.85 87.4,55.85 87.59,56.05 87.79,56.05 87.99,55.85 87.99,55.65 87.79,55.46 87.79,55.26 87.99,55.06 88.19,55.06 88.38,55.26 88.58,55.26 88.78,55.06 88.78,54.86 88.58,54.67 88.58,54.47 88.78,54.27 88.98,54.27 89.17,54.47 89.37,54.47 89.5,54.34 91.33,54.34 91.34,54.35 92.17,54.35 92.31,54.49 92.31,54.64 92.45,54.78 92.71,54.78 92.87,54.62 92.87,54.49 93.01,54.35 93.29,54.35 93.43,54.49 93.43,54.59 93.6,54.76 93.85,54.76 93.99,54.62 93.99,54.49 94.13,54.34 94.39,54.34
  BOTTOM w0.152: U61.G2 v4(76.36,64.04)
DDR4_C1_DQ17: length 49.9
  TOP w0.152: U1.K16 104.74,58.34 v2(104.24,57.84)
  03_SIG1 w0.173: v2(104.24,57.84) 104.24,57.57 103.74,57.07 103.74,56.64 103.44,56.34 103.03,56.34 102.74,56.05 102.74,55.64 102.44,55.34 94.39,55.34 ; v4(77.16,68.04) 77.34,68.04 77.51,67.86 77.51,67.59 77.38,67.46 76.58,67.46 75.85,66.72 75.4,66.72 75.31,66.63 75.31,66.39 75.52,66.17 75.88,66.17 75.96,66.09 75.96,65.47 76.19,65.24 80.59,65.24 80.76,65.06 80.76,62.97 80.57,62.79
  03_SIG1 w0.262: 94.39,55.34 94.26,55.34 94.15,55.45 91.33,55.45 90.86,54.99 89.77,54.99 85.84,58.92 84.99,58.92 84.5,59.41 83.74,59.41 83.34,59.81 83.34,60.17 83.5,60.34 84.59,60.34 84.77,60.52 84.77,61.62 84.63,61.76 83.51,61.76 83.17,61.42 82.72,61.42 82.23,60.93 82,60.93 81.39,61.53 81.39,61.73 81.6,61.93 81.6,62.22 81.37,62.45 81.13,62.45 80.73,62.05 79.86,62.05 79.62,62.28 79.62,62.58 79.82,62.78 80.56,62.78 80.57,62.79
  BOTTOM w0.152: U61.F7 v4(77.16,68.04)
DDR4_C1_DQ18: length 51.8
  TOP w0.152: U1.L18 v2(105.24,59.84)
  03_SIG1 w0.173: 94.39,53.34 102.44,53.34 102.74,53.64 102.74,54.05 103.03,54.34 103.44,54.34 103.74,54.64 103.74,55.05 104.03,55.34 104.44,55.34 104.74,55.64 104.74,56.05 105.03,56.34 105.44,56.34 105.74,56.64 105.74,59.34 v2(105.24,59.84) ; 75.96,62.79 75.96,65 75.56,65.4 v4(75.56,65.64)
  03_SIG1 w0.262: 75.96,62.79 75.96,62.3 76.14,62.11 76.34,62.11 76.58,62.36 76.78,62.36 76.98,62.16 76.98,61.96 76.73,61.72 76.73,61.52 76.93,61.32 77.13,61.32 77.37,61.57 77.57,61.57 77.77,61.37 77.77,61.17 77.47,60.88 77.47,60.69 77.67,60.49 77.88,60.49 78.09,60.7 78.25,60.7 78.44,60.51 78.44,60.27 78.31,60.14 78.31,59.94 78.51,59.74 78.71,59.74 78.95,59.99 79.15,59.99 79.35,59.79 79.35,59.59 79.1,59.35 79.1,59.15 79.97,58.29 81.92,58.29 82.44,57.77 83.16,57.77 84.34,56.59 85.5,56.59 89.1,52.99 89.36,52.99 89.5,53.13 89.5,53.53 89.64,53.67 90.05,53.67 90.19,53.53 90.19,53.13 90.33,52.99 90.61,52.99 90.75,53.13 90.75,53.53 90.89,53.67 91.17,53.67 91.31,53.53 91.31,53.13 91.45,52.99 91.73,52.99 91.87,53.13 91.87,53.53 92,53.67 92.28,53.67 92.42,53.53 92.42,53.13 92.56,52.99 92.84,52.99 92.98,53.13 92.98,53.53 93.12,53.67 93.4,53.67 93.54,53.53 93.54,53.13 93.68,52.99 93.91,52.99 94.26,53.34 94.39,53.34
  BOTTOM w0.152: U61.H3 v4(75.56,65.64)
DDR4_C1_DQ19: length 52.9
  TOP w0.152: U1.K18 v2(104.24,59.84)
  03_SIG1 w0.173: 73.2,71.17 73.56,70.82 73.56,68.67 73.79,68.44 74.12,68.44 74.36,68.2 74.36,67.87 74.59,67.64 75.16,67.64 v4(75.56,68.04) ; 94.39,64.29 94.39,61.99 95.03,61.34 101.44,61.34 101.74,61.05 101.74,60.64 102.03,60.34 103.74,60.34 v2(104.24,59.84)
  03_SIG1 w0.262: 73.2,71.17 73.13,71.25 70.78,71.25 70.63,71.39 70.63,73.44 71.26,74.07 76.99,74.07 79.45,71.6 81.68,71.6 82.66,70.62 84.77,70.62 84.93,70.78 87.9,70.78 94.39,64.29
  BOTTOM w0.152: U61.H7 v4(75.56,68.04)
DDR4_C1_DQ20: length 53.1
  TOP w0.152: v2(103.24,58.84) 103.74,59.34 U1.J17
  03_SIG1 w0.173: v4(75.56,64.04) U61.H2 75.16,66.03 75.04,66.15 74.73,66.15 74.53,66.35 74.53,66.81 74.79,67.07 75.52,67.07 75.96,67.51 75.96,68.2 75.72,68.44 75.39,68.44 75.16,68.67 75.16,69.8 75.39,70.04 81.4,70.04 81.61,69.82 ; 94.39,59.87 94.91,59.34 102.74,59.34 v2(103.24,58.84)
  03_SIG1 w0.262: 94.39,59.87 92.96,61.29 92.96,63.88 90.89,65.96 90.69,65.96 90.59,65.86 90.37,65.86 90.18,66.05 90.18,66.23 90.3,66.35 90.3,66.55 88.8,68.05 88.6,68.05 88.44,67.89 88.44,67.65 88.29,67.5 88,67.5 87.53,67.97 87.53,68.12 87.92,68.52 87.92,68.72 87.52,69.12 87.2,69.12 86.5,68.42 86.5,68.12 87.14,67.48 87.14,67.27 86.9,67.03 86.71,67.03 85.95,67.79 85.78,67.79 85.56,67.57 85.56,67.29 86.21,66.63 86.21,66.43 86.05,66.27 85.22,66.27 84.93,66.56 84.93,66.85 84.69,67.09 84.69,67.34 84.92,67.58 84.92,67.77 84.73,67.97 84.51,67.97 84.25,67.71 84.05,67.71 83.46,68.3 83.46,68.5 82.89,69.08 82.36,69.08 81.61,69.82
  BOTTOM w0.152: U61.H2 v4(75.56,64.04)
DDR4_C1_DQ21: length 52.7
  TOP w0.152: v2(102.24,58.84) 102.74,59.34 U1.H17
  03_SIG1 w0.173: v2(102.24,58.84) 102.24,58.43 102.15,58.34 95.44,58.34 95.44,58.34 95,58.34 94.39,58.95 ; 81.61,68.16 81.61,69.03 81.4,69.24 78.47,69.24 78.36,69.12 78.36,68.62 78.18,68.44 77.79,68.44 77.55,68.68 77.55,69 77.32,69.24 76.9,69.24 76.76,69.1 76.76,68.71 76.75,68.71 76.75,68.67 76.52,68.44 76.19,68.44 75.96,68.67 75.96,69.41 75.74,69.64 v4(75.56,69.64)
  03_SIG1 w0.262: 94.39,58.95 92.29,61.05 92.29,63.62 92.27,63.62 91.79,64.1 91.52,64.1 90.79,63.36 90.79,63.05 91.51,62.34 91.51,62.01 91.3,61.81 91,61.81 90.21,62.6 90.02,62.6 89.75,62.32 89.75,62.05 90.17,61.62 90.17,61.26 89.86,60.95 89.66,60.95 88.7,61.91 88.7,62.18 91.07,64.55 91.07,64.82 90.86,65.03 90.66,65.03 88.26,62.63 88.02,62.63 87.7,62.94 87.7,63.27 87.34,63.64 87.01,63.64 86.14,64.51 86.14,65.4 85.93,65.61 85.58,65.61 85.42,65.44 85.42,65.25 85.26,65.1 84.83,65.1 84.71,65.22 84.71,65.81 84.23,66.29 84.23,66.61 83.14,67.7 82.56,67.7 82.31,67.96 81.82,67.96 81.61,68.16
  BOTTOM w0.152: U61.H8 v4(75.56,69.64)
DDR4_C1_DQ22: length 54.4
  TOP w0.152: v2(102.24,60.84) U1.H19
  03_SIG1 w0.173: v4(74.76,65.64) U61.J3 74.36,62.93 74.5,62.79 ; 94.39,52.34 102.44,52.34 102.74,52.64 102.74,53.05 103.03,53.34 103.44,53.34 103.74,53.64 103.74,54.05 104.03,54.34 104.44,54.34 104.74,54.64 104.74,55.05 105.03,55.34 105.44,55.34 105.74,55.64 105.74,56.05 106.03,56.34 106.44,56.34 106.74,56.64 106.74,60.05 106.44,60.34 106.03,60.34 105.74,60.64 105.74,62.06 105.45,62.34 103.03,62.34 102.74,62.05 U1.H19 v2(102.24,60.84)
  03_SIG1 w0.262: 74.5,62.79 79.82,57.47 81.53,57.47 82.43,56.56 83.11,56.56 84.27,55.41 85.76,55.41 88.83,52.34 94.39,52.34
  BOTTOM w0.152: U61.J3 v4(74.76,65.64)
DDR4_C1_DQ23: length 53.8
  TOP w0.152: v2(102.24,59.84) U1.H18
  03_SIG1 w0.173: 94.39,60.79 94.83,60.34 101.47,60.34 101.97,59.84 v2(102.24,59.84) ; 74.36,71.17 74.36,68.67 74.76,68.27 v4(74.76,68.04) ; 78.46,71.17 78.61,71.02 81.35,71.02 81.61,70.75
  03_SIG1 w0.262: 81.61,70.75 82.59,69.77 83.11,69.77 84.13,68.76 85.81,68.76 86.9,69.85 87.92,69.85 93.65,64.12 93.65,61.52 94.39,60.79 ; 74.36,71.17 74.36,71.38 73.85,71.88 71.65,71.88 71.48,72.06 71.48,73.31 71.66,73.49 73.04,73.49 73.18,73.35 73.18,72.67 73.33,72.53 73.71,72.53 73.84,72.66 73.84,73.35 73.98,73.49 75.45,73.49 75.59,73.35 75.59,72.16 75.75,72.01 76.17,72.01 76.31,72.15 76.31,72.96 76.45,73.1 77.09,73.1 77.26,72.93 77.26,72.17 76.72,71.64 76.72,71.44 76.92,71.24 77.3,71.24 77.77,71.7 77.93,71.7 78.46,71.17
  BOTTOM w0.152: U61.J7 v4(74.76,68.04)
DDR4_C1_DQ24: length 41
  TOP w0.152: v2(100.24,60.84) U1.F19
  07_SIG3 w0.173: v2(100.24,60.84) 100.24,60.65 100.74,60.15 100.74,58.64 101.03,58.34 101.44,58.34 101.74,58.05 101.74,57.64 101.44,57.34 101.03,57.34 100.74,57.05 100.74,56.54 100.48,56.29 99.95,56.29 99.76,56.11 99.76,55.64 99.47,55.34 95.04,55.34 94.39,54.69 ; 80.76,62.79 U61.A3 v4(81.16,65.64)
  07_SIG3 w0.262: 94.39,54.69 93.73,54.03 86.13,54.03 85.77,54.39 84.18,54.39 83.16,55.42 82.55,55.42 82.35,55.62 82.35,56.82 80.76,58.41 80.76,58.83 80.9,58.97 81.45,58.97 81.59,59.11 81.59,59.39 81.45,59.53 80.9,59.53 80.76,59.67 80.76,59.95 80.9,60.09 81.45,60.09 81.59,60.23 81.59,60.51 81.45,60.65 80.9,60.65 80.76,60.79 80.76,62.79
  BOTTOM w0.152: U61.A3 v4(81.16,65.64)
DDR4_C1_DQ25: length 40
  TOP w0.152: v2(100.24,59.84) U1.F18
  07_SIG3 w0.173: 94.39,60.34 100.07,60.34 100.24,60.18 v2(100.24,59.84) ; 81.61,69.93 81.5,70.04 80.99,70.04 80.59,69.64 v4(80.36,69.64)
  07_SIG3 w0.262: 81.61,69.93 82.1,69.43 82.95,69.43 83.13,69.25 83.13,68.74 83.64,68.24 83.64,68.16 85.47,66.32 85.47,64.03 86.59,62.92 86.59,60.11 87.09,59.6 87.45,59.6 87.59,59.74 87.59,60.54 87.74,60.69 88.02,60.69 88.15,60.55 88.15,59.74 88.29,59.6 88.57,59.6 88.71,59.74 88.71,60.54 88.85,60.69 89.13,60.69 89.27,60.55 89.27,59.74 89.41,59.6 89.69,59.6 89.83,59.74 89.83,60.54 89.97,60.69 90.25,60.69 90.39,60.55 90.39,59.74 90.53,59.6 90.8,59.6 90.94,59.74 90.94,60.54 91.09,60.69 91.37,60.69 91.5,60.55 91.5,59.74 91.64,59.6 91.92,59.6 92.06,59.74 92.06,60.54 92.21,60.69 92.49,60.69 92.62,60.55 92.62,59.55 92.77,59.4 93.04,59.4 93.22,59.58 93.22,60.55 93.35,60.68 93.77,60.68 94.1,60.34 94.39,60.34
  BOTTOM w0.152: U61.B8 v4(80.36,69.64)
DDR4_C1_DQ26: length 40.3
  TOP w0.152: v2(99.24,60.84) U1.E19
  07_SIG3 w0.173: 81.61,70.84 80.99,70.84 80.76,70.6 80.76,70.27 80.52,70.04 80.19,70.04 79.96,69.8 79.96,69.47 79.72,69.24 78.59,69.24 78.36,69 78.36,66.3 78.56,66.09 79.1,66.09 v4(79.56,65.64) ; 94.39,61.34 98.74,61.34 v2(99.24,60.84)
  07_SIG3 w0.262: 81.61,70.84 81.62,70.84 82.36,70.09 83.57,70.09 83.83,69.83 83.83,68.97 84.52,68.27 84.52,68.18 85.34,67.36 85.85,67.36 86.13,67.08 86.13,64.29 87.25,63.17 87.25,61.49 87.4,61.34 87.67,61.34 87.81,61.48 87.81,61.82 87.95,61.96 88.22,61.96 88.36,61.82 88.36,61.48 88.5,61.34 88.78,61.34 88.92,61.48 88.92,61.82 89.06,61.96 89.34,61.96 89.48,61.82 89.48,61.48 89.62,61.34 89.9,61.34 90.04,61.48 90.04,61.82 90.18,61.96 90.46,61.96 90.6,61.82 90.6,61.48 90.74,61.34 91.02,61.34 91.16,61.48 91.16,61.82 91.3,61.96 91.58,61.96 91.72,61.82 91.72,61.48 91.86,61.34 92.14,61.34 92.28,61.48 92.28,61.82 92.42,61.96 92.7,61.96 92.84,61.82 92.84,61.48 92.97,61.34 93.25,61.34 93.39,61.48 93.39,61.82 93.53,61.96 93.81,61.96 93.95,61.82 93.95,61.48 94.09,61.34 94.39,61.34
  BOTTOM w0.152: U61.C3 v4(79.56,65.64)
DDR4_C1_DQ27: length 40
  TOP w0.152: v2(99.24,59.84) U1.E18
  07_SIG3 w0.173: 81.61,69.01 81.39,69.24 80.19,69.24 79.96,69 79.96,68.67 79.56,68.27 v4(79.56,68.04) ; v2(99.24,59.84) 99.24,59.52 99.06,59.34 94.39,59.34
  07_SIG3 w0.262: 94.39,59.34 94.09,59.34 92.78,58.03 92.58,58.03 92.44,58.17 92.44,58.8 92.3,58.94 92.02,58.94 91.88,58.8 91.88,58.15 91.72,58 91.46,58 91.32,58.14 91.32,58.8 91.18,58.94 90.9,58.94 90.76,58.8 90.76,58.15 90.61,58 90.34,58 90.2,58.14 90.2,58.8 90.06,58.94 89.78,58.94 89.64,58.8 89.64,58.15 89.49,58 89.23,58 89.09,58.14 89.09,58.8 88.95,58.94 88.67,58.94 88.53,58.8 88.53,58.15 88.37,58 88.11,58 87.97,58.14 87.97,58.8 87.83,58.94 87.55,58.94 87.41,58.8 87.41,58.15 87.25,58 86.83,58 86.64,58.18 86.64,58.85 86.51,58.97 86.51,59.23 85.93,59.82 85.93,62.48 85.67,62.74 85.17,62.74 84.77,63.14 84.77,64.16 84.16,64.77 84.16,65.11 84.39,65.34 84.58,65.34 84.81,65.57 84.81,65.9 84.58,66.13 84.39,66.13 84.16,66.36 84.16,66.72 83.18,67.69 82.56,67.69 82.19,68.06 82.19,68.6 82,68.79 81.83,68.79 81.61,69.01
  BOTTOM w0.152: U61.C7 v4(79.56,68.04)
DDR4_C1_DQ28: length 40.7
  TOP w0.152: v2(101.24,61.84) U1.G20
  07_SIG3 w0.173: 94.39,53.73 95,54.34 99.42,54.34 99.77,54.7 99.77,55.13 99.98,55.33 100.58,55.33 100.77,55.52 100.77,56.09 101.01,56.33 101.49,56.33 101.74,56.58 101.74,57.05 102.03,57.34 102.44,57.34 102.74,57.64 102.74,58.05 102.44,58.34 102.03,58.34 101.74,58.64 101.74,61.34 v2(101.24,61.84) ; 79.96,62.79 79.96,63.64 v4(79.56,64.04)
  07_SIG3 w0.262: 94.39,53.73 93.98,53.33 86.65,53.33 86.5,53.17 83.61,53.17 81.69,55.1 81.69,56.57 79.96,58.3 79.96,62.79
  BOTTOM w0.152: U61.C2 v4(79.56,64.04)
DDR4_C1_DQ29: length 40.2
  TOP w0.152: v2(100.24,61.84) U1.F20
  07_SIG3 w0.173: 80.62,71.17 80.53,71.17 79.96,70.6 79.96,70.27 79.56,69.87 v4(79.56,69.64) ; 94.39,62.41 94.46,62.34 99.38,62.34 99.88,61.84 v2(100.24,61.84)
  07_SIG3 w0.262: 94.39,62.41 94.19,62.61 93.81,62.61 93.68,62.74 93.68,63.56 93.54,63.7 93.26,63.7 93.12,63.56 93.12,62.75 92.98,62.61 92.7,62.61 92.56,62.75 92.56,63.56 92.42,63.7 92.14,63.7 92,63.56 92,62.75 91.86,62.61 91.59,62.61 91.45,62.75 91.45,63.56 91.31,63.7 91.03,63.7 90.89,63.56 90.89,62.75 90.75,62.61 88.14,62.61 87.91,62.84 87.91,63.12 88.16,63.37 88.16,63.43 90.04,63.43 90.27,63.67 90.27,66.32 89.1,67.49 86.75,67.49 86.64,67.6 86.64,68.45 86.36,68.73 85.03,68.73 84.62,69.14 84.62,70.28 84.16,70.74 82.63,70.74 81.87,71.49 80.94,71.49 80.62,71.17
  BOTTOM w0.152: U61.C8 v4(79.56,69.64)
DDR4_C1_DQ30: length 38.3
  TOP w0.152: U1.E17 99.74,59.34 v2(99.24,58.84)
  07_SIG3 w0.173: 94.39,55.92 94.81,56.34 99.51,56.34 99.74,56.57 99.74,57 100.04,57.3 100.4,57.3 100.74,57.64 100.74,58.05 100.44,58.34 99.74,58.34 v2(99.24,58.84) ; 81.61,62.79 81.61,65.76 81.23,66.14 80.08,66.14 79.96,66.02 79.96,65.36 79.83,65.24 79.16,65.24 v4(78.76,65.64)
  07_SIG3 w0.262: 94.39,55.92 93.17,54.7 86.4,54.7 85.71,55.4 84.35,55.4 83.52,56.24 83.52,57.45 83.19,57.78 82.33,57.78 81.92,58.19 81.92,58.39 82.06,58.53 82.14,58.53 82.27,58.66 82.27,60.9 82.14,61.02 81.8,61.02 81.43,61.39 81.43,62.46 81.61,62.64 81.61,62.79
  BOTTOM w0.152: U61.D3 v4(78.76,65.64)
DDR4_C1_DQ31: length 37
  TOP w0.152: U1.D16 98.74,58.34 v2(98.24,57.84)
  07_SIG3 w0.173: 81.61,67.62 81.61,67.69 81.56,67.74 81.56,68.2 81.32,68.44 80.19,68.44 79.96,68.2 79.96,66.49 79.78,66.31 79.67,66.31 79.55,66.43 79.55,67.53 79.46,67.62 79.26,67.62 79.17,67.53 79.17,66.56 79.08,66.47 78.88,66.47 78.76,66.59 v4(78.76,68.04) ; 94.39,58.34 98.11,58.34 98.24,58.22 v2(98.24,57.84)
  07_SIG3 w0.262: 81.61,67.62 82.72,66.51 83.22,66.51 83.51,66.22 83.51,64.47 84.08,63.91 84.08,62.91 84.67,62.32 84.67,59.16 84.91,58.92 85.66,58.92 85.93,58.64 85.93,57.43 86.45,56.9 86.82,56.9 87.27,57.35 91.86,57.35 92.25,56.96 92.62,56.96 94,58.34 94.39,58.34
  BOTTOM w0.152: U61.D7 v4(78.76,68.04)
DDR4_C1_DQ32: length 61
  TOP w0.152: U1.D17 98.74,59.34 v2(98.24,58.84)
  05_SIG2 w0.173: 76.76,90.98 76.76,91.83 v4(76.36,92.23) ; 94.39,57.95 95,57.34 97.44,57.34 97.74,57.64 97.74,58.06 98.24,58.56 v2(98.24,58.84)
  05_SIG2 w0.262: 94.39,57.95 89.55,62.79 86.71,62.79 85.58,63.92 84.29,63.92 84.09,64.12 84.09,66.08 83.92,66.24 83.69,66.24 83.53,66.08 83.53,64.12 83.39,63.98 82.53,63.98 82.22,64.29 82.22,68.64 82.44,68.87 82.7,68.87 82.84,69 82.84,69.28 82.7,69.42 82.44,69.42 82.3,69.56 82.3,69.84 82.44,69.98 82.7,69.98 82.84,70.12 82.84,70.4 82.7,70.54 82.44,70.54 82.27,70.72 82.27,71.05 81.31,72 81.31,74.82 82.3,75.81 82.3,85.44 82.14,85.6 77.67,85.6 76.46,86.81 76.46,90.47 76.76,90.77 76.76,90.98
  BOTTOM w0.152: U62.G2 v4(76.36,92.23)
DDR4_C1_DQ33: length 60.8
  TOP w0.152: v2(97.24,58.84) 97.74,59.34 U1.C17
  05_SIG2 w0.173: 94.39,65.04 94.41,65.07 94.59,65.07 94.79,64.88 94.79,62.59 95.03,62.34 95.44,62.34 95.74,62.05 95.74,61.64 96.03,61.34 96.56,61.34 96.74,61.17 96.74,59.34 v2(97.24,58.84) ; 81.61,96.34 81.32,96.63 77.78,96.63 77.56,96.4 77.56,95.52 77.35,95.31 76.52,95.31 76.39,95.45 76.39,95.66 76.51,95.78 76.84,95.78 76.94,95.88 76.94,96.01 v4(77.16,96.23)
  05_SIG2 w0.262: 94.39,65.04 94.21,64.87 94.01,64.87 93.81,65.06 93.81,65.26 94.09,65.54 94.09,65.74 93.89,65.93 93.7,65.93 93.42,65.66 93.22,65.66 93.02,65.85 93.02,66.05 93.3,66.33 93.3,66.53 93.1,66.72 92.91,66.72 92.66,66.48 92.47,66.48 92.27,66.68 92.27,66.88 92.51,67.12 92.51,67.32 92.31,67.52 92.12,67.52 91.9,67.3 91.7,67.3 91.5,67.5 91.5,67.69 91.72,67.91 91.72,68.11 91.52,68.31 91.33,68.31 91.1,68.08 90.9,68.08 90.71,68.28 90.71,68.48 90.93,68.7 90.93,68.9 90.73,69.1 90.54,69.1 90.31,68.87 90.11,68.87 89.45,69.53 86.88,69.53 86.62,69.79 86.62,88.63 85.99,89.27 85.02,89.27 84.59,89.69 84.59,90.76 83.45,91.9 83.45,94.5 81.61,96.34
  BOTTOM w0.152: U62.F7 v4(77.16,96.23)
DDR4_C1_DQ34: length 61.9
  TOP w0.152: U1.C19 v2(97.24,60.84)
  05_SIG2 w0.173: v2(97.24,60.84) 97.74,60.34 97.74,59.64 98.03,59.34 98.44,59.34 98.74,59.05 98.74,57.64 98.44,57.34 98.03,57.34 97.74,57.05 97.74,56.64 97.44,56.34 95.03,56.34 94.39,56.99 ; v4(75.56,93.83) 75.56,93.6 75.96,93.2 75.96,90.98
  05_SIG2 w0.262: 94.39,56.99 89.27,62.1 86.32,62.1 85.77,62.66 82.74,62.66 81.61,63.78 81.61,70.64 80.85,71.4 80.85,75.53 81.65,76.34 81.65,84.84 81.47,85.02 77.49,85.02 75.96,86.55 75.96,90.98
  BOTTOM w0.152: U62.H3 v4(75.56,93.83)
